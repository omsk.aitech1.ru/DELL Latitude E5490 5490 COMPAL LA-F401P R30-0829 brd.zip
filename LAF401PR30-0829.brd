# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 21.8
  TOP w0.127: CA2.2 313.43,31.82 v3(313.95,31.82) v3(313.95,30.09) ; v3(313.44,41.8) v1(313.15,41.32)
  TOP w0.203: UA1.38 301.4,38.77 302.02,39.39 v1(302.52,39.39)
  TOP w0.254: CA57.2 301.99,40.7 v1(302.07,40.79)
  TOP w0.381: v1(302.07,40.79) 302.2,40.79 CA58.2
  TOP w0.508: CA25.2 301.44,29.42 v1(301.25,29.61) ; DA2.2 v1(311.46,31.97) ; RA37.1 v1(295.15,29.04) ; CA2.2 v1(311.94,32.63) ; CA41.2 v1(296.22,29.91)
  VCC w0.203: 316.45,28.23 JHP1.5 ; JHP1.5 315.37,28.23 ; JHP1.5 317.53,28.23 ; JHP1.7 320.18,39.07 ; JHP1.7 318.02,39.07 ; JHP1.7 319.1,39.07
  BOTTOM w0.457: v1(313.15,41.32) 312.88,41.05 CA4.2 312.89,40.29 CA1.1
  BOTTOM w0.508: CA3.2 312.27,33.9 v1(312.55,34.18)
  vias: v1(303.54,32.02) v1(304.93,31.96) v1(305.82,40.89) v1(319.28,39.26)
VBAT1_ISL9538: length 4
  TOP w0.203: PR940.2 PC950.2 v2(20.08,13.31) 19.45,13.95 PU901.31
VBUS1_ECOK: length 433.5
  TOP w0.102: v1(309.31,76.79) 308.05,76.79 307.15,75.89 305.62,75.89 305.3,75.57 304.72,75.57 UE1.M6 ; PR1220.1 PR1222.1 16.21,39.85 17.66,41.29 22.87,41.29 v2(24.14,42.56) v1(26.55,42.56) 28.47,42.56 PR1257.1
  IN1 w0.089: v1(218.55,17.99) 219.25,18.69 221.19,18.69 221.25,18.62 222.43,18.62 223.2,19.39 229.04,19.39 232.64,22.99 241.97,22.99 243.32,24.33 251.2,24.33 251.28,24.41 251.28,24.41 253.46,26.59 255.22,26.59 258.88,30.24 280.98,30.24 281.8,31.07 283.52,31.07 286.4,33.95 286.4,34.61 290.15,38.36 290.15,39.25 290.59,39.69 292.22,39.69 296.43,43.89 297.17,43.89 297.83,44.55 297.83,45.98 299.29,47.44 299.29,48.46 299.72,48.88 301.22,48.88 302.39,50.06 303.46,50.06 303.66,50.26 303.66,51.89 304.86,53.09 304.86,54.88 304.3,55.44 304.3,58.23 303.85,58.68 303.85,60.1 305.38,61.62 305.38,62.64 306.39,63.66 306.39,64.53 307.62,65.76 308.81,65.76 309.36,66.31 310.76,66.31 311.66,67.22 311.66,67.52 312.36,68.22 312.36,73.3 310.52,75.14 310.52,76.15 309.89,76.79 v1(309.31,76.79)
  IN2 w0.122: v1(26.55,42.56) 25.35,43.76 25.35,47.31 23.39,49.28 23.39,54.09 33.14,63.84 33.14,64.5 39.1,70.45 39.1,72.7 42.28,75.88 42.28,77 45.05,79.77 49.64,79.77 54.89,85.03 55.04,85.03 56.42,86.41 57.69,86.41 59.9,88.62 62.37,88.62 65.07,91.31 67.37,91.31 68.78,92.73 72.27,92.73 73.16,91.84 87.33,91.84 88.09,91.08 90.72,91.08 92.4,92.76 94.32,92.76 95.19,91.89 100.8,91.89 103.09,89.6 104.46,89.6 104.97,89.09 107.84,89.09 109.07,90.32 109.94,90.32 110.11,90.48 115.35,90.48 116.24,89.59 119.86,89.59 120.49,88.95 125.83,88.95 126.34,89.46 133.07,89.46 134.21,90.6 145.26,90.6 146.02,89.84 151.43,89.84 152.33,88.94 v1(152.33,86.7)
  IN3 w0.122: v1(218.55,17.99) 218.55,17.99 215.36,17.99 215.02,18.34 210.81,18.34 207.81,21.34 206.78,21.34 203.78,24.34 202.57,24.34 200.6,26.31 198.48,26.31 192.29,32.5 188.31,32.5 185.49,35.32 184.47,35.32 180.03,39.77 180.03,41.28 175.65,45.66 175.65,46.71 160.84,61.52 160.84,66.16 158.18,68.82 158.18,73.17 156.49,74.87 156.49,76.79 155.73,77.55 155.73,78.34 156.49,79.1 156.49,83.13 152.93,86.7 v1(152.33,86.7)
VBUS2_ECOK: length 441.4
  TOP w0.102: v1(306.2,73.22) 305.57,73.22 305.26,73.53 UE1.N3 ; PR1242.1 v1(29.65,34.8) 29.42,34.57 v2(29.42,34.28) ; v1(62.5,105.71) PR20.2 63.1,106.16 PR24.1
  IN1 w0.089: v1(62.5,105.71) 62.89,105.32 62.89,104.11 55.41,96.63 55.41,91.46 54.05,90.1 54.05,85.72 54.44,85.33 v1(54.44,83.43) ; v1(218.38,18.56) 218.74,18.92 221.43,18.92 221.53,18.82 222.24,18.82 223,19.58 228.87,19.58 233.22,23.94 238.53,23.94 240.71,26.12 250.33,26.12 251.79,27.57 254.16,27.57 257.14,30.55 258.16,30.55 258.91,31.3 283.48,31.3 286.21,34.03 286.21,34.69 289.91,38.39 289.91,39.28 290.51,39.88 291.38,39.88 292.12,40.62 292.12,41.22 293.01,42.12 293.55,42.12 294.65,43.22 294.65,43.64 294.84,43.84 295.71,43.84 295.95,44.08 297.09,44.08 297.64,44.63 297.64,46.07 299.09,47.52 299.09,48.53 299.63,49.07 301.14,49.07 302.86,50.79 302.86,51.45 303.47,52.06 303.57,52.06 304.67,53.16 304.67,54.8 304.11,55.36 304.11,58.09 303.28,58.92 303.28,60.05 304.15,60.93 304.15,61.56 304.95,62.35 304.95,63.53 305.88,64.46 306.05,64.46 307.54,65.95 308.67,65.95 311.33,68.61 311.33,70.51 310.08,71.75 310.08,74.37 309.38,75.08 308.06,75.08 v1(306.2,73.22)
  IN2 w0.122: v1(151.37,87.33) 150.82,87.33 150.59,87.56 150.59,88.01 149.2,89.39 145.84,89.39 145.17,90.06 143.01,90.06 142.37,89.43 138.71,89.43 138.03,88.74 136.14,88.74 135.9,88.98 129.9,88.98 129.22,88.31 126.12,88.31 125.93,88.51 120.1,88.51 119.69,88.92 109.59,88.92 109.31,88.65 104.79,88.65 104.28,89.15 102.91,89.15 102.51,89.55 99.19,89.55 98.49,88.85 91.98,88.85 90.64,90.19 88.22,90.19 87.08,91.33 68.14,91.33 67.62,90.81 65.2,90.81 62.56,88.17 61.23,88.17 58.6,85.53 57.51,85.53 56.36,84.39 54.92,84.39 54.44,83.9 v1(54.44,83.43) 48.15,77.14 46.47,77.14 33.63,64.31 33.63,62.92 26.71,55.99 26.71,53.04 26.08,52.41 26.08,50.86 27.62,49.32 27.62,47.84 28.33,47.14 28.33,36.12 v1(29.65,34.8)
  IN3 w0.122: v1(218.38,18.56) 218.03,18.21 215.46,18.21 215.11,18.56 210.9,18.56 207.9,21.56 206.87,21.56 203.87,24.56 202.66,24.56 200.69,26.53 198.57,26.53 192.38,32.72 188.41,32.72 185.55,35.58 184.54,35.58 180.25,39.86 180.25,41.43 175.87,45.81 175.87,46.8 161.09,61.58 161.09,66.24 158.4,68.92 158.4,73.27 156.71,74.96 156.71,83.29 152.68,87.33 v1(151.37,87.33)
VBUS3_ECOK: length 2.7
  TOP w0.102: UE1.F13 299.67,81.64 299.67,82.11 v1(299.22,82.57)
  BOTTOM w0.102: T264.1 300.03,81.76 v1(299.22,82.57)
VCC_GT: length 4.7
  TOP w0.102: PR680.2 57.33,62.32 v2(57.46,62.45)
  TOP w0.254: v1(56.44,60.56) 56.44,61.09 56.63,61.28 PR680.2
  BOTTOM w0.254: PU612.3 v1(56.44,60.56) 55.59,59.71 PC669.1
VCC_GT_SENSE: length 51.7
  TOP w0.203: PR648.1 PC653.1 62.24,50.96 PC651.2
  TOP w0.254: PC639.1 61.87,52.42 61.54,52.09 v1(61.54,51.96) 61.54,51.83 61.87,51.5 PC651.2
  IN1 w0.254: v1(93.25,64.24) 93.25,63.76 88.65,59.17 88.65,57.23 v1(88.52,57.1)
  IN3 w0.254: v1(88.52,57.1) 88.65,56.98 88.65,56.56 87.16,55.07 76.36,55.07 75.86,55.58 63.89,55.58 63.19,54.88 63.19,52.18 62.52,51.52 61.79,51.52 61.54,51.77 v1(61.54,51.96)
  BOTTOM w0.076: UC1.J70 97.46,64.83 97.19,64.56 95.95,64.56 95.66,64.27 95.55,64.27 95.52,64.24 95.44,64.24
  BOTTOM w0.254: 95.44,64.24 v1(93.25,64.24) 92.68,64.24 92.31,64.61 91.02,64.61 RC161.1
VCC_IA1: length 4.9
  TOP w0.127: v2(55.96,71.72) 57.17,71.72 PR688.2
  TOP w0.254: PR688.2 57.43,71.32 56.57,70.45 v1(56.57,70.03)
  BOTTOM w0.254: PC676.1 56.13,70.03 v1(56.57,70.03) PU610.3
VCC_IA2: length 4
  TOP w0.127: PR691.2 v2(63.05,74.87)
  TOP w0.254: PR691.2 63.46,76.24 v1(63.78,76.56)
  BOTTOM w0.254: PC677.1 63.39,76.95 v1(63.78,76.56) PU613.3
VCCDSW_EN: length 204.5
  TOP w0.102: v1(181.3,35.26) 181.59,35.55 181.59,36.19 181.75,36.35 RC445.1 182.06,36.68 181.67,37.08 v2(181.13,37.08)
  TOP w0.107: v1(304.76,76.33) UE1.M7
  IN2 w0.122: v1(304.76,76.33) 305.82,75.27 305.82,74.9 307.73,72.99 307.73,69.11 311.06,65.78 311.06,63.57 311.69,62.93 311.69,61.27 310.82,60.4 310.82,59.82 308.92,57.91 308.92,53.13 305,49.21 303.94,49.21 303.3,48.58 303.3,47.08 302.83,46.61 301.86,46.61 300.95,45.69 299.62,45.69 297.52,43.6 296.63,43.6 296.33,43.29 296.33,42.99 294.05,40.71 294.05,39.68 293.29,38.93 293.29,37.65 290.39,34.74 288.93,34.74 288.14,33.94 286.51,33.94 283.35,30.79 283.35,29.21 281.56,27.42 265.25,27.42 263.28,25.46 259.86,25.46 259,24.6 258.34,24.6 256.22,22.48 253.85,22.48 253.37,22.95 247.02,22.95 243.38,19.32 234.42,19.32 231.83,16.73 231.83,13.71 227.81,9.69 227.33,9.69 226.32,8.68 220.22,8.68 218.78,10.12 213.41,10.12 211.49,8.2 206.46,8.2 204.84,9.82 204.84,10.22 203.69,11.38 197.7,11.38 193.11,15.97 193.11,16.8 188.24,21.67 184.82,21.67 v1(184.52,21.38)
  IN4 w0.089: v1(184.52,21.38) 184.52,22.03 184.05,22.5 184.05,25.17 179.75,29.47 179.75,33.71 v1(181.3,35.26)
  BOTTOM w0.102: CE66.1 304.76,75.45 v1(304.76,76.33)
VCCDSW_EN_GPIO: length 4.7
  TOP w0.102: v2(182.99,33.6) 183.37,33.98 DC1.2 182.73,34.75 182.55,34.57 RC431.1 ; RC431.1 181.59,34.57 181.55,34.61 QC6.2 ; RC431.1 RC445.2
VCCDSW_EN_Q: length 4.4
  TOP w0.102: v2(184.49,37.25) 185.07,36.67 DC2.2 DC1.1 185.03,34.75 RC442.1
VCCIO_SENSE: length 166.5
  TOP w0.254: RC165.1 122.63,53.8 v1(123.37,53.06) ; v1(146.28,108.76) 145.75,108.76 PR422.2
  IN1 w0.089: v1(123.37,53.06) 123.37,53.05 123.83,52.6 123.83,51.69 124.72,50.8 124.72,49.68 125.28,49.12 127.18,49.12 128.27,48.03 128.27,47.66
  IN1 w0.254: v1(185.16,54.98) 184.6,54.98 174.49,65.09 174.49,74.95 150.9,98.54 150.9,101.47 147.55,104.83 147.55,107.75 146.54,108.76 v1(146.28,108.76) ; v1(160.28,27.83) 160.02,28.09 153.33,28.09 151.63,29.8 145.05,29.8 141.36,33.49 141.36,35.01 141.14,35.22 141.14,37.57 140.39,38.32 140.11,38.32 139.02,39.41 137.35,39.41 132.16,44.6 129.64,44.6 128.27,45.96 128.27,47.66
  BOTTOM w0.254: v1(185.16,54.98) 185.33,54.81 185.33,54.08 183.04,51.79 183.04,49 172.04,38 172.04,32.74 167.61,28.31 160.77,28.31 v1(160.28,27.83) ; v1(123.37,53.06) 123.77,53.45 UC1.AM23
VCCSA_B+: length 1.5
  TOP w0.127: v1(70.87,87.33) 71.01,87.33 v2(71.4,87.73)
  TOP w0.508: PC612.1 v1(70.87,87.33)
VCCSENSE: length 83.9
  TOP w0.254: v1(68.89,58.18) 69.06,58.01 69.38,58.01 PC617.1 69.54,57 PR622.1 v2(68.59,56.99) 68.46,56.86 68.46,56.22 PC620.1
  IN1 w0.254: v1(68.89,58.18) 68.78,58.29 68.78,58.63 69.28,59.14 70.17,59.14 75.95,64.92 75.95,72.5 82.4,78.95 87.48,78.95 91.44,82.91 99.51,82.91 100.02,82.4 100.82,82.4 102.08,81.14 103.69,81.14 108.01,76.83 112.64,76.83 114.24,75.23 v1(114.54,75.23) 114.99,75.23 116.17,74.05 116.17,70.48 116.61,70.04 116.99,70.04 117.3,70.35 117.3,70.91 v1(117.18,71.02)
  BOTTOM w0.076: UC1.E32 118.77,67.48 118.77,67.94 118.84,68 118.84,68.24 118.76,68.31 118.76,68.52 118.83,68.59 118.83,68.86 118.78,68.91 118.78,70.03
  BOTTOM w0.254: PC618.2 69.27,57.8 v1(68.89,58.18) ; v1(114.54,75.23) 114.54,75.22 114.18,75.22 113.49,75.91 113.49,76.54 RC140.1 ; 118.78,70.03 118.78,70.11 118.12,70.77 117.44,70.77 v1(117.18,71.02)
VCCST_PWRGD: length 368.8
  TOP w0.102: v1(98.69,81.26) 99.64,81.26 100.77,82.39 103.29,82.39 105.83,79.85 107.79,79.85 108.75,80.8 110.1,80.8 112.45,83.15 112.45,84.46 114.99,87 116.09,87 117.7,88.61 121.6,88.61 122.05,88.17 125.91,88.17 131.13,93.39 140.65,93.39 141.33,92.7 144.23,92.7 144.91,93.39 145.91,93.39 v2(146.79,94.27) 148.62,96.09 v1(148.66,96.09) ; RC123.1 68.04,39.36 v1(68.04,40.05) ; RE308.1 306.39,87.71 306.39,88.6 v1(306.08,88.92) ; v1(288.53,85.27) 288.63,85.16 290.39,85.16 290.95,85.73 UE4.4
  IN4 w0.089: v1(148.66,96.09) 156.89,96.09 174.57,78.42 174.57,59.24 179.89,53.92 181.08,53.92 184.26,50.74 192,50.74 198.58,44.16 198.58,44.14 202.28,40.44 204.98,40.44 212.31,33.1 217.37,33.1 218.64,34.37 236.22,34.37 240.23,30.36 247.29,30.36 251.76,34.83 251.89,34.83 257.35,40.29 257.35,40.69 259.28,42.63 259.81,42.63 262.82,45.64 262.82,46.04 263.33,46.55 263.63,46.55 263.91,46.83 263.91,47.31 264.15,47.54 264.71,47.54 265.7,48.53 265.7,49.46 269.96,53.72 269.96,54.24 272.74,57.02 272.74,61.8 271.64,62.91 271.64,63.69 270.16,65.17 270.16,70.46 270.53,70.83 270.53,80.03 274.24,83.75 274.84,83.75 275.81,84.72 275.81,87.21 276.57,87.97 281.19,87.97 281.79,87.37 284.05,87.37 284.63,86.78 287.01,86.78 v1(288.53,85.27) 294.72,91.46 303.08,91.46 303.35,91.19 304.77,91.19 304.91,91.05 304.91,90.09 v1(306.08,88.92) ; v1(96.22,74.56) 95.11,73.45 94.47,73.45 89.35,68.33 89.35,66.96 87.02,64.63 87.02,63.42 85.18,61.58 85.18,61.08 82.46,58.35 82.46,55.8 76.74,50.07 76.74,46.24 76,45.51 75.09,45.51 70.11,40.53 68.52,40.53 v1(68.04,40.05)
  BOTTOM w0.102: v1(98.69,81.26) 98.2,80.77 98.2,79.31 97.89,79 RC71.1 97.34,78.67 97.34,77.35 RC78.1 CC301.1 97.08,76.69 97.08,75.07 96.58,74.56 v1(96.22,74.56)
VCCST_PWRGD_CPU: length 10.5
  BOTTOM w0.076: 99.34,72.62 99.64,72.32 99.64,71.69 100.69,70.64 100.69,70.06 100.91,69.84 100.91,69.37 UC1.B65
  BOTTOM w0.102: RC78.2 97.41,76.05 v2(97.41,75.3) 97.41,75.13 96.61,74.33 96.61,73.48 97.22,72.88 99.08,72.88 99.34,72.62
VCCST_PWRGD_EC: length 215.2
  TOP w0.102: v1(305.94,85.86) 306.6,86.52 RE308.2 v2(307.6,86.52) ; v1(210.7,27.48) 211,27.17 211,24.28 209.76,23.04 209.76,14.56 210.55,13.77 v1(210.55,12.92) ; v1(178.82,22.01) 178.82,19.65 177.78,18.61 177.78,13.51 RE552.2
  TOP w0.107: UE1.K10 303.14,79.5 303.16,79.5 v1(303.16,79.51)
  IN1 w0.089: v1(178.82,22.01) 179.17,22.36 179.61,22.36 180.01,21.96 187.93,21.96 196.55,13.34 200.32,13.34 201.53,14.55 206.07,14.55 207.92,12.71 210.33,12.71 v1(210.55,12.92)
  IN3 w0.122: v1(210.7,27.48) 211.13,27.04 211.49,27.04 211.89,27.45 220.84,27.45 221.74,26.55 227.92,26.55 228.69,27.32 238.51,27.32 242.75,31.56 247.2,31.56 248.76,33.12 257.15,33.12 258.94,34.91 268.1,34.91 268.77,35.58 270.66,35.58 271.9,36.82 276.72,36.82 278.05,38.15 278.33,38.15 279.51,39.33 279.51,40.99 280.18,41.66 280.18,44.63 283.31,47.76 283.92,47.76 286.74,50.58 286.74,51.1 287.36,51.73 287.36,52.89 288.42,53.95 289.52,53.95 289.76,54.19 290.33,54.19 290.56,54.42 290.56,55.02 291,55.46 291.63,55.46 291.79,55.62 291.79,56.29 292.77,57.27 292.77,59.38 292.29,59.86 292.29,63.31 292.92,63.93 292.92,65.71 291.54,67.08 291.54,70.74 292.8,72 292.8,73.55 293.78,74.53 293.78,76.03 294.85,77.1 299.85,77.1 300.51,77.77 300.51,79.71 300.49,79.73 300.49,79.73 300.14,80.08 299.6,80.08 298.68,80.99 298.68,81.3 298.96,81.58 299.7,81.58 300.13,82.01 303.84,82.01 304.45,82.62 304.45,83.69 305.94,85.18 v1(305.94,85.86)
  BOTTOM w0.102: v1(303.16,79.51) 303.58,79.93 304.2,79.93 304.63,80.36 304.63,83.89 305.94,85.2 v1(305.94,85.86)
VCCSTG_EN: length 162
  TOP w0.102: v1(131.68,80.16) 132.62,79.22 137.06,79.22 137.25,79.02 139.76,79.02 141.52,77.26 145.8,77.26 148.46,79.3 153.29,79.3 154.14,78.46 154.14,77.85 157.1,74.88 157.1,71.44 162.66,65.88 164.21,65.88 173.41,56.68 173.41,48.52 183.12,38.82 184.54,38.82 186,37.36 186,31.32 184.41,29.74 183.52,29.74 182.91,29.13 182.91,28.03 178.77,23.89 177.31,23.89 176.82,23.4 169.24,23.4 167.38,25.27 155.94,25.27 153.88,27.32 149.03,27.32 147.38,25.67 138,25.67 134.95,28.72 132.09,28.72 130.88,29.92 RZ120.1
  IN1 w0.254: v1(131.68,80.16) 133.6,82.08 135.53,82.08 v1(137.17,83.71)
  BOTTOM w0.254: UZ19.4 129.88,81.11 v2(130.54,80.45) 130.71,80.28 131.55,80.28 v1(131.68,80.16) RZ320.2 ; UZ35.4 137.17,84.12 v1(137.17,83.71)
VDD_ISL9538: length 10.1
  TOP w0.203: PU901.18 15.72,17.96 15.56,18.12
  TOP w0.254: 15.56,18.12 v2(15.22,18.46) 15.03,18.65 v1(14.24,18.65) 13.29,18.65 PR919.1
  BOTTOM w0.254: PR915.2 14.4,18.81 v1(14.24,18.65) 14.2,18.69 PC933.1 PR918.2
VDDP_ISL9538: length 5.4
  TOP w0.102: v1(21.02,18.8) 22.53,20.31 v2(23.2,20.31)
  TOP w0.203: v1(21.02,18.8) 21.02,18.56 20.82,18.36 PU901.8
  BOTTOM w0.254: v1(21.02,18.8) 21.01,18.81 PR915.1 20.33,18.8 PC932.2
VIN_1V_PRIM: length 0.8
  TOP w0.102: 133.1,117.67 133.1,118.03 v2(132.8,118.33)
VIN_1VS_VCCIO:
  vias: v2(139.13,112.48)
VSS_GT_SENSE: length 56.6
  TOP w0.203: PU602.18 63.59,49.18 PC653.2 62.73,50.06 PC654.2
  TOP w0.254: PC654.2 61.87,50.36 v1(61.54,50.69)
  IN1 w0.254: v1(89.16,57.1) 89.03,57.23 89.03,59.01 93.79,63.77 93.79,64.53 93.49,64.84 v1(92.84,64.84)
  IN3 w0.254: v1(89.16,57.1) 89.03,56.98 89.03,56.41 87.32,54.69 76.21,54.69 75.7,55.2 64.04,55.2 63.57,54.72 63.57,52.02 62.68,51.14 61.98,51.14 v1(61.54,50.69)
  BOTTOM w0.076: UC1.J69 98.06,64.83 97.77,65.12 97.4,65.12 97.26,65.04 97.05,65.04 96.92,65.11 96.68,65.11 96.31,64.74 95.3,64.74 95.29,64.75
  BOTTOM w0.254: RC163.1 91.18,65.12 v2(91.88,65.12) 92.59,65.12 92.84,64.86 v1(92.84,64.84) 92.93,64.75 95.29,64.75
VSSIO_SENSE: length 168.3
  TOP w0.254: PR412.2 145.75,109.39 v1(146.28,109.39) ; v1(124.29,53.06) 123.58,53.77 RC167.1
  IN1 w0.089: 128.8,47.69 128.8,48.01 127.34,49.47 126.06,49.47 125.74,49.8 125.74,53.36 125.61,53.49 124.71,53.49 v1(124.29,53.06)
  IN1 w0.254: v1(185.89,55.01) 185.42,55.48 184.81,55.48 175,65.3 175,75.17 151.41,98.75 151.41,101.68 148.06,105.04 148.06,107.97 146.64,109.39 v1(146.28,109.39) ; v1(161.04,27.79) 160.23,28.6 153.54,28.6 151.84,30.31 145.26,30.31 141.86,33.71 141.86,35.22 141.65,35.43 141.65,37.78 140.61,38.82 140.32,38.82 139.23,39.92 137.56,39.92 132.37,45.1 129.85,45.1 128.8,46.15 128.8,47.69
  BOTTOM w0.254: v1(161.04,27.79) 161.06,27.81 167.82,27.81 172.55,32.53 172.55,37.79 183.55,48.79 183.55,51.58 185.84,53.87 185.84,54.93 185.89,54.99 v1(185.89,55.01) ; v1(124.29,53.06) 124.68,53.45 UC1.AM22
VSSSENSE: length 84.9
  TOP w0.203: v1(68.46,54.37) 68.56,54.27 PU602.6
  TOP w0.254: v1(68.27,58.18) 68.27,57.43 68.01,57.18 68.01,55.39 68.28,55.12 PC620.2 68.46,54.94 v1(68.46,54.37)
  IN1 w0.254: v1(116.81,70.55) 116.55,70.82 116.55,74.21 116.55,74.22 116.55,74.22 114.93,75.85 v1(114.54,75.85) 114.16,75.85 112.8,77.21 108.16,77.21 103.85,81.52 102.24,81.52 100.98,82.78 100.18,82.78 99.67,83.29 91.28,83.29 87.32,79.33 82.24,79.33 75.57,72.66 75.57,65.07 70.01,59.52 69.13,59.52 68.39,58.79 68.39,58.31 v1(68.27,58.18)
  BOTTOM w0.076: 118.33,69.4 118.33,69.04 118.21,68.93 118.21,68.63 118.27,68.57 118.27,68.26 118.2,68.2 118.2,67.93 118.34,67.79 UC1.E33
  BOTTOM w0.203: PC619.2 69.52,54.9 69.2,54.58 68.66,54.58 v1(68.46,54.37)
  BOTTOM w0.254: 118.33,69.4 118.33,69.89 117.87,70.35 117.02,70.35 v1(116.81,70.55) ; v1(114.54,75.85) 114.27,75.85 114,76.12 114,76.58 RC141.1
32KHZ_OUT: length 10.3
  TOP w0.102: CE54.1 298.07,64.53 v1(298.21,64.67)
  TOP w0.107: v1(299.16,73.13) UE1.F3
  BOTTOM w0.102: v1(299.16,73.13) 299.17,73.12 v2(299.17,68.7) 299.17,67.62 298.21,66.67 v1(298.21,64.67)
+AC_IN: length 7.8
  TOP w0.102: PR1255.1 13.98,49.22 v2(14.61,48.58)
  TOP w0.508: 6.42,54.25 4.87,55.8 3.53,55.8 3.17,55.44 PR1251.1 2.66,54.5 PQ1215.3
+BL_PWR_SRC: length 4.2
  TOP w0.102: v3(107.87,84.35) v1(108.56,84.35) ; v1(108.56,84.35) v3(108.56,82.72) ; v1(108.56,84.35) 109.03,84.35 v3(110.04,85.35)
+CHARGER_SRC:
  vias: v1(6.82,25.74) v1(6.82,25.1) v1(6.82,24.02) v1(6.82,23.39) v1(6.82,22.37) v1(6.82,21.74) v1(10.34,28.68) v1(10.34,27.44) v1(10.34,26.19) v1(10.34,24.95) v3(7.14,20.59)
+COINCELL: length 4.3
  TOP w0.127: v2(60.71,76.73) 60.97,76.73 v1(61.65,77.41)
  TOP w0.508: PR2.1 62.1,78.44 PC2.2 62.11,78.17 61.65,77.72 v1(61.65,77.41)
  BOTTOM w0.508: JRTC1.1 61.25,77.81 v1(61.65,77.41)
+CRT_VCC: length 71.5
  TOP w0.127: v2(316.31,81.36) 316.31,80.75 317.05,80.01 RV119.2
  TOP w0.203: v1(281.27,53.63) 281.14,53.5 280.56,53.5 280.38,53.67 UV6.17
  TOP w0.381: RV120.2 316.97,73.96 v1(317.15,73.78) ; v1(315.73,74.82) 315.6,74.95 RV121.2
  TOP w0.508: RV119.2 317.93,80.01 v1(318.29,79.65) ; RV122.2 315.33,77.46 v1(315.33,77.08)
  IN1 w1.016: 272.59,79.45 272.59,80.94 272.08,81.45 272.08,87.26 273.34,88.51 273.34,90.45 275.39,92.5 281.13,92.5 281.96,93.32 294.25,93.32 295.08,92.5 307.57,92.5 317.63,82.44
  BOTTOM w1.016: JCRT1.9 322.15,77.46 319.7,77.46 319.41,77.74
  vias: v1(281.57,54.14) v1(318.39,78.02)
+DC_IN: length 43.8
  TOP w0.102: v1(71.15,101.21) v3(70.26,101.21)
  TOP w0.508: v1(71.15,101.21) 71.19,101.17 PC11.1 72.08,99.13 69.68,96.74 v3(67.32,96.74) v3(61.29,96.74) 60.63,97.4 56.29,97.4 52.48,93.59 52.48,92.69 ; PR1201.1 v1(65.65,111.31)
  IN1 w0.508: v1(71.15,101.21) 71.76,101.81 71.76,105.62 70.3,107.08 70.3,110.36 69.35,111.31 v1(65.65,111.31)
+DC_IN_SS: length 95.3
  TOP w0.508: PD904.2 11.22,28.11 v2(11.24,28.14) 11.24,29.23 v1(10.42,30.05)
  IN1 w0.508: v1(36.58,34.88) 36.58,28.09 35.76,27.26 30.99,27.26 28.85,29.41 18.6,29.41 17.45,30.55 10.91,30.55 v1(10.42,30.05)
  BOTTOM w0.508: v1(51.82,83.71) 41.28,73.17 39.18,73.17 37.66,71.65 37.66,56.53 36.9,55.77 36.9,48.02 36.58,47.71 v1(36.58,34.88)
+DCIN_JACK: length 2.4
  TOP w0.102: 57.03,87.78 v3(57.79,87.01) ; 56.27,87.52 56.27,86.33 v3(56.19,86.25)
  vias: v1(55.36,88.92) v1(55.51,88.22) v1(55.9,89.33) v1(55.89,87.78) v1(55.93,88.73) v1(56.49,89.02) v1(56.52,88.41) v1(56.52,87.75) v1(57.07,88.72) v1(57.04,88.12) v3(55.12,87.78)
+DCPRTC: length 11.8
  TOP w0.102: CC214.1 v1(139.2,40.4)
  BOTTOM w0.076: UC1.BB10 131.9,46.81 132.86,45.85 133.41,45.85 134.92,44.34 135.39,44.34
  BOTTOM w0.102: v1(139.2,40.4) 139.08,40.4 138.46,41.02 138.46,42.08 v2(137.39,43.15) 136.2,44.34 135.39,44.34
+DDR_VREF_A_CA: length 7.3
  TOP w0.508: v1(82.03,6.22) 81.92,6.11 CD25.1 CD26.1 RD17.1 v2(84.88,5.24) 85.73,5.24 RD15.2 RD16.1
  BOTTOM w0.254: JDIMM1.164 v1(82.03,6.22)
+DDR_VREF_A_DQ: length 9.7
  BOTTOM w0.076: 93.69,44.61 95.82,46.75 97.46,46.75 97.63,46.92 97.63,47.32 97.8,47.49 97.8,47.87 97.94,48.02 98.5,48.02 UC1.AY68
  BOTTOM w0.102: T132.1 93.48,44.4 93.69,44.61
+DDR_VREF_B_CA: length 27.6
  TOP w0.508: RD28.2 v2(173.33,4.4) 174.12,4.4 175.14,3.38 v1(175.14,2.43) ; RD28.2 171.48,3.48 RD30.1 ; RD28.2 RD29.1 CD57.1 CD58.1
  IN2 w0.508: v1(163.03,6.97) 163.07,6.93 163.07,5.89 164.25,4.72 165.93,4.72 169.17,1.48 171.2,1.48 172.79,3.07 174.76,3.07 175.14,2.69 v1(175.14,2.43)
  BOTTOM w0.254: JDIMM2.164 v1(163.03,6.97)
+DDR_VREF_B_DQ: length 157.1
  TOP w0.508: v1(98.62,47.63) 98.1,47.63 95.32,44.85 95.32,39.88 88.94,33.5 v1(85.82,33.5) ; CD62.1 RD30.2 171.2,1.84 170.93,1.57 168.51,1.57 167.96,2.12 167.96,2.7 165.67,4.99 163.15,4.99 160.76,2.6 158.12,2.6 v1(157.14,3.57)
  IN3 w0.508: v1(85.82,33.5) 85.82,32.95 77.48,24.6 77.48,14.09 78.14,13.43 78.14,6.5 80.19,4.45 v1(80.19,2.93) ; v1(157.14,3.57) 156.38,2.81 143.26,2.81 142.25,3.83 121.42,3.83 117.99,7.26 111,7.26 107.89,4.15 101.67,4.15 100.91,3.39 v1(90.83,3.39)
  BOTTOM w0.203: v1(98.62,47.63) 98.73,47.74 UC1.BA67
  BOTTOM w0.508: v1(80.19,2.93) 84.85,2.93 85.07,3.15 90.59,3.15 v1(90.83,3.39)
+DDR_VREF_CA: length 59.4
  TOP w0.508: v1(83.11,3.59) 83.45,3.25 CD31.1 83.75,4.12 RD17.2 ; v1(98.2,48.39) 98.21,48.38 98.84,48.38 99.26,47.96 99.26,47.31 97.03,45.09 97.03,39.45 v2(96.21,38.63) 95.62,38.04 v1(95.2,38.04)
  IN3 w0.508: v1(83.11,3.59) 83.11,6.77 81.59,8.3 80.55,8.3 80.04,8.81 80.04,10.26 80.55,10.77 80.55,14.8 81.51,15.76 81.51,25.52 94.04,38.04 v1(95.2,38.04)
  BOTTOM w0.152: UC1.AY67 99.18,48.46 98.26,48.46 v1(98.2,48.39)
+EC_DEBUG_VCC: length 10.6
  BOTTOM w0.254: RE71.2 274.95,79.46 275.21,79.72 277.44,79.72 v2(277.46,79.75) 278.92,79.75 278.97,79.7 279.34,79.7 279.59,79.44 279.59,78.64 279.34,78.39 278.8,78.39 278.31,77.91 277.73,77.91 277.5,77.68 276.7,77.68 276.48,77.9 JDEG1.1
+EDP_VDD: length 1
  TOP w0.127: v1(100.28,83.44) 99.91,83.06 v2(99.41,83.06)
+LCDVDD: length 6.6
  TOP w0.127: v1(99.57,85.43) 98.82,86.17 v2(98.74,86.17) ; v1(99.57,85.43) 100.17,84.83 v2(100.17,84.09) ; v1(99.57,85.43) 98.61,84.46 v2(98.46,84.46)
  BOTTOM w0.508: 102.09,89.83 102.11,89.86 103.28,89.86 103.89,89.25 RV7.2
+LINE1-VREFO-L:
  vias: v2(304.58,36.06)
+LINE1-VREFO-R:
  vias: v2(303.74,35.1)
+MIC2-VREFO: length 10.6
  TOP w0.203: UA1.29 304.41,34.72 v1(304.72,35.03)
  IN4 w0.508: v1(304.72,35.03) 305.84,36.15 306.9,36.15 308.3,37.55 310.69,37.55 310.77,37.64 v1(310.8,37.64)
  BOTTOM w0.127: v2(304.91,36.19) 304.72,36 v1(304.72,35.03)
+PBATT: length 8.4
  TOP w0.254: 23.35,3.73 22.17,4.91 v2(22.17,4.91) 21.87,5.2 PR940.1
+PECI_VREF: length 12.1
  TOP w0.102: CE25.1 304.23,87.28 304.23,88.4 v2(304.4,88.56)
  TOP w0.254: v1(304.68,86.05) 304.63,86.1 CE25.1 304.99,86.52 RE59.2 ; v1(302.36,80.33) UE1.J11
  BOTTOM w0.254: v1(304.68,86.05) 303.84,86.05 303.55,85.76 303.55,84.93 301.88,83.27 301.88,80.99 302.25,80.63 302.25,80.63 302.36,80.52 v1(302.36,80.33)
+PWR_SRC: length 152.1
  TOP w0.508: v1(175.92,99.08) 172.74,95.9 v3(172.74,91.08) 172.74,78.57 186.72,64.58 186.72,59.07 197.93,47.86 197.93,31.16 202.05,27.04 207.12,27.04 207.83,26.33 207.83,22.7 206.85,21.72 206.85,15.17 208.64,13.37 208.64,9.87 209.43,9.09 209.43,5.01 v1(209.33,4.92) ; v1(219.64,6.24) 219.64,7.15 LZ2.1 ; PD901.2 7.76,26.07 v1(8.31,26.61)
  IN1 w0.254: v1(160.22,117.75) 160.22,119.02 160.6,119.4 168.12,119.4 169.39,118.13 173.55,118.13 173.8,118.38 v1(173.8,118.83)
  IN4 w0.508: v1(28.87,13.9) 28.72,13.9 v1(25.61,17.01)
  BOTTOM w0.254: PR102.2 172.74,118.13 173.55,118.13 173.8,118.38 v1(173.8,118.83) ; PR929.2 23.89,18.5 24.14,18.26 24.14,17.77 24.69,17.21
  BOTTOM w0.508: v1(219.64,6.24) 218.55,5.16 215.67,5.16 215.26,4.74 209.51,4.74 v1(209.33,4.92)
  vias: v1(28.85,16.63) v1(28.87,13.26) v1(30.09,16.63) v1(30.46,14.24) v1(30.47,13.65) v1(30.47,13.06) v1(30.82,12.51) v1(31.04,9.95) v1(31.04,9.34) v1(31.12,13.65) v1(31.12,13.06) v1(31.34,16.63) v1(31.5,12.51) v1(31.68,9.95) v1(31.68,9.34) v1(31.81,13.66) v1(31.81,13.05) v1(32.14,12.51) v1(32.29,9.95) v1(32.29,9.34) v1(32.34,13.35) v1(32.31,8.5) v1(32.31,7.87) v1(32.58,16.63) v1(35.26,14.6) v1(35.95,15.23) v1(35.92,14.6) v1(48.77,61.11) v1(48.77,60.41) v1(48.77,59.71) v1(49.15,59.07) v1(49.54,61.11) v1(49.54,60.41) v1(49.54,59.71) v1(49.92,59.07) v1(50.3,61.11) v1(50.3,60.41) v1(50.3,59.71) v1(50.68,59.07) v1(51.06,61.11) v1(51.06,60.41) v1(51.06,59.71) v1(77.98,95.78) v1(77.98,95.14) v1(78.3,96.41) v1(78.62,95.78) v1(78.62,95.14) v1(79,96.41) v1(79.32,95.78) v1(79.32,95.14) v1(106.56,83.39) v1(107.19,83.86) v1(107.19,83.27) v1(107.19,82.67) v1(158.95,117.94) v1(158.95,117.3) v1(158.95,116.67) v1(159.58,118) v1(159.58,117.37) v1(159.58,116.73) v1(159.58,116.1) v1(160.22,117.11) v1(160.22,116.48) v1(160.22,115.84) v1(176.54,99.08) v1(177.17,99.08) v1(177.81,99.08)
+PWR_SRC_AC:
  vias: v2(3.08,15.23)
+PWR_SRC_L: length 0.6
  TOP w0.508: LZ2.2 220.99,7.16
  vias: v3(221.57,7.1)
+REGCTL_PNP10:
  vias: v2(282.58,86.82)
+RREF: length 2.8
  TOP w0.305: RR4.1 29.47,52.98 v2(29.41,52.91) 29.19,52.7 27.61,52.7
+RSVD_VCC3P3_1: length 4
  TOP w0.203: UL1.1 281.74,83.42 282.14,83.03 282.14,81.85 v2(282.4,81.59) 282.87,81.12 282.87,80.69 RL6.1
+RTC_CELL: length 442.1
  TOP w0.127: PD3.1 v2(59.44,76.01)
  TOP w0.381: RE31.1 287.58,69.23 v1(288.04,69.23) 288.24,69.03 RE508.2 ; RE507.2 288.73,75.05 v1(288.63,74.95)
  TOP w0.406: v1(288.49,78.5) 288.68,78.5 RE32.1
  TOP w0.508: v1(292.38,67.79) 291.93,67.79 291.22,68.5 RE324.2 ; RA54.2 302.16,28.2 v1(302.08,28.12) ; v1(322.14,62.57) 321.45,61.88 QE15.3 ; v1(174.38,33.42) 174.38,35.71 177.27,38.6 177.27,43.46 172.49,48.24 172.49,48.65 171.71,49.44 171.71,57.37 164.44,64.64 162.59,64.64 153.24,73.98 153.24,76.87 152.28,77.83 v1(152.28,78.4) ; v1(58.81,77.95) 58.12,77.95 57.66,77.49 PC3.1 57.85,77.17 PD3.1
  IN1 w0.508: v1(288.49,78.5) 287.63,77.65 287.63,75.94 v1(288.63,74.95) 288.42,74.74 287.41,74.74 286.9,74.24 286.9,72.69 287.66,71.92 287.66,70.58 288.04,70.2 v1(288.04,69.23)
  IN2 w0.508: v1(288.04,69.23) 288.04,68.92 288.55,68.41 291.47,68.41 292.09,67.79 v1(292.38,67.79) ; v1(89.03,86.89) 89.03,87.2 89.6,87.78 94.49,87.78 95.7,86.57 99.98,86.57 101.47,88.07 103.83,88.07 104.34,87.56 107.35,87.56 107.89,87.02 113.51,87.02 114,86.53 115.6,86.53 116.21,87.14 117.53,87.14 118.52,86.15 135,86.15 135.28,85.87 136.92,85.87 139.08,88.03 146.24,88.03 148.15,86.12 149.81,86.12 v1(152.3,83.63)
  IN3 w0.508: v1(302.08,28.12) 302.08,26.88 301.06,25.86 297.44,25.86 297.06,25.48 297.06,24.72 296.65,24.31 267.8,24.31 266.85,23.36 262.77,23.36 261.9,22.5 257.66,22.5 255.11,19.94 247.82,19.94 235.05,7.18 221.06,7.18 220.35,7.89 217.71,7.89 216.67,8.93 212.42,8.93 212.06,8.57 209.84,8.57 208.89,9.52 208.89,12.42 203.97,17.35 199.59,17.35 198.75,16.52 195.57,16.52 194.04,18.05 192.76,18.05 188.82,21.99 186.07,21.99 185.49,22.57 183.97,22.57 177.74,28.81 177.74,29.42 174.38,32.78 v1(174.38,33.42)
  IN4 w0.254: v1(302.08,28.12) 302.56,28.59 302.56,36.7 303.79,37.93 303.79,41.74 304.43,42.38 306.78,42.38 309.54,45.14 309.54,47.3 310.65,48.41 310.65,51.72 309.34,53.03 309.34,56.37 311.65,58.68 313.81,58.68 316.3,61.17 320.74,61.17 v1(322.14,62.57)
  IN4 w0.508: v1(89.03,86.89) 88.02,87.9 88.02,88.85 86.3,90.57 68.71,90.57 66.87,88.73 66.05,88.73 65.09,87.78 65.09,85.88 59.54,80.33 59.54,78.68 v1(58.81,77.95)
  BOTTOM w0.508: v1(152.28,78.4) 152.28,81.07 152.98,81.77 152.98,82.96 v1(152.3,83.63) ; RE551.2 322.53,62.96 v1(322.14,62.57) 320.32,60.75 316.81,60.75 316.18,61.37 313.75,61.37 312.86,60.48 312.86,59.76 311.28,58.18 305.57,58.18 305.12,58.63 305.12,59.17 303.32,60.98 298.97,60.98 298.38,61.57 298.38,61.79 294.46,65.71 294.46,66.61 293.72,67.35 292.82,67.35 292.38,67.79 v1(292.38,67.79)
+RTC_CELL_PCH: length 323.8
  TOP w0.127: v2(320.63,66.36) 320.81,66.36 v1(321.18,65.99)
  TOP w0.254: CC103.1 CC102.1 126.95,55.09 126.95,54.44 126.7,54.18 126.62,54.18 v1(126.12,53.68) ; RC69.2 136.3,37.89 v1(136.53,38.12) 136.47,38.12 135.77,38.82 RC56.2
  TOP w0.381: v1(126.12,53.68) 126.43,53.36 CC270.1 ; RE546.1 320.95,65.23 321.16,65.02 CE632.1 CE631.1 321.59,65.58 v1(321.18,65.99)
  TOP w0.508: QE15.1 320.31,63.66 RE546.1
  IN2 w0.254: v1(126.12,53.68) 125.82,53.38 125.82,53.02 125.66,52.86 125.66,48.98 125.83,48.8
  IN2 w0.508: v1(136.53,38.12) 136.15,38.12 135.11,39.16 133.68,39.16 133.17,39.67 133.17,41.47 129.89,44.75 129.89,46.11 v1(129.47,46.53) 128.67,47.33 128.03,47.33 127.33,48.02 126.62,48.02 125.83,48.8
  IN3 w0.508: v1(249.06,18.62) 249.78,19.33 262.08,19.33 262.79,20.05 262.79,21.96 263.57,22.74 267.09,22.74 268.05,23.7 297.05,23.7 297.76,24.4 v1(297.76,25.23) ; v1(199.84,18.18) 199.46,18.18 198.41,17.13 195.82,17.13 193.5,19.45 193.5,21.4 193.1,21.81 191.04,21.81 189.75,23.1 186.9,23.1 184.56,25.44 182.12,25.44 178.44,29.11 178.44,29.8 v1(176.28,31.96) 175.04,33.2 175.04,34 174.58,34.46 169.02,34.46 167.77,35.71 167.77,39.71 166.57,40.91 165.92,40.91 161.93,44.9 161.93,45.56 160.3,47.19 159.67,47.19 159.22,47.63 159.22,49.84 157.09,51.97 157.09,52.36 156.58,52.87 155.83,52.87 155.45,52.5 155.45,51.96 v1(155.45,51.96)
  IN4 w0.508: v1(199.84,18.18) 200.54,18.88 203.33,18.88 204.11,19.65 208.78,19.65 209.44,18.99 214.48,18.99 215.37,19.88 217.81,19.88 218.39,19.3 220.73,19.3 221.59,20.16 226.43,20.16 227.96,18.64 249.05,18.64 v1(249.06,18.62) ; v1(297.76,25.23) 297.13,25.85 295.99,25.85 295.46,26.38 294.7,26.38 292.97,28.11 292.97,30.66 293.12,30.82 293.12,32.34 297.12,36.34 297.82,36.34 298.58,37.1 298.58,38.31 299.34,39.07 300.23,39.07 300.8,39.64 300.8,41.1 301.68,41.98 303.17,41.98 304.18,42.99 306.53,42.99 308.93,45.39 308.93,47.64 310.04,48.75 310.04,50.06 309.85,50.25 309.76,50.25 308.73,51.28 308.73,56.62 311.4,59.29 313.56,59.29 316.05,61.78 320.01,61.78 321.18,62.95 v1(321.18,65.99)
  BOTTOM w0.102: UC1.BB14 129.48,46.55 v1(129.47,46.53)
  BOTTOM w0.254: UC1.AK19 v1(126.12,53.68)
  BOTTOM w0.508: RE551.1 321.18,64.66 v1(321.18,65.99) ; v1(136.53,38.12) 136.34,38.12 135.9,37.67 135.9,34.15 139.51,30.53 139.51,29.29 142.8,26 170.13,26 172.79,28.66 174.12,28.66 174.82,29.36 174.82,30.5 v1(176.28,31.96) ; RC57.2 154.86,51.45 155.38,51.96 v1(155.45,51.96)
+RTC_CELL_VBAT: length 11
  TOP w0.102: v1(290.76,76.8) 290.89,76.8 v2(291.27,77.18)
  TOP w0.254: v1(293.87,72.64) 293.96,72.56 295.39,72.56 UE1.A2 ; RE32.2 290.14,77.88 CE11.1 290.52,76.8 v1(290.76,76.8)
  IN2 w0.254: v1(293.87,72.64) 293.86,72.64 293.6,72.9 293.6,76.01 293.22,76.4 292.41,76.4 292.18,76.17 291.09,76.17 290.76,76.5 v1(290.76,76.8)
+SDC_IN: length 65.4
  TOP w0.508: PR943.1 v1(14.33,20.59) ; PQ1203.3 5.97,39.23 PR1202.1 4.2,38.63 3.43,37.86 v1(2.39,37.86) ; PQ5.3 57.18,102.3 PR10.1 v1(55.54,102.96)
  IN1 w0.508: v1(55.54,102.96) 54.75,102.96 48.77,96.98 48.77,90.89 46.76,88.87 46.76,86.27 v1(46.74,86.25)
  IN4 w0.508: v1(4.96,19.2) 5.97,19.2 7.93,21.15 13.77,21.15 v1(14.33,20.59)
  BOTTOM w0.254: v1(3.43,17.29) 2.52,16.38 2.52,11.35 2.72,11.14 7.32,11.14 8.79,12.62 10.83,12.62 11.31,13.1 11.44,13.1 12.37,14.03 PR944.1
  BOTTOM w0.508: v1(2.39,37.86) 2.04,38.22 2.04,41.93 v1(3.43,43.33)
  vias: v1(3.43,45.99) v1(3.43,45.36) v1(3.43,44.72) v1(3.43,44.09) v1(3.43,19.2) v1(3.43,18.56) v1(3.43,17.93) v1(3.82,19.83) v1(4.07,45.99) v1(4.07,45.36) v1(4.07,44.72) v1(4.07,44.09) v1(4.07,43.33) v1(4.2,19.2) v1(4.2,18.56) v1(4.2,17.93) v1(4.2,17.29) v1(4.58,19.83) v1(19.94,61.11) v1(19.94,60.34) v1(20.71,61.87) v1(20.71,61.11) v1(20.71,60.34) v1(21.6,61.87) v1(21.6,61.11) v1(21.6,60.34) v1(22.48,61.87) v1(22.48,61.11) v1(22.48,60.34) v3(28.33,59.58)
+SDREG2:
  vias: v2(22.6,47.77)
+SIM_PWR: length 254.4
  TOP w0.102: v3(127.14,102.21) 127.14,102.43 126.54,103.04 v1(126.45,103.04)
  TOP w0.508: v1(126.45,103.04) 125.91,103.04 CZ41.1
  IN1 w0.508: v1(126.45,103.04) 126.45,106.65 122.65,110.44 121.2,110.44 119.46,112.18 118.27,112.18 117.8,112.65 v1(117.8,113.06)
  IN4 w0.508: v1(138.86,98.85) 138.86,98.38 141.84,95.4 143.41,95.4 144.86,93.95 145.55,93.95 149.51,89.98 151.26,89.98 154.63,86.62 154.63,85.68 160.76,79.55 160.76,76.21 167.04,69.94 167.04,55.33 180.42,41.95 186.24,41.95 192.97,35.22 192.97,33.57 199.53,27.01 206.89,27.01 208.79,25.1 214,25.1 214.83,25.93 217.56,25.93 218.06,25.42 221.62,25.42 222.26,24.78 231.2,24.78 232.89,23.09 253.36,23.09 253.8,22.65 257.69,22.65 268.49,33.44 269.62,33.44 271.3,35.12 271.3,36.26 272.56,37.52 276.76,37.52 277.62,38.37 279.39,38.37 280.33,39.31 280.33,42.51 283.85,46.03 286.44,46.03 288.62,48.21 289.4,48.21 290.16,48.97 291.65,48.97 293.35,50.67 v1(295.56,50.67)
  BOTTOM w0.254: v1(295.56,50.67) 295.55,50.66 JNGFF2.36
  BOTTOM w0.508: JSIM1.1 125,105.88 126.45,104.44 v1(126.45,103.04) 127.86,103.04 132.05,98.85 v1(138.86,98.85) ; RZ335.1 117.8,112.4 CZ37.1 117.78,113.05 v1(117.8,113.06)
+TBTA_LDO_BMC: length 1.9
  TOP w0.076: UT5.E1 33.14,83.22 33.04,83.33 33.04,83.74 33.34,84.04
  TOP w0.102: 33.34,84.04 33.53,84.23 CT71.1
+TBTA_VBUS: length 2.2
  TOP w0.508: PC1208.1 v1(14.45,85.87)
  BOTTOM w0.203: v1(6.7,95.34) 6.67,95.37 6.53,95.37 6.23,95.67 JUSBC1.B9
  BOTTOM w0.254: 6.49,98.18 JUSBC1.B4
  vias: v1(6.74,98.35) v1(8.56,96.16) v1(9.2,96.16) v1(9.78,98.72) v1(9.71,98.11) v1(9.83,96.16) v1(10.37,98.72) v1(10.32,98.11) v1(10.42,95.97) v1(10.42,95.33) v1(10.95,98.72) v1(11.37,86.95) v1(11.37,86.31) v1(12.01,86.95) v1(12.01,86.31) v1(12.64,86.95) v1(12.64,86.31) v1(13.28,86.95) v1(13.28,86.31) v1(13.91,86.95) v1(13.91,86.31) v3(12.64,87.71)
+TBTA_VBUS_1: length 31.9
  TOP w0.508: UT8.1 48.19,100.42 65.32,100.42 66.37,101.46 67.69,101.46 71.89,105.66 v1(74.08,105.66)
  BOTTOM w0.508: PR1239.1 v1(74.08,105.66)
  vias: v1(10.04,57.55) v1(10.04,56.66) v1(10.8,57.55) v1(10.8,56.66) v1(11.56,57.55) v1(11.56,56.66) v1(12.45,57.55) v1(12.45,56.66) v1(13.34,57.55) v1(13.34,56.66) v1(18.74,84.83) v1(18.74,84.19) v1(19.37,84.83) v1(19.37,84.19) v1(20.01,84.83) v1(20.01,84.19) v1(20.01,83.56) v1(20.64,84.83) v1(20.64,84.19) v1(20.64,83.56) v1(30.68,77.46) v1(30.73,76.86) v1(31.26,77.29) v1(35.49,88.82) v1(35.92,88.41) v1(36.35,87.98) v1(36.33,76.6) v1(36.33,75.96) v1(46.43,97.55) v1(47,97.89) v1(46.94,97.11) v3(8.64,57.68)
+USB_EX2_PWR:
  vias: v3(17.98,77.87)
+USB_EX3_PWR: length 0.6
  TOP w0.102: v1(85.17,106.88) 85.53,106.88 v3(85.73,107.08)
+UZ12_TPM: length 1.3
  TOP w0.254: UZ12.8 170.58,39.17 CZ50.1
  vias: v2(172.73,39.49)
+UZ12_VHIO: length 7.7
  TOP w0.254: UZ12.22 163.49,36.67 CZ53.1 162.97,36.15 162.3,36.15 v1(162.24,36.21)
  IN3 w0.457: 163,39.42 163,36.98 v1(162.24,36.21)
  IN3 w0.508: 163,39.42 163,39.95 v1(163.76,40.71)
  vias: v2(167.57,42.77)
+VCHGR:
  vias: v1(32.34,6.72) v1(32.34,6.09) v3(32.29,4.87)
+VHDMI_VCC: length 11.3
  IN1 w0.381: v1(114.66,112.24) 114.66,110.91 v1(116.85,108.73) 114.69,106.57 v1(112.45,106.57)
  BOTTOM w0.381: v1(116.85,108.73) 116.6,108.97 RV23.2 ; RV22.2 114.62,112.27 v1(114.66,112.24)
  vias: v1(111.28,106.57) v1(111.87,106.57) v2(111.61,107.31)
+VR_CAP: length 18.3
  TOP w0.254: v1(296.76,79.53) UE1.C10 ; UE1.J1 301.88,71.85 301.88,71.07 v2(303.03,69.93) 303.53,69.43 v1(303.61,69.43) 304.03,69 CE312.1 CE311.1
  IN2 w0.508: v1(303.61,69.43) 303.61,68.92 302.9,68.22 300.97,68.22 299.53,69.65 299.53,71.52 300.61,72.6 300.61,76.92
+Z4012: length 2.5
  TOP w0.127: PR2.2 v3(61.18,80.66)
  TOP w0.508: PR2.2 60.83,79.3 60.59,79.07 PD3.2
AC1_DISC#: length 125.9
  TOP w0.102: v1(38.82,74.57) 38.42,74.57 37.85,74 36.14,74 35.5,73.36 32.58,73.36 31.82,74.12 RT72.2 ; v1(37.34,30.75) 37.34,30.61 PR939.1
  IN1 w0.089: v1(54.84,85.5) 54.24,86.1 54.24,90.02 55.63,91.41 55.63,96.54 63.08,103.98 63.08,107.5 63.53,107.95 v1(63.91,107.95)
  IN3 w0.122: v1(54.84,85.5) 54.43,85.08 54.43,84.74 41.98,72.29 41.98,71.92 40.26,70.21 40.26,63.24 38.23,61.21 38.23,31.64 v1(37.34,30.75)
  IN4 w0.089: v1(38.82,74.57) 38.46,74.92 38.46,80.49 39.63,81.65 v1(39.63,83.33)
  BOTTOM w0.102: v1(54.84,85.5) 48.15,85.5 v2(48.14,85.49) 47.44,85.49 47.22,85.26 43.28,85.26 41.34,83.33 v1(39.63,83.33) ; PR1244.1 65.46,108.3 65.12,107.95 v1(63.91,107.95)
AC1_DISC#_R: length 2.5
  TOP w0.076: UT5.G11 32.14,77.9 32.26,77.78 32.26,77.03
  TOP w0.102: 32.26,77.03 v2(32.26,76.73) 32.26,76.23 RT72.1
AC_DIS: length 358.1
  TOP w0.102: RE83.1 301.95,86.11 v1(301.88,86.05) 301.93,86 301.93,83.01 301.6,82.67 301.6,81.16 301.17,80.73 UE1.H12 ; v2(226.14,30.12) 226.14,29.47 v1(226.19,29.42) ; PQ909.2 37.03,32.45 PR927.1 v1(37.79,29.8)
  IN3 w0.122: v1(226.19,29.42) 226.76,29.99 236.63,29.99 240.82,34.18 246.26,34.18 247.61,35.54 256.34,35.54 258.08,37.28 266.94,37.28 269.32,39.67 272.52,39.67 274.05,41.19 274.05,43.52 274.96,44.44 276.4,44.44 279.66,47.7 279.66,49.13 283.61,53.08 283.61,53.96 285.5,55.85 285.5,58.45 284.7,59.25 284.7,65.25 285.73,66.28 285.73,68.67 285.52,68.88 285.52,70.14 286.59,71.21 286.59,74.57 287.53,75.51 287.53,78.34 288.24,79.05 291,79.05 295.79,83.84 297.69,83.84 298.58,84.73 299.41,84.73 300.73,86.05 v1(301.88,86.05)
  BOTTOM w0.102: v1(37.79,29.8) 44.42,29.8 51.6,22.62 78.55,22.62 80.9,24.97 121.1,24.97 128.26,17.81 175.54,17.81 177.36,16 187.29,16 188.17,15.12 188.17,12.29 188.6,11.85 188.6,9.85 188.91,9.55 188.91,6.3 193.61,1.6 198.83,1.6 200.02,2.79 222.34,2.79 226.52,6.98 226.52,29.09 v1(226.19,29.42)
AC_DISC#: length 487
  TOP w0.102: PR1231.1 31.9,35.96 PQ1211.6 31.9,37.09 30.6,38.39 PQ1211.3 30.01,38.81 29.81,38.61 PC1217.1 29.2,38.63 PQ1210.6 28.15,37.8 PR1245.1 28.34,36.53 29.04,35.83 29.04,33.47 29.47,33.04 v1(29.47,31.56) ; PR1223.2 16.76,31.11 17.39,30.47 18.19,30.47 18.54,30.12 v2(19.31,30.12) 23.44,30.12 v1(24.07,30.75) ; PR25.2 v1(55.43,106.95)
  TOP w0.112: UE1.E13 v1(299.2,81.97)
  IN1 w0.089: v1(55.43,106.95) 48.14,99.66 48.14,94.51 47.01,93.37 v1(47.01,92.25)
  IN2 w0.122: v1(24.07,30.75) 22.23,30.75 18.47,34.51 18.47,45.12 17.05,46.54 17.05,54.07 26.83,63.85 26.83,77.12 26.48,77.47 26.48,86.14 26.21,86.41 26.21,87.66 28.4,89.86 29.22,89.86 31.08,91.72 46.48,91.72 v1(47.01,92.25)
  IN3 w0.122: v1(299.2,81.97) 299.05,81.82 297.53,81.82 296.85,81.14 295.82,81.14 294.14,79.46 293.11,79.46 291.32,77.67 291.32,76 290.01,74.69 290.01,73.96 288.6,72.55 288.6,71.28 289.21,70.67 289.21,67.4 288.57,66.75 288.57,65.82 288.98,65.41 288.98,62.79 288.27,62.07 287.93,62.07 287.3,61.44 287.3,60.41 286.82,59.92 286.82,58.49 287.28,58.03 287.28,56.09 286.28,55.09 286.01,55.09 284.56,53.64 284.56,52.77 280.57,48.78 280.57,47.27 275.6,42.3 275.6,41.24 273.03,38.68 269.8,38.68 267.4,36.27 258.4,36.27 256.69,34.56 248.06,34.56 246.64,33.14 241.66,33.14 237.24,28.71 228.12,28.71 227.69,28.29 225.16,28.29 v1(224.99,28.47)
  BOTTOM w0.102: v1(224.99,28.47) 224.55,28.03 224.55,25.52 225.94,24.12 225.94,7.47 221.66,3.19 196.93,3.19 195.95,2.22 193.57,2.22 189.35,6.43 189.35,9.73 189.15,9.93 189.15,13.16 188.59,13.72 188.59,15.28 187.47,16.4 177.53,16.4 175.71,18.22 128.93,18.22 121.73,25.43 80.28,25.43 78.23,23.38 51.99,23.38 44.17,31.2 29.84,31.2 v1(29.47,31.56) 29.09,31.18 27.42,31.18 26.61,30.37 24.45,30.37 v1(24.07,30.75)
AC_PRESENT: length 256.5
  TOP w0.102: v1(132.72,31.51) 133.1,31.51 RC243.1
  TOP w0.107: v1(303.16,77.93) UE1.K8
  IN3 w0.122: v1(303.16,77.93) 303.16,77.89 304.36,76.69 304.36,75.41 305.2,74.58 305.2,71.27 304.07,70.15 304.07,69.28 302.4,67.62 302.4,65.86 302.98,65.28 303.53,65.28 303.83,64.98 303.83,64.2 302.57,62.93 301.48,62.93 301.12,62.58 301.12,61.51 298.89,59.28 298.89,55.16 296.5,52.77 296.5,52.65 295.49,51.64 295.49,51.16 293.66,49.33 293.66,47.41 291.56,45.3 290.68,45.3 288.85,43.48 288.85,42.07 284.4,37.62 284.4,36.44 281.94,33.98 281.59,33.98 278.19,30.57 260.2,30.57 258.83,29.2 255.1,29.2 254.2,28.3 249.31,28.3 248.31,27.31 244.7,27.31 239.83,22.44 232.24,22.44 230.07,20.27 225.12,20.27 224.14,21.24 222.52,21.24 221,22.76 218.86,22.76 218.28,22.18 212.54,22.18 211.97,22.76 210.3,22.76 209.74,23.32 208.98,23.32 207.88,24.42 206.1,24.42 202.2,28.31 199.79,28.31 191.6,36.5 188.61,36.5 188.01,37.1 186.55,37.1 185.91,37.74 184.81,37.74 182.76,39.79 v1(182.76,40.02)
  BOTTOM w0.076: UC1.AY15 128.76,48.21 128.6,47.93 128.6,47.65 128.49,47.54 128.49,45.68 130.54,43.63
  BOTTOM w0.102: v1(182.76,40.02) 182.76,32.28 174.35,23.87 138.21,23.87 132.72,29.36 v1(132.72,31.51) 132.67,31.51 132.45,31.74 132.45,39.26 131.46,40.25 131.46,41.57 v2(131.09,41.93) 130.54,42.49 130.54,43.63
ACAV_IN: length 347
  TOP w0.102: PR946.2 PR953.1 31.81,32.83 31.5,32.53 v1(31.5,30.69)
  TOP w0.107: v1(296.76,76.33) UE1.C7
  IN3 w0.122: v1(225.13,25.57) 225.56,26 236.23,26 236.86,25.37 237.8,25.37 243,30.57 247.28,30.57 249.08,32.37 257.35,32.37 258.93,33.95 270.13,33.95 270.95,34.77 277.84,34.77 279.1,36.03 279.1,36.85 279.72,37.48 279.72,38.03 280.24,38.55 280.24,40.77 280.85,41.38 280.85,43.28 282.05,44.47 282.05,45.55 283.59,47.09 284.21,47.09 287.41,50.28 287.41,50.83 288.71,52.12 289.47,52.12 289.99,52.64 289.99,53.27 290.24,53.52 290.99,53.52 292.46,54.99 292.46,55.97 293.44,56.95 293.44,59.69 293.25,59.88 293.25,62.36 294.39,63.5 294.39,65.96 294.21,66.13 294.21,70.71 294.82,71.32 294.82,73.53 295,73.7 295,75.9 295.42,76.33 v1(296.76,76.33)
  BOTTOM w0.102: v1(31.5,30.69) 31.95,30.24 v2(32.44,30.24) 44.84,30.24 51.91,23.18 78.32,23.18 80.35,25.2 121.16,25.2 128.34,18.02 175.63,18.02 177.44,16.2 187.38,16.2 188.39,15.2 188.39,13.63 188.94,13.07 188.94,9.8 189.12,9.62 189.12,6.37 193.69,1.8 198.47,1.8 199.66,2.99 221.75,2.99 226.15,7.39 226.15,24.42 225.13,25.44 v1(225.13,25.57)
ACAV_IN1: length 58.7
  TOP w0.102: PR928.1 11.78,13.92 v1(11.67,14.03) ; PR925.1 33.8,32.72 PQ909.1 34.74,32.01 PR942.1 v1(35.06,31.64)
  IN4 w0.089: v1(35.06,31.64) 35.06,28.21 37.34,25.93 37.34,12.95 36.12,11.73 27.79,11.73 26.19,13.34 11.94,13.34 11.67,13.61 v1(11.67,14.03) 11.78,14.14 12.22,14.14 12.46,14.38 12.46,18.83 v1(11.7,19.59)
  BOTTOM w0.102: v1(11.67,14.03) 11.67,13.94 11.21,13.48 v2(11.12,13.48) ; v1(11.7,19.59) 11.72,19.58 PR918.1
ACIN_ISL9538: length 5.6
  TOP w0.203: PU901.19 15.42,17.56
  TOP w0.254: 15.42,17.56 15.35,17.63 14.29,17.63 v1(14.16,17.77)
  BOTTOM w0.102: v1(14.16,17.77) v2(14.82,17.77)
  BOTTOM w0.254: v1(14.16,17.77) 14.13,17.8 PR945.1 PC955.1 PR944.2
ACOK_ISL9538: length 3.9
  TOP w0.203: PU901.24 15.76,15.56
  TOP w0.254: PR928.2 14.12,13.92 v2(14.77,14.58) 15.76,15.56
ADP_ISL9538: length 2.9
  TOP w0.203: PU901.16 17.05,19.36 16.96,19.45 16.2,19.45 PR943.2
ALW_PWRGD_3V_5V: length 172
  TOP w0.102: 153.36,116.61 153.36,118.77 154.12,119.53 169.3,119.53 v1(169.58,119.25) ; 153.36,116.61 PR119.2 ; 153.36,116.61 152.28,116.61 152.02,116.35 152.02,116.09 151.61,115.17 150.94,114.12 149.23,112.41 149.23,111.55 147.15,109.47 147.15,105.61 v2(147.52,105.24) 149.54,103.22 v1(153.25,103.22) ; 179.08,37.61 179.14,37.55 182.69,37.55 183.37,36.87 DC2.1 ; 179.08,37.61 179.08,42.23 172.9,48.4 172.9,55.37 v1(172.29,55.97) ; 179.08,37.61 178.57,37.1 176.47,37.1 174.86,35.49 174.86,32.7 173.23,31.07 172.85,31.07 172.6,30.82 172.6,29.55 171.44,28.39 148.47,28.39 146.74,26.66 138.84,26.66 138.07,27.43 UZ6.2
  IN3 w0.122: v1(153.25,103.22) 153.25,100.14 166.76,86.63 166.76,79.67 167.62,78.8 167.62,61 172.29,56.33 v1(172.29,55.97)
  BOTTOM w0.254: PR120.2 169.19,118.86 v1(169.58,119.25)
ALWON: length 244.8
  TOP w0.107: v1(294.29,74.64) 294.37,74.72 294.92,74.72 295.33,75.13 UE1.A5
  IN3 w0.122: v1(161.08,83.74) 161.08,74.81 162.99,72.9 162.99,62.28 181.62,43.66 187.08,43.66 200.22,30.51 200.71,30.51 200.74,30.47 202.91,30.47 204.2,29.18 206.22,29.18 208.61,26.79 211.55,26.79 211.8,27.04 220.37,27.04 221.16,26.25 234.57,26.25 235.41,27.09 238.77,27.09 242.91,31.23 247.18,31.23 248.77,32.82 257.16,32.82 258.75,34.41 269.89,34.41 272.08,36.6 276.81,36.6 278.14,37.92 278.43,37.92 279.74,39.23 279.74,40.9 280.41,41.57 280.41,43.46 281.6,44.66 281.6,45.73 283.4,47.53 284.01,47.53 286.96,50.48 286.96,51.01 287.59,51.64 287.59,52.78 288.54,53.73 289.61,53.73 289.85,53.97 290.43,53.97 290.78,54.33 290.78,54.93 291.09,55.24 291.72,55.24 292.01,55.53 292.01,56.2 292.99,57.18 292.99,59.5 292.8,59.69 292.8,62.55 293.05,62.8 293.05,63.67 293.29,63.91 293.29,66.17 291.95,67.51 291.95,70.25 293.3,71.6 293.3,73.65 v1(294.29,74.64)
  BOTTOM w0.102: v1(161.08,83.74) 161.08,85.73 v2(169.56,94.21) 174.63,99.28 174.63,116.1 174.22,116.5 PR114.1
AR_DET#: length 14.5
  BOTTOM w0.076: 139.07,63.27 135.78,63.27 135.51,63.01 UC1.P4
  BOTTOM w0.102: 139.07,63.27 v2(141.42,65.62) 142.08,66.29 143.9,66.29 144.73,67.12 146.18,67.12 RC401.1 RC400.1
AUD_HP_NB_SENSE: length 30.2
  TOP w0.254: 319.35,27.96 v3(314.2,27.96) 313.56,28.61 312.54,28.61 311.79,29.36 310.42,29.36 DA2.3 v1(310.9,30.04) ; RA60.2 v1(293.82,29.91)
  IN1 w0.254: v1(310.9,30.04) 307.65,30.04 306.96,29.36 304.22,29.36 303.84,28.97 296.36,28.97 295.42,29.91 v1(293.82,29.91)
AUD_HP_OUT_L: length 2.3
  TOP w0.381: RA57.2 306.25,37.41 RA7.2 307.86,37.41 LA15.1
AUD_HP_OUT_L1: length 11.9
  TOP w0.381: LA15.2 309.73,36.92 DA1.2 310,35.77 311.03,35.77 v1(311.09,35.83) 311.85,36.59 v3(313.72,36.59) 313.72,37.76 314.63,38.68 316.07,38.68 316.35,38.4
  BOTTOM w0.381: v1(311.09,35.83) 311.54,35.39 CA3.1
AUD_HP_OUT_R: length 2.2
  TOP w0.381: LA16.1 RA8.2 306.66,36.54 RA58.2
AUD_HP_OUT_R1: length 20.7
  TOP w0.127: v1(313.38,33.55) v3(313.95,33.55)
  TOP w0.381: v1(313.38,33.55) CA2.1 311.66,33.55 311.1,34.1 DA1.3 309.33,34.1 307.99,35.44 LA16.2
  IN1 w0.381: 321.89,27.83 314.33,27.83 313.38,28.78 v1(313.38,33.55)
AUD_PC_BEEP: length 3.9
  TOP w0.203: 298.26,31.51 298.6,31.85 UA1.16
  TOP w0.254: CA27.2 CA28.2 297.64,30.05 297.64,31.13 298.02,31.51 298.26,31.51
AUD_PWR_EN: length 196.3
  TOP w0.102: v1(143.57,59.19) 143.73,59.19 RC279.1 144.94,57.98 145.9,57.98 146.32,58.4 148.3,58.4 148.47,58.57 150.31,58.57 150.94,59.2 150.94,59.4 151.49,59.95 151.49,60.42 151.77,60.7 152.6,60.7 154.34,62.44 155.54,62.44 157.21,64.1 v2(163.39,64.1) v1(164.34,63.15) ; UZ5.3 275.36,76.08 275.44,76.17 275.44,76.51 v1(275.04,76.91) 274.94,76.91 274.56,76.53 UZ5.5
  IN2 w0.122: v1(143.57,59.19) 143.46,59.3 136.89,59.3 136.11,60.07 133.84,60.07 v1(133.76,59.99)
  IN3 w0.122: v1(275.04,76.91) 274.55,76.42 274.55,75.94 275.92,74.57 275.92,70.3 276.74,69.48 276.74,63.31 275.4,61.97 275.4,60.31 274.84,59.76 274.84,56.39 274.45,56 274.13,56 273.82,55.69 273.82,55.08 273.55,54.8 273.55,53.96 271.76,52.17 271.11,52.17 269.88,50.94 269.23,50.94 267.95,49.67 267.08,49.67 265.03,47.62 265.03,46.78 264.75,46.49 261.5,46.49 260.99,45.98 259.59,45.98 259.03,46.54 256.33,46.54 248.26,38.47 240.71,38.47 236.57,34.33 221.9,34.33 221.41,33.85 217.1,33.85 216.1,32.85 206.11,32.85 205.62,32.35 200.84,32.35 181.5,51.69 180.89,51.69 179.96,52.62 174.5,52.62 164.34,62.78 v1(164.34,63.15)
  BOTTOM w0.102: v1(133.76,59.99) 133.44,59.67 UC1.W8
AUD_SENSE_A: length 5.8
  TOP w0.127: v2(293.5,30.65) 293.68,30.83 RA60.1
  TOP w0.203: 297.28,32.03 297.4,32.15 UA1.13
  TOP w0.254: RA59.2 294.45,31.82 RA60.1 CA41.1 295.34,31 296.37,32.03 297.28,32.03
AUD_SENSE_B: length 1.7
  TOP w0.203: 297.57,31.62 297.8,31.85 UA1.14
  TOP w0.254: 297.57,31.62 297.13,31.18 RA61.2
AUX1_SNOOP_EN#: length 3.2
  BOTTOM w0.102: RT416.1 17.91,90.7 RT308.1 17.91,92.52 v2(18.04,92.65) 18.39,92.65 18.49,92.56 UT9.29
AUX_EN_WOWL: length 179
  TOP w0.102: v1(188.99,38.37) 188.9,38.28 188.9,31.95 185.49,28.53 185.49,26.88 184.98,26.37 v2(184.98,25.34) 184.98,22.5 184.09,21.61 184.09,16.54 184.65,15.98 DZ9.2 183.98,14.75 182.97,14.75 RZ70.1
  TOP w0.107: UE1.D3 v1(297.56,73.13)
  IN3 w0.122: v1(297.56,73.13) 297.56,72.69 295.94,71.07 295.94,68.78 296.58,68.15 296.58,65.65 296.17,65.25 296.17,63.95 294.14,61.93 294.14,60.25 294.57,59.82 294.57,58.83 294.36,58.62 294.36,56.48 293.41,55.53 293.41,53.93 292.51,53.03 292.51,52.81 291.76,52.07 291.14,52.07 288.12,49.05 288.12,47.37 286.59,45.84 283.59,45.84 282.72,44.98 282.72,42.16 280.93,40.37 280.93,38.27 280.39,37.74 280.39,37.2 279.77,36.57 279.77,35.7 277.31,33.24 259.17,33.24 257.63,31.7 249.53,31.7 247.67,29.84 243.54,29.84 238.4,24.7 236.58,24.7 235.95,25.33 228.16,25.33 227.39,24.56 222.22,24.56 220.24,26.55 211.98,26.55 211,25.57 209.2,25.57 207.3,27.47 205.28,27.47 202.78,29.96 200.49,29.96 200.39,30.06 199.98,30.06 191.66,38.37 v1(188.99,38.37)
BAT1_LED#: length 48
  TOP w0.254: RZ28.1 284.61,53.74 284.99,54.12 v2(285.48,54.12) 285.93,54.12 v1(286.01,54.04) ; UE1.D10 v1(297.56,79.53)
  IN1 w0.254: v1(286.01,54.04) 286.01,54.42 287.46,55.87 287.46,57.68 286.69,58.44 286.69,59.21 286.34,59.56 286.34,61.84 285.68,62.5 285.68,64.04 282.9,66.82 282.2,66.82 281.31,67.71 281.31,69.74 282.54,70.97 282.54,74.78 v1(281.34,75.99)
  BOTTOM w0.127: 296.3,79.8 296.42,79.92 297.16,79.92 v1(297.56,79.53)
  BOTTOM w0.254: v1(281.34,75.99) 281.34,76.27 284.83,79.77 286.72,79.77 288.04,81.09 291.39,81.09 292.44,80.03 295.41,80.03 295.64,79.8 296.3,79.8
BAT2_LED#: length 45.4
  TOP w0.254: QZ2.1 266.99,64.85 266.46,65.38 266.46,67.74 267.7,68.98 RZ361.1 268.1,68.98 268.36,69.23 268.36,70.35 v1(268.04,70.67) ; UE1.D11 v1(297.56,80.33)
  BOTTOM w0.254: v1(297.56,80.33) 297,80.89 295.88,80.89 295.38,80.39 292.63,80.39 291.53,81.49 287.94,81.49 286.58,80.12 284.52,80.12 282.17,77.78 281.72,77.78 279.94,75.99 279.94,74.03 279.51,73.6 278.85,73.6 277.86,72.61 277.86,71.63 277.37,71.15 275.65,71.15 274.81,70.31 271.76,70.31 270.94,71.14 v2(268.7,71.14) 268.51,71.14 v1(268.04,70.67)
BAT2_LED#_R: length 9
  TOP w0.102: QZ3.2 268.62,71 269.37,70.25 269.37,68.4 268.93,67.96 268.53,67.96 v2(268.26,67.69) QZ2.6 267.33,65.95 267.8,65.47 268.38,65.47 268.63,65.23 QZ2.3
BATT_WHITE#: length 60.8
  TOP w0.127: 267.47,71.9 v3(266.96,71.9)
  TOP w0.254: JLED1.3 285.4,51.96 285.22,52.13 285.22,53.23 285.55,53.56 v1(285.68,53.56) ; RZ361.2 267.47,70.15 267.47,71.9 268.23,72.66 269.49,72.66 QZ3.3 269.49,71.6 v1(269.48,71.61)
  IN1 w0.254: v1(285.68,53.56) 285.53,53.71 285.53,54.48 287,55.95 287,57.01 285.45,58.56 285.45,60.6 284.74,61.31 284.74,64.28 282.64,66.38 281.79,66.38 280.68,67.49 280.68,74.24 280.12,74.8 280.12,75.64 279.49,76.26 279.49,77.11 278.99,77.61 v1(278.99,77.92)
  IN3 w0.254: v1(278.99,77.92) 278.99,78.57 276.74,80.82 271.3,80.82 270.62,80.13 269.47,80.13 267.29,77.95 267.29,73.8 v1(269.48,71.61)
