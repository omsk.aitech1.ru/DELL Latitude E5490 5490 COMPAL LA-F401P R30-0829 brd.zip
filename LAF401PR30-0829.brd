# Allegro board LAF401PR30-0829.brd (continued)
## Nets (continued)
PCIE_PRX_C_DTX_N11: JNGFF3.29 RN82.1
PCIE_PRX_C_DTX_N12: JNGFF3.43 RN78.1
PCIE_PRX_C_DTX_P1: CR13.2 UR1.7
PCIE_PRX_C_DTX_P4: CL1.2 UL1.38
PCIE_PRX_C_DTX_P11: JNGFF3.31 RN81.1
PCIE_PRX_C_DTX_P12: JNGFF3.41 RN77.1
PCIE_PRX_C_RD_DTX_N8: CZ142.2 UZ36.4
PCIE_PRX_C_RD_DTX_N11: CN27.2 UN4.4
PCIE_PRX_C_RD_DTX_N12: CN37.2 UN5.4
PCIE_PRX_C_RD_DTX_P8: CZ141.2 UZ36.5
PCIE_PRX_C_RD_DTX_P11: CN26.2 UN4.5
PCIE_PRX_C_RD_DTX_P12: CN36.2 UN5.5
PCIE_PRX_DTX_N1: CR14.1 UC1.H13
PCIE_PRX_DTX_N3: JNGFF1.43 UC1.H16
PCIE_PRX_DTX_N4: CL2.1 UC1.G15
PCIE_PRX_DTX_N8: CZ142.1 UC1.G21
PCIE_PRX_DTX_N11: CN27.1 UC1.E28
PCIE_PRX_DTX_N12: CN37.1 UC1.E30
PCIE_PRX_DTX_P1: CR13.1 UC1.G13
PCIE_PRX_DTX_P3: JNGFF1.41 UC1.G16
PCIE_PRX_DTX_P4: CL1.1 UC1.F15
PCIE_PRX_DTX_P8: CZ141.1 UC1.F21
PCIE_PRX_DTX_P11: CN26.1 UC1.E27
PCIE_PRX_DTX_P12: CN36.1 UC1.F30
PCIE_PRX_RD_DTX_N8: JNGFF2.43 UZ36.15
PCIE_PRX_RD_DTX_N11: RN82.2 UN4.15
PCIE_PRX_RD_DTX_N12: RN78.2 UN5.15
PCIE_PRX_RD_DTX_P8: JNGFF2.41 UZ36.14
PCIE_PRX_RD_DTX_P11: RN81.2 UN4.14
PCIE_PRX_RD_DTX_P12: RN77.2 UN5.14
PCIE_PTX_C_DRX_N1: CR12.2 UR1.4
PCIE_PTX_C_DRX_N3: CZ13.2 JNGFF1.37
PCIE_PTX_C_DRX_N4: CL6.2 UL1.42
PCIE_PTX_C_DRX_N8: CZ10.2 JNGFF2.47
PCIE_PTX_C_DRX_N11: CN69.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN71.1 JNGFF3.47
PCIE_PTX_C_DRX_P1: CR11.2 UR1.3
PCIE_PTX_C_DRX_P3: CZ12.2 JNGFF1.35
PCIE_PTX_C_DRX_P4: CL5.2 UL1.41
PCIE_PTX_C_DRX_P8: CZ11.2 JNGFF2.49
PCIE_PTX_C_DRX_P11: CN70.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN72.1 JNGFF3.49
PCIE_PTX_C_RD_DRX_N8: CZ136.2 UZ36.2
PCIE_PTX_C_RD_DRX_N11: CN23.2 UN4.2
PCIE_PTX_C_RD_DRX_N12: CN33.2 UN5.2
PCIE_PTX_C_RD_DRX_P8: CZ135.2 UZ36.1
PCIE_PTX_C_RD_DRX_P11: CN22.2 UN4.1
PCIE_PTX_C_RD_DRX_P12: CN32.2 UN5.1
PCIE_PTX_DRX_N1: CR12.1 UC1.B17
PCIE_PTX_DRX_N3: CZ13.1 UC1.D17
PCIE_PTX_DRX_N4: CL6.1 UC1.B19
PCIE_PTX_DRX_N8: CZ136.1 UC1.D21
PCIE_PTX_DRX_N11: CN23.1 UC1.D24
PCIE_PTX_DRX_N12: CN33.1 UC1.A25
PCIE_PTX_DRX_P1: CR11.1 UC1.A17
PCIE_PTX_DRX_P3: CZ12.1 UC1.C17
PCIE_PTX_DRX_P4: CL5.1 UC1.A19
PCIE_PTX_DRX_P8: CZ135.1 UC1.C21
PCIE_PTX_DRX_P11: CN22.1 UC1.C24
PCIE_PTX_DRX_P12: CN32.1 UC1.B25
PCIE_PTX_RD_DRX_N8: CZ10.1 UZ36.17
PCIE_PTX_RD_DRX_N11: CN69.2 UN4.17
PCIE_PTX_RD_DRX_N12: CN71.2 UN5.17
PCIE_PTX_RD_DRX_P8: CZ11.1 UZ36.18
PCIE_PTX_RD_DRX_P11: CN70.2 UN4.18
PCIE_PTX_RD_DRX_P12: CN72.2 UN5.18
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.55 JNGFF1.70 JNGFF2.54 JNGFF3.54 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.1 RE275.2 UE1.N13
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD#: CA31.1 DA8.2 RA18.1 RA48.2 RA50.2 UA1.47
PDA_RESET#_R: RT110.2 UT5.F11
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE1.K13
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_LAN#: RC62.2 UL1.36
PLTRST_TPM#: RC60.2 RC325.2 UZ12.17
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: RE324.1 RZ364.1 UE1.E4
POA_WAKE#_R: JUSH1.4 RZ364.2
POWER_SW#_MB: CE101.1 CE102.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PROCHOT#: CC310.1 PC605.2 PC918.2 PR678.1 PR926.1 RC83.1 RC84.1 RE288.2
PROCHOT#_ISL9538: PQ1216.1 PR926.2 PU901.23
PROCHOT#_R: CC336.1 RC84.2 UC1.C65
PROCHOT#_R1: RE288.1 UE1.H13
PS_ID: PR4.1 PR5.2 UE1.J8
PWM1_IA: PR687.1 PU602.12
PWM2_IA: PR692.1 PU602.13
PWM_FAN1: JFAN1.2 RE48.2 UE1.L10
PWM_GT: PR664.1 PU602.22
PWM_SA: PR606.2 PU614.3
PWM_VSA: PR606.1 PU602.30
RD1_A_DE0: RN25.2 RN38.1 UN4.6
RD1_A_DE1: RN26.2 RN39.1 UN4.8
RD1_A_EQ0: RN42.2 RN179.1 UN4.23
RD1_A_EQ1: RN43.2 RN176.1 UN4.22
RD1_A_EQ2: RN44.2 RN174.1 UN4.19
RD1_B_DE0: RN27.2 RN40.1 UN4.13
RD1_B_DE1: RN28.2 RN41.1 UN4.9
RD1_B_EQ0: RN49.2 RN52.1 UN4.11
RD1_B_EQ1: RN50.2 RN53.1 UN4.21
RD1_B_EQ2: RN51.2 RN54.1 UN4.16
RD1_REXT: RN30.1 UN4.10
RD2_A_DE0: RN55.2 RN59.1 UN5.6
RD2_A_DE1: RN56.2 RN60.1 UN5.8
RD2_A_EQ0: RN225.2 UN5.23
RD2_A_EQ0_R: QN5.3 RN63.2 RN225.1
RD2_A_EQ1: RN224.2 UN5.22
RD2_A_EQ1_R: QN5.6 RN64.2 RN224.1
RD2_A_EQ2: RN223.2 UN5.19
RD2_A_EQ2_R: QN4.3 RN65.2 RN223.1
RD2_B_DE0: RN57.2 RN61.1 UN5.13
RD2_B_DE1: RN58.2 RN62.1 UN5.9
RD2_B_EQ0: RN69.2 RN72.1 UN5.11
RD2_B_EQ1: RN70.2 RN73.1 UN5.21
RD2_B_EQ2: RN71.2 RN74.1 UN5.16
RD2_REXT: RN31.1 UN5.10
RD5_A_DE0: RZ154.2 RZ155.1 UZ36.6
RD5_A_DE1: RZ156.2 RZ157.1 UZ36.8
RD5_A_EQ0: RZ354.2 RZ355.1 UZ36.23
RD5_A_EQ1: RZ356.2 RZ357.1 UZ36.22
RD5_A_EQ2: RZ358.2 RZ359.1 UZ36.19
RD5_B_DE0: RZ158.2 RZ159.1 UZ36.13
RD5_B_DE1: RZ160.2 RZ161.1 UZ36.9
RD5_B_EQ0: RZ162.2 RZ163.1 UZ36.11
RD5_B_EQ1: RZ164.2 RZ165.1 UZ36.21
RD5_B_EQ2: RZ166.2 RZ167.1 UZ36.16
RD5_REXT: RZ348.1 UZ36.10
RED: CV129.1 DV5.2 JCRT1.1 LV16.2
RED_CRT: CV126.1 LV16.1 RV116.1 UV6.23
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RES_BIAS: RL13.1 UL1.12
RESET_IN#: RE361.1 RE362.1 UE1.C1
RESET_OUT: RE548.2 UE1.G4
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.2 UA1.17
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.20
RJ45_MDIN2: JLOM1.5 TL1.17
RJ45_MDIN3: JLOM1.8 TL1.23
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.19
RJ45_MDIP2: JLOM1.4 TL1.16
RJ45_MDIP3: JLOM1.7 TL1.22
RTCRST_ON: QE12.2 RE93.1 RE565.2 UE1.F11
RTCRST_ON_R: CE65.1 DE2.2 QE17.2 RE543.1
RTD3_CIO_PWR_EN: T18.1(TP-1) UC1.AC2
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 QZ4.2 RE68.1
RUN_ON_1.8V: CZ197.1 RZ345.2 UZ8.3
RUN_ON_EC: RE292.2 RPE10.4 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UC8.1 UC8.4 UC8.10 UC8.13 UE1.G3
SA_LGATE: PQ614.8 PU614.5
SA_SNUB: PC622.1 PR627.2
SA_SW: PL614.4 PQ614.9 PR619.2 PR627.1 PU614.8
SA_UGATE: PQ614.1 PU614.1
SATA_PRX_C_DTX_N0: CN6.1 JSATA1.5
SATA_PRX_C_DTX_P0: CN7.1 JSATA1.6
SATA_PRX_C_RD_DTX_N0: CN14.2 UN7.4
SATA_PRX_C_RD_DTX_P0: CN15.2 UN7.5
SATA_PRX_DTX_N0: CN14.1 UC1.F20
SATA_PRX_DTX_P0: CN15.1 UC1.E20
SATA_PRX_RD_DTX_N0: CN6.2 UN7.12
SATA_PRX_RD_DTX_P0: CN7.2 UN7.11
SATA_PTX_C_DRX_N0: CN5.1 JSATA1.3
SATA_PTX_C_DRX_P0: CN4.1 JSATA1.2
SATA_PTX_C_RD_DRX_N0: CN13.2 UN7.2
SATA_PTX_C_RD_DRX_P0: CN12.2 UN7.1
SATA_PTX_DRX_N0: CN13.1 UC1.B21
SATA_PTX_DRX_P0: CN12.1 UC1.A21
SATA_PTX_RD_DRX_N0: CN5.2 UN7.14
SATA_PTX_RD_DRX_P0: CN4.2 UN7.15
SATALED#: QZ2.4 RN100.2 RN101.2 RPC4.2 UC1.H1
SBIOS_TX: RE306.1 UC1.AB2
SD/MMCCD#: JSD1.18 UR1.30
SD/MMCCLK: RR5.1 UR1.17
SD/MMCCLK_R: CR21.1 JSD1.5 RR5.2
SD/MMCCMD: RR6.1 UR1.19
SD/MMCCMD_R: JSD1.2 RR6.2
SD/MMCDAT0/RCLK+: RR10.1 UR1.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR10.2
SD/MMCDAT1/RCLK-: RR9.1 UR1.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR9.2
SD/MMCDAT2: RR8.1 UR1.21
SD/MMCDAT2_R: JSD1.9 RR8.2
SD/MMCDAT3: RR7.1 UR1.20
SD/MMCDAT3_R: JSD1.1 RR7.2
SD_GPIO: RR3.2 UR1.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.12 UR1.25
SD_UHS2_D0P: JSD1.11 UR1.26
SD_UHS2_D1N: JSD1.15 UR1.23
SD_UHS2_D1P: JSD1.16 UR1.22
SDWP: QR1.1 UR1.29
SDWP_Q: JSD1.19 QR1.3
SIM_DET: JNGFF2.66 JSIM1.9
SIO_EXT_SCI#: RC237.1 RC561.1 UC1.AN7
SIO_EXT_SMI#: RC346.1 UC1.A6
SIO_EXT_WAKE#: RC283.1 UC1.AC1 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.1 UC1.BA15 UE1.K11
SIO_SLP_A#: JAPS1.6 UC1.AN16 UE1.M11
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE1.H9 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 RZ362.2 RZ363.1 UC1.AT11 UZ35.1
SIO_SLP_S3#: JAPS1.2 QE11.2 RE280.1 UC1.AP15 UE1.K9 UE3.2 UE5.1
SIO_SLP_S4#: JAPS1.5 PR208.1 PR513.1 UC1.BA16 UE1.N12 UZ21.4 UZ34.2
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE1.N8
SIO_SLP_SUS#: RC441.1 RE349.1 UC1.AN15
SIO_SLP_SUS#_R: RE349.2 RE561.1 UE1.N4
SIO_SLP_WLAN#: QZ15.1 UC1.BB17 UE1.D9
SLEEVE: LA11.1 RA6.2 UA1.18
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.3 LA11.2
SLOT2_SATA_LED#: JNGFF2.10 RN101.1
SLP_WLAN#_GATE: QZ15.2 RE552.1 RZ518.2
SLP_WLAN#_M: DZ9.3 QZ15.3 RZ71.1
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: CC318.1 RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: CC319.1 RC15.1 UC1.W3 UE1.D8
SML1_SMBDATA: RC17.1 UC1.V3 UE1.E11
SNB_+1VALWP: PC302.1 PR303.2
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SPKR: RA12.2 RC183.1 UC1.AW5
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CC78.1 CC79.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
SUSACK#: RC443.1 UE1.K12
SUSACK#_R: RC443.2 RC551.1 UC1.AP11
SUSCLK: RC48.1 RN99.2 RZ56.2 UC1.BA17
SUSCLK_R: JNGFF3.68 RN99.1
SW2_DP1_AUXN: CT81.1 CT116.1 RV70.1 UV7.27
SW2_DP1_AUXN_C: CT116.2 RT131.1 UT9.25
SW2_DP1_AUXP: CT80.1 CT115.1 RV76.1 UV7.26
SW2_DP1_AUXP_C: CT115.2 RT130.1 UT9.24
SW2_DP1_CADET: RV73.1 UV7.43
SW2_DP1_HPD: RT73.2 RT380.1 UV7.48
SW2_DP1_HPD_R: RT73.1 UT5.C10
SW2_DP1_N0: CT104.1 UV7.49
SW2_DP1_N0_C: CT104.2 UT9.10
SW2_DP1_N1: CT106.1 UV7.46
SW2_DP1_N1_C: CT106.2 UT9.13
SW2_DP1_N2: CT108.1 UV7.44
SW2_DP1_N2_C: CT108.2 UT9.16
SW2_DP1_N3: CT110.1 UV7.41
SW2_DP1_N3_C: CT110.2 UT9.19
SW2_DP1_P0: CT103.1 UV7.50
SW2_DP1_P0_C: CT103.2 UT9.9
SW2_DP1_P1: CT105.1 UV7.47
SW2_DP1_P1_C: CT105.2 UT9.12
SW2_DP1_P2: CT107.1 UV7.45
SW2_DP1_P2_C: CT107.2 UT9.15
SW2_DP1_P3: CT109.1 UV7.42
SW2_DP1_P3_C: CT109.2 UT9.18
SW2_DP3_AUXN: CV112.1 RV72.1 UV7.29
SW2_DP3_AUXN_C: CV112.2 UV6.3
SW2_DP3_AUXP: CV111.1 RV78.1 UV7.28
SW2_DP3_AUXP_C: CV111.2 UV6.2
SW2_DP3_CADET: RV75.1 UV7.33
SW2_DP3_HPD: RV102.1 UV6.32 UV7.38
SW2_DP3_N0: CV108.1 UV7.39
SW2_DP3_N0_C: CV108.2 UV6.6
SW2_DP3_N1: CV110.1 UV7.36
SW2_DP3_N1_C: CV110.2 UV6.8
SW2_DP3_P0: CV107.1 UV7.40
SW2_DP3_P0_C: CV107.2 UV6.5
SW2_DP3_P1: CV109.1 UV7.37
SW2_DP3_P1_C: CV109.2 UV6.7
SW2_PS8338_CFG0: RV87.1 RV88.1 UV7.59
SW2_PS8338_P0: RV95.1 RV96.1 UV7.60
SW2_PS8338_P1: RV93.1 RV94.1 UV7.1
SW2_PS8338_PC10: RV85.1 RV86.1 UV7.56
SW2_PS8338_PC11: RV83.1 RV84.1 UV7.55
SW2_PS8338_PC20: RV81.1 RV82.1 UV7.54
SW2_PS8338_PC21: RV79.1 RV80.1 UV7.53
SW2_PS8338_PEQ: RV89.1 RV90.1 UV7.8
SW2_PS8338_SW: RV91.1 RV92.1 UV7.18
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.6 PU301.19 PU301.20
SW_USB20_N9: LI7.1 UI3.11
SW_USB20_P9: LI7.4 UI3.10
SYS_PWROK: RC129.1 RE56.1 RE548.1 UC1.B6
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.1 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
SYSTEM_ID: CE47.1 RE300.1 UE1.J10
TACH_FAN1: JFAN1.3 RE51.2 UE1.E3
TBT_FORCE_PWR: T19.1(TP-1) UC1.B7
TBT_RESET_N_EC_R: RE95.2 UE1.L8
TBTA_AUXN_C: CT81.2 RT95.1 UT5.J2
TBTA_AUXP_C: CT80.2 RT96.1 UT5.J1
TBTA_BOT_N: RT122.2 UT5.L7
TBTA_BOT_N_R: DT40.1 DT40.9 JUSBC1.B7 RT122.1
TBTA_BOT_P: RT123.2 UT5.K7
TBTA_BOT_P_R: DT40.2 DT40.8 JUSBC1.B6 RT123.1
TBTA_CC1: CT86.1 DT40.4 DT40.7 JUSBC1.A5 RT104.2 UT5.L9
TBTA_CC2: CT85.1 DT40.5 DT40.6 JUSBC1.B5 RT105.2 UT5.L10
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 RT406.2 UT5.L3
TBTA_DEBUG4: RT90.1 RT407.2 RT418.1 UT5.K3
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_ROM_CLK_PD: RT54.2 UT5.A3
TBTA_ROM_CLK_PD_R: JDB1.2 RT54.1 UT6.6
TBTA_ROM_CS#_PD: RT57.2 UT5.B3
TBTA_ROM_CS#_PD_R: JDB1.5 RT51.2 RT57.1 UT6.1
TBTA_ROM_DI_PD: RT55.2 UT5.B4
TBTA_ROM_DI_PD_R: JDB1.3 RT55.1 UT6.5
TBTA_ROM_DO_PD: RT56.2 UT5.A4
TBTA_ROM_DO_PD_R: JDB1.4 RT52.2 RT56.1 UT6.2
TBTA_ROM_HOLD#_PD: RT50.2 UT6.7
TBTA_ROM_WP#_PD: RT53.2 UT6.3
TBTA_ROSC: RT100.1 UT5.G2
TBTA_RX1N: DT14.1 JUSBC1.B10 UT9.31
TBTA_RX1P: DT13.1 JUSBC1.B11 UT9.30
TBTA_RX2N: DT9.1 JUSBC1.A10 UT9.39
TBTA_RX2P: DT10.1 JUSBC1.A11 UT9.40
TBTA_SBU1: DT39.5 DT39.6 JUSBC1.A8 RT108.1 RT132.2
TBTA_SBU1_R: RT108.2 UT5.K8
TBTA_SBU2: DT39.4 DT39.7 JUSBC1.B8 RT109.1 RT133.2
TBTA_SBU2_R: RT109.2 UT5.L8
TBTA_TOP_N: RT121.1 UT5.L6
TBTA_TOP_N_R: DT39.2 DT39.8 JUSBC1.A7 RT121.2
TBTA_TOP_P: RT120.1 UT5.K6
TBTA_TOP_P_R: DT39.1 DT39.9 JUSBC1.A6 RT120.2
TBTA_TX1N: CT96.1 UT9.34
TBTA_TX1N_C: CT96.2 DT6.1 JUSBC1.A3
TBTA_TX1P: CT95.1 UT9.33
TBTA_TX1P_C: CT95.2 DT5.1 JUSBC1.A2
TBTA_TX2N: CT98.1 UT9.36
TBTA_TX2N_C: CT98.2 DT18.1 JUSBC1.B3
TBTA_TX2P: CT97.1 UT9.37
TBTA_TX2P_C: CT97.2 DT17.1 JUSBC1.B2
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
THERMTRIP1#: RE301.1 UE1.B12
THERMTRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
TOUCH_SCREEN_DET#: JEDP1.32 RV8.1 UC1.AY5
TOUCH_SCREEN_PD#: JEDP1.5 RC272.1 UC1.A7
TOUCHPAD_INTR#: JKBTP1.5 RC414.1 RE318.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.1 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.1 UL1.33
TPM_GPIO0: RZ112.2 UZ12.29
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: RZ363.2 UZ12.3
TPM_PIRQ#: RC560.2 RC561.2 RZ69.2 UZ12.18
TPM_PIRQ#_R: RC560.1 UC1.AP8
TPM_TYPE: RC349.1 UC1.AY7
TRST#_XDP: JXDP1.54 UC8.12
TUSB546A_SBU1_R: RT132.1 RT414.1 UT9.27
TUSB546A_SBU2_R: RT133.1 RT415.1 UT9.26
TYPEC_CON_SEL1: RC555.1 RC556.1 UC1.W4
TYPEC_CON_SEL2: RC553.1 RC554.1 UC1.AB3
TYPEC_ID: CE62.1 RE343.2 UE1.F2
UART_MISO: RT82.1 RT83.2 UT5.F2
UART_MOSI: RT81.1 RT83.1 UT5.E2
UG1_ISL9538: PQ905.1 PU901.11
UG2_ISL9538: PQ904.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.32 JSIM1.3
UIM_DATA: CZ39.1 JNGFF2.34 JSIM1.7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.30 JSIM1.2
UPD1_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.C3
UPD1_SMBCLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 RT375.2 UT5.B5
UPD1_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.B4
UPD1_SMBDAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 RT376.2 UT5.A5
UPD1_SMBINT#: RE91.1 RT60.1 UE1.F10
UPD1_SMBINT#_R: RT60.2 RT68.1 UT5.B6
UPD2_SMBCLK: RPE12.3 UE1.D7
UPD2_SMBDAT: RPE12.4 UE1.E7
UPD2_SMBINT#: RE92.1 UE1.F5
USB1_A_DE0: RI53.1 RI54.1 UI5.16
USB1_A_DE1: RI51.1 RI52.1 UI5.18
USB1_A_EQ0: RI40.1 RI41.1 UI5.17
USB1_A_EQ1: RI38.1 RI39.1 UI5.15
USB1_B_DE0: RI57.1 RI58.1 UI5.3
USB1_B_DE1: RI55.1 RI56.1 UI5.6
USB1_B_EQ0: RI44.1 RI45.1 UI5.2
USB1_B_EQ1: RI42.1 RI43.1 UI5.4
USB1_TEST: RI34.2 UI5.14
USB2_ID: RC337.1 RT74.2 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PD#: RI37.2 RI81.2 UI5.5
USB3_PRX_C_DTX_N1: CT112.2 UT9.4
USB3_PRX_C_DTX_P1: CT111.2 UT9.5
USB3_PRX_C_RD_DTX_N6: CI42.2 UI5.23
USB3_PRX_C_RD_DTX_P6: CI41.2 UI5.22
USB3_PRX_DTX_N1: CT112.1 UC1.H8
USB3_PRX_DTX_N2: LI16.4 RI28.1 UC1.J6
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UC1.J10
USB3_PRX_DTX_N4: DI6.1 DI6.9 JUSB3.5 UC1.E10
USB3_PRX_DTX_N6: CI42.1 UC1.G11
USB3_PRX_DTX_P1: CT111.1 UC1.G8
USB3_PRX_DTX_P2: LI16.1 RI27.1 UC1.H6
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UC1.H10
USB3_PRX_DTX_P4: DI6.2 DI6.8 JUSB3.6 UC1.F10
USB3_PRX_DTX_P6: CI41.1 UC1.F11
USB3_PRX_L_DTX_N2: JNGFF2.29 LI16.3 RI28.2
USB3_PRX_L_DTX_P2: JNGFF2.31 LI16.2 RI27.2
USB3_PRX_RD_DTX_N6: DI4.1 DI4.9 JUSB1.5 UI5.8
USB3_PRX_RD_DTX_P6: DI4.2 DI4.8 JUSB1.6 UI5.9
USB3_PTX_C_DRX_N1: CT114.2 UT9.7
USB3_PTX_C_DRX_N2: CI29.1 LI17.4 RI30.1
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_N4: CI27.1 DI6.4 DI6.7 JUSB3.8
USB3_PTX_C_DRX_N6: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_P1: CT113.2 UT9.8
USB3_PTX_C_DRX_P2: CI30.1 LI17.1 RI29.1
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_C_DRX_P4: CI28.1 DI6.5 DI6.6 JUSB3.9
USB3_PTX_C_DRX_P6: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_C_RD_DRX_N6: CI40.1 UI5.20
USB3_PTX_C_RD_DRX_P6: CI39.1 UI5.19
USB3_PTX_DRX_N1: CT114.1 UC1.C13
USB3_PTX_DRX_N2: CI29.2 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N4: CI27.2 UC1.C15
USB3_PTX_DRX_N6: CI40.2 UC1.D16
USB3_PTX_DRX_P1: CT113.1 UC1.D13
USB3_PTX_DRX_P2: CI30.2 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P4: CI28.2 UC1.D15
USB3_PTX_DRX_P6: CI39.2 UC1.C16
USB3_PTX_L_DRX_N2: JNGFF2.35 LI17.3 RI30.2
USB3_PTX_L_DRX_P2: JNGFF2.37 LI17.2 RI29.2
USB3_PTX_RD_DRX_N6: CI13.2 UI5.11
USB3_PTX_RD_DRX_P6: CI16.2 UI5.12
USB20_N1: UC1.AB9 UT5.K5
USB20_N2: LI3.4 UC1.AD6
USB20_N2_R: DI2.3 JUSB2.2 LI3.3
USB20_N3: LI4.4 UC1.AH3
USB20_N3_R: DI3.3 JUSB3.2 LI4.3
USB20_N4: LI8.4 RI48.1 UC1.AD9
USB20_N4_L: JNGFF2.9 LI8.3 RI48.2
USB20_N5: LZ1.1 UC1.AJ1
USB20_N5_R: JEDP1.12 LZ1.2
USB20_N7: LI9.1 RI50.1 UC1.AH1
USB20_N7_L: JNGFF1.5 LI9.2 RI50.2
USB20_N8: LV27.3 UC1.AF8
USB20_N8_R: DV4.2 JEDP1.2 LV27.4
USB20_N9: UC1.AG1 UI3.2
USB20_N9_R: DI5.2 JUSB1.2 LI7.2
USB20_N10: JUSH1.8 UC1.AH7
USB20_P1: UC1.AB10 UT5.L5
USB20_P2: LI3.1 UC1.AD7
USB20_P2_R: DI2.2 JUSB2.3 LI3.2
USB20_P3: LI4.1 UC1.AJ3
USB20_P3_R: DI3.2 JUSB3.3 LI4.2
USB20_P4: LI8.1 RI47.1 UC1.AD10
USB20_P4_L: JNGFF2.7 LI8.2 RI47.2
USB20_P5: LZ1.4 UC1.AJ2
USB20_P5_R: JEDP1.13 LZ1.3
USB20_P7: LI9.4 RI49.1 UC1.AH2
USB20_P7_L: JNGFF1.3 LI9.3 RI49.2
USB20_P8: LV27.2 UC1.AF9
USB20_P8_R: DV4.3 JEDP1.3 LV27.1
USB20_P9: UC1.AG2 UI3.3
USB20_P9_R: DI5.3 JUSB1.3 LI7.3
USB20_P10: JUSH1.9 UC1.AH8
USB_OC0#: RPC3.2 UC1.A9 UI3.13
USB_OC1#: RPC3.3 UC1.C9 UI1.3
USB_OC2#: RPC3.4 UC1.D9 UI2.3
USB_OC3#: RPC3.1 UC1.B9
USB_POWERSHARE_EN#: RPE11.2 UE1.J3 UI3.6
USB_POWERSHARE_VBUS_EN: RI81.1 RPE11.4 UE1.J2 UI3.5
USB_PWR_EN1#: RPE11.3 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.1 UE1.G5 UI2.4
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 LE1.1 RE526.1 UE1.C13
USH_DET#_L: DZ7.1 JUSH1.26 LE1.2
USH_EXPANDER_SMBCLK: CZ62.1 JUSH1.11 RZ8.2 UE1.B3
USH_EXPANDER_SMBDAT: CZ63.1 JUSH1.12 RZ9.2 UE1.E5
USH_PWR_STATE#: JUSH1.22 RZ10.2 UE1.H2
USH_RST#_R: JUSH1.21 RZ114.2
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VCT_LAN_R1: RL3.1 UL1.6
VGA_IDENTIFY: RE84.1 RE85.1 UE1.L9
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR604.2 PR625.1 RC152.1 RC153.2
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: CC321.1 PR601.2 PR618.1 UC1.A63
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR605.2 PR626.1 RC157.1 UC1.D64
VIDSOUT_B: PR626.2 PU602.35
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5105: CE38.1 RE77.1 UE1.C9
VSYNC_CONN: CV132.1 JCRT1.14 RV121.1 RV651.2
VSYNC_CRT: RV651.1 UV6.18
WIGIG_32KHZ: JNGFF1.50 RZ56.1
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_PWR_EN: DZ9.1 RZ38.2 RZ70.2 RZ71.2 UZ4.5
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WWAN_COEX1: JNGFF2.64 RZ130.1
WWAN_COEX2: JNGFF2.62 RZ129.1
WWAN_COEX3: JNGFF2.60 RZ128.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.23 RE38.1 UE1.M13
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.2 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN_U22: RC46.2 RC294.1 RC419.2
XTAL24_IN_U22_CPU: RC419.1 UC1.E37
XTAL24_IN_U22_R: CC21.1 RC294.2 YC1.3
XTAL24_IN_U42: RC417.2 RC421.2 RC550.1
XTAL24_IN_U42_CPU: RC417.1 UC1.E3
XTAL24_IN_U42_R: CC334.1 RC550.2 YC3.3
XTAL24_OUT_U22: RC46.1 RC295.1 RC420.2
XTAL24_OUT_U22_CPU: RC420.1 UC1.E35
XTAL24_OUT_U22_R: CC22.1 RC295.2 YC1.1
XTAL24_OUT_U42: RC418.2 RC421.1 RC422.1
XTAL24_OUT_U42_CPU: RC418.1 UC1.C7
XTAL24_OUT_U42_R: CC335.1 RC422.2 YC3.1
XTALI: CL14.1 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.1 RL34.1 YL1.3
Z2805: RL18.1 TL1.24
Z2806: RL16.1 TL1.18
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N04748: PC939.1 PR929.1 PU901.3
N43975: QN1.5 QN1.6 RN2.2
N16399089: PD901.1 PD903.1 PD904.1 PR916.2
N16400770: PR901.3 PR910.1
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N16783095: PC113.2 PR108.1
N16783126: PC111.1 PC142.1 PR104.1 PR105.1 PU100.16 PU100.17
N16783134: PC127.2 PR117.1
N16784595: PC102.1 PR100.2
N16784799: PC114.1 PR111.2
N17023599: PD905.3 PR939.2 PR950.1
N17023623: PD905.1 PR961.1 PU903.1
N17023625: PR946.1 PU903.4
N17023649: PR942.2 PU903.2
N17023661: PD905.2 PR941.2
N17185089: PQ1204.5 PR1218.1
N17185092: PQ1204.6 PR1214.2 PR1218.2
N17185371: PQ1204.2 PR1223.1
N17188383: PQ1201.2 PR1216.2 PR1262.1
N17275961: PR612.2 PR614.2 PU602.39
N17275988: PR616.2 PU602.40
N17370862: PC4.2 PQ4.4 PQ5.1 PR11.2 PR16.1
N17370885: PQ5.2 PR10.2 PR15.1
N17370921: PQ1.6 PR15.2
N17370927: PQ7.1 PR16.2
N17370961: PL3.1 PQ2.1 PR3.1 PR6.2
N17370983: PQ2.3 PR3.2 PR5.1
N17370995: PQ3.2 PR6.1 PR8.2
N17370999: PQ2.2 PQ3.1 PR7.2
N17371029: PC6.1 PQ9.4 PR12.2 PR18.1
N17371043: PQ6.1 PR18.2
N17371125: PQ7.2 PR20.1
N17371182: PQ6.2 PR23.2 PR30.1
N17371184: PR23.1 PU1.4
N17371196: PR21.2 PU1.1
N17371202: PR22.2 PU1.2
N17372063: PQ1.3 PR17.2 PR19.2
N17372074: PQ1.5 PR25.1
N17372283: PQ1.2 PR19.1
N17400451: PC515.2 PR515.2 PR516.1 PU503.3
N17494434: PC1211.1 PD1205.1 PQ1212.1 PR1238.1 PR1239.2 PR1246.1 PR1255.2 PU1201.5
N18490882: RI14.2 UI3.16
N18762046: CA33.1 RA17.2
N18762152: CZ127.1 UZ5.10
N18762172: CZ126.1 UZ5.12
N18762349: CA51.1 RA44.1 UA1.27
N18762353: CA53.1 UA1.7
N18762355: CA52.1 UA1.39
N18762401: RA53.1 RA54.1 UA1.20
N18762411: CA29.1 UA1.35
N18762416: CA29.2 UA1.37
N18762426: CA35.1 UA1.28
N18762428: CA49.1 UA1.34
N18762438: CA25.1 UA1.19
N20151644: PR901.2 PR909.1
N27077001: PR917.2 PR937.2
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.1 SW1.2
N28769860: PR421.2 PR422.1 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28810563: CZ110.1 UZ2.10
N28811129: CZ114.1 UZ3.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28938912: CC8.1 RC29.2
N28938914: CC7.1 RC28.2
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30342894: QV4.2 RV18.2
N32590572: CZ117.1 UZ4.12
N32592963: CZ118.1 UZ4.10
N32594166: CZ109.1 UZ2.12
N32817808: CZ113.1 UZ3.12
N32818355: RZ64.2 RZ65.2 UZ3.3
N32819772: CZ121.1 UZ8.6
N32875032: CZ130.1 UZ23.6
N33199744: JDIMM1.165 T51.1(TP-1)
N33298471: JDIMM2.165 T55.1(TP-1)
N35551558: PC1210.1 PQ1206.4 PR1228.2 PR1229.1
N35551572: PC1214.1 PQ1209.5 PR1243.2
N35551576: PQ1209.2 PQ1209.3 PR1236.1
N35551581: PQ1209.6 PR1229.2
N35551584: PC1213.1 PD1205.2 PR1238.2 PR1240.2 PR1243.1 PU1201.7
N35551592: PC1212.1 PR1237.2 PR1247.1 PU1201.6
N35551616: PQ1212.2 PR1248.1 PR1249.1 PR1250.1
N35551696: PC1202.2 PQ1213.4 PQ1215.1 PR1205.2 PR1212.1
N35551713: PQ1201.6 PR1212.2
N35551783: PC1203.2 PQ1202.4 PQ1203.1 PR1207.2 PR1213.1
N35551785: PQ1203.2 PR1202.2 PR1209.1
N35551806: PQ1204.3 PR1209.2
N35551822: PQ1201.3 PR1213.2
N36255106: PQ1201.5 PR1220.2
N36626863: CT90.1 RT111.2 UT7.3
N36827741: RZ120.2 UZ26.4 UZ34.4
N38798736: RT97.2 RT98.1 RT99.1 UT5.F10
N38798744: RT85.1 UT5.G4
N38798745: RT84.1 UT5.F4
N38798858: RT63.1 UT5.F1
N38798904: RT105.1 UT5.K10
N38798905: RT104.1 UT5.K9
N38798908: RT103.1 UT5.L11
N38798948: RT85.2 T220.1(TP-1)
N38798949: RT84.2 T219.1(TP-1)
N38799002: CT87.1 UT5.H7
N38799008: RT101.1 UT5.D6
N38802239: QV2.1 RV5.2
N38802260: QV7.1 RV6.1 RV400.1
N38802262: CV635.1 QV8.2 RV400.2
N38804727: JEDP1.21 LV1.1
N39067212: RE57.1 RE58.1 UE1.B1
N39067288: RE318.1 UE1.G2
N39070459: QE11.3 RE70.1 RE90.2
N39070470: QE4.2 RE70.2
N39154673: RV123.2 UV6.10
N39154676: RV124.2 UV6.9
N39317125: PR423.1 PR424.1 PU402.5
N39469798: PR679.1 PU614.7
N39469818: PC631.1 PR630.2
N39469863: PC632.1 PR636.1 PU602.28
N39469972: PR678.2 PU602.38
N39469996: PC611.2 PU614.2
N39469998: PC611.1 PR619.1
N39470129: PC640.1 PR646.2
N39470145: PC601.1 PR652.2
N39470173: PC632.2 PR641.1
N39470189: PH604.1 PR642.2
N39470446: PC603.1 PR602.1 PU602.34
N39470448: PC604.1 PR603.1 PU602.33
N39470528: PR608.1 PU602.32
N39470532: PR611.1 PU602.31
N40543303: RI36.2 UI5.7
N40543312: RI35.2 UI5.24
N40719702: CE57.1 RE350.2
N41288260: JNGFF2.25 RZ326.1
N41303246: CZ38.2 RZ334.1
N41840158: QN4.5 RN182.2 RN183.1 RN192.2
N41840194: QN5.2 RN184.2 RN185.1 RN186.2
N41840238: QN5.5 RN187.2 RN188.1 RN189.2
N44315031: PC947.1 PR935.1 PR947.1 PU901.29
N44519703: PR936.1 PR948.1 PU901.30
N44621211: PR933.2 PR951.2 PU901.26
N45200928: JNGFF2.67 T225.1(TP-1)
N45269008: JESPI.8 RE375.1 RE560.1
N45589397: CL17.1 TL1.4
N45589399: CL16.1 TL1.1
N45589425: CL20.1 TL1.7
N45589439: CL21.1 TL1.10
N45863109: CD31.2 RD18.1
N45863346: JDIMM1.162 T50.1(TP-1)
N45879530: JDIMM2.162 T54.1(TP-1)
N45879727: CD62.2 RD31.1
N45925426: RT378.1 UT5.D1
N45925428: RT379.1 UT5.D2
N45988164: PC119.1 PU102.16 PU102.17
N46047516: PQ8.3 PR26.2 PR28.1
N46047518: PQ8.1 PR22.1 PR27.1
N46047526: PQ8.2 PR29.2
N46050852: PQ1208.2 PQ1208.3 PR1259.1
N46050860: PQ1208.5 PR1244.2 PR1260.2 PR1261.1
N46050887: PQ1208.6 PQ1211.1 PR1234.1 PR1261.2
N46050911: PQ1211.5 PR1233.1 PR1242.2
N46050913: PQ1211.2 PR1235.1 PR1257.2
N46050923: PQ1210.5 PR1245.2
N46051012: PQ1207.6 PQ1211.4 PR1230.1 PR1258.2
N46051197: PQ1207.2 PQ1207.3 PR1232.1
N46051213: PQ1207.5 PR1241.2
N46101144: PC1206.1 PR1201.2 PR1203.1 PR1219.1 PU1201.3
N46101200: PC1205.1 PR1208.2 PR1217.1 PU1201.2
N46209617: PQ1205.2 PR1225.2
N46209621: PQ1205.1 PR1215.1 PR1226.2
N46209625: PQ1205.3 PR1221.2 PR1224.1
N46209711: PR1211.2 PU1200.1
N46209717: PR1215.2 PU1200.2
N46210543: PR1216.1 PU1200.4
N46212351: PQ1215.2 PR1251.2 PR1252.1
N46212363: PQ1214.6 PR1252.2
N46447690: QZ3.1 RZ25.1
N46814682: PH601.2 PR610.1 PR631.2
N46814700: PC627.1 PR632.2
N46814728: PH602.1 PR628.2
N46814746: PC627.2 PR638.2 PU602.8
N46814769: PC617.2 PR621.1
N46815156: PR620.2 PU602.1
N46815164: PC621.2 PR623.1
N46815166: PR621.2 PR622.2 PR623.2 PU602.5
N46815186: PC616.2 PR617.2 PU602.4
N46815188: PC614.2 PR617.1
N46815204: PR610.2 PU602.3
N46815214: PC613.2 PR613.2 PU602.2
N46816449: PC647.2 PR650.2
N46816463: PC629.2 PR639.1
N46816511: PH603.2 PR635.1 PR647.2
N46816791: PC630.1 PR640.1 PU602.20
N46816817: PC630.2 PR644.1
N46816821: PH605.1 PR657.2
N46816907: PC639.2 PR645.1
N46907385: RT380.2 UT9.32
N46924944: PR920.2 PU901.21
N46924987: PR922.2 PU901.22
N47045001: CZ56.1 RZ63.1
N47046031: JNGFF2.58 RZ132.2
N47324022: PC313.1 PU301.16 PU301.17
N48068474: PC307.2 PR308.1
N48704005: PL614.3 PR624.1
N49117945: PR932.1 PU901.27
N49618756: QC6.1 RC433.2
N49618758: CC340.1 QC7.2 RC432.2 RC433.1
N49742107: QE12.1 RE94.1
N49990748: PR687.2 PU610.1
N49990845: PR659.2 PU610.2
N49990847: PC655.2 PU610.7
N49990849: PR660.2 PU610.5
N49990851: PC655.1 PR660.1
N49990930: PR686.2 PU610.17
N49991792: PR692.2 PU613.1
N49991813: PR671.2 PU613.2
N49991827: PR672.2 PU613.5
N49991829: PC671.2 PU613.7
N49991831: PC671.1 PR672.1
N49991845: PR689.2 PU613.17
N49992706: PR681.2 PU612.17
N49992725: PL612.3 PR661.1
N49992760: PC663.2 PU612.7
N49992762: PR665.2 PU612.5
N49992764: PC663.1 PR665.1
N49992770: PR664.2 PU612.1
N49992776: PR662.2 PU612.2
N50204886: PC930.1 PR914.2
N50205391: PC944.1 PR934.2
N50261217: RV97.1 UV7.20
N50261242: CV96.1 UV7.17
N50318439: RZ62.1 UZ12.27
N50405068: RV620.2 UV6.11
N50430953: QV7.2 RV323.2 RV324.2 RV326.2
N50578362: RC436.2 UC1.F65 UC1.G65
N50694114: CE64.1 DE2.1 QE15.2 RE541.2 RE543.2 RE565.1
N50694120: QE17.1 RE546.2
N51151144: RV622.2 UV6.12
N52178133: CZ200.1 QZ1.2 RZ380.2
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N132000604: PC934.1 PR921.2
N132005053: PR917.3 PR938.2
N5026098529: T204.1(TP-1) UV7.4
N5026098531: T223.1(TP-1) UV7.2
N5026098558: T224.1(TP-1) UV7.14

Pads without a net: CLIP1 1; DV6 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 4; JKBTP1 10 17; JNGFF1 6 16 17 19 20 21 22 25 26 27 28 31 32 34 59 61 65 67 68 71 73; JNGFF2 20 22 24 28 44 46 48 56 59 61 63 65 68; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSATA1 8 20; JSIM1 4 6 8; JSPI1 17; JUSH1 2 17; PBATT1 11 12; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 9 10 12; PU401 4; PU402 4; PU503 2 6 7; PU610 6 13 16 19; PU612 6 13 16 19; PU613 6 13 16 19; PU901 13; QL2 3 4 5; QZ7 1 2 6; RC22 2; RC27 2; RC405 2; RPE12 1 2 7 8; RT75 2; RT87 1; RT88 1; RT110 1; RT339 2; RZ326 2; UA1 4 11 12 15 23 24 48; UC1 A3 A4 A11 A23 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB12 AB13 AB62 AC63 AD3 AD4 AE62 AE63 AF6 AF7 AF11 AF12 AF13 AG62 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AP1 AP2 AP3 AP4 AP13 AP56 AR56 AU56 AU58 AU63 AW1 AW13 AW20 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B11 B23 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BB2 BB4 BB7 BB9 BB11 BB57 BB66 C2 C4 C8 C11 C12 C19 C20 C23 C27 C28 C29 C31 C32 C33 C36 C37 C38 C41 C54 C70 C71 D1 D3 D4 D5 D7 D12 D19 D20 D23 D27 D28 D29 D31 D32 D33 D36 D37 D38 D41 D54 D71 E1 E2 E16 E22 E23 E25 E61 F6 F16 F18 F25 F52 F60 F61 G18 G61 H11 H63 J4 J68 J71 K45 K46 L6 M1 M2 M3 M4 N1 N2 N3 N9 N11 P1 P3 P62 U6 U7 V1 V2 V62 W7 W12; UD1 1; UE1 B8 B9; UE4 1; UE6 1; UI3 9 15; UR1 31; UT5 C1; UT7 4; UV6 13 27 28 31; UV7 31 32 34 35 58; UV24 3; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; UZ36 3; YC1 2 4; YC3 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 6225 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 948 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 188 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 87 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 57.3
  TOP w0.102: v1(67.03,18.12) v2(66.65,18.5) 66.45,18.7 RD19.1 65.34,18.37 UD1.4
  IN3 w0.122: v1(42.98,53.53) 40.3,53.53 38.99,52.22 38.99,41.56 62.43,18.12 v1(67.03,18.12)
  BOTTOM w0.254: PR210.1 v1(42.98,53.53)
1.8V_PRIM_PWRGD: length 320.3
  TOP w0.102: RE361.2 296.22,66.09 v1(296.05,65.92)
  TOP w0.107: v1(303.96,76.33) UE1.L7
  TOP w0.254: PU501.5 123.05,108.81 122.18,109.68 v1(121.99,109.68) PR517.1
  IN3 w0.122: v1(296.05,65.92) 295.86,65.73 295.86,63.96 293.92,62.02 293.92,60.16 294.35,59.73 294.35,58.92 294.14,58.71 294.14,56.6 293.19,55.66 293.19,54.02 292.28,53.12 292.28,52.91 291.67,52.29 290.54,52.29 289.93,51.68 288.89,51.68 287.85,50.64 287.85,47.42 286.5,46.07 283.49,46.07 282.5,45.07 282.5,42.25 280.7,40.45 280.7,38.38 280.17,37.85 280.17,37.29 279.55,36.67 279.55,35.79 277.23,33.47 259.08,33.47 257.53,31.93 249.37,31.93 247.54,30.09 243.48,30.09 238.31,24.92 236.67,24.92 236.04,25.56 228.06,25.56 227.3,24.79 222.31,24.79 220.33,26.77 211.85,26.77 210.88,25.8 209.29,25.8 207.39,27.69 205.37,27.69 202.84,30.22 200.61,30.22 200.55,30.28 200.09,30.28 187.08,43.3 181.64,43.3 162.76,62.18 162.76,69.62 160.69,71.7 160.69,82.42 153.68,89.42 v1(153.68,91.01)
  IN4 w0.089: v1(314.46,75.01) 313.44,76.03 311.41,76.03 310.9,75.52 304.77,75.52 v1(303.96,76.33)
  BOTTOM w0.102: v1(314.46,75.01) 314.46,74.8 315.98,73.27 315.98,71.42 316.24,71.16 318.1,71.16 319.25,70.01 319.25,62.19 318.81,61.75 316.82,61.75 312.63,65.94 306.94,65.94 306.68,66.2 306.68,67.54 305.76,68.47 301.6,68.47 300.56,67.43 300.56,65.3 299.03,63.76 298.06,63.76 296.05,65.77 v1(296.05,65.92) ; v1(153.68,91.01) 153.68,92.61 151.78,94.52 v2(145.23,94.52) 142.61,91.9 137.71,91.9 128.88,100.73 125.48,100.73 125.04,101.17 125.04,103.59 124.4,104.22 122.75,104.22 121.99,104.98 v1(121.99,109.68)
2.5VSP: length 4.3
  TOP w0.254: PC515.1 190.98,4.2 190.98,6.27 191.16,6.45 PC516.1
  TOP w0.381: PC515.1 191.01,3.31 PR515.1
  vias: v2(192.09,5.25)
3.3V_CAM_EN#: length 120.8
  TOP w0.076: v1(128.88,50.47) 128.88,50.51 129.26,50.88 129.54,50.88 129.54,50.88 129.87,50.88 129.87,50.88 130,50.88 130.17,50.71 130.17,49.53 130.35,49.35
  TOP w0.102: RC311.1 133.99,45.71 130.35,49.35 ; v1(155.38,80.31) 155.38,81.65 148.7,88.33 v2(148.7,88.52) 146.75,90.47 145.72,90.47 144.78,91.41 131.63,91.41 127.08,86.85 118.29,86.85 117.03,85.59 v1(115.71,85.59)
  IN4 w0.089: v1(128.88,50.47) 128.88,50.5 129.25,50.87 129.99,50.87 130.2,50.66 130.2,49.68 130.48,49.4 131.05,49.4 131.21,49.24 136.13,49.24 138.24,47.13 140.17,47.13 142.92,49.87 145.71,49.87 146.81,50.97 152.32,50.97 153.63,52.28 153.63,55.73 152.29,57.07 151.86,57.07 150.75,58.18 150.75,64.61 150.58,64.79 150.58,67.92 151.81,69.15 151.81,74.96 154.53,77.69 154.53,79.18 155.38,80.03 v1(155.38,80.31)
  BOTTOM w0.102: UC1.AT15 129.26,50.85 v1(128.88,50.47) ; v1(115.71,85.59) 115.25,85.13 RZ380.1
3.3V_TS_EN: length 248.3
  TOP w0.102: RE547.1 v1(309.31,77.42) ; v1(188.41,26.39) v2(188.41,27.11) ; v1(163.2,57.8) 159.33,57.8 159.2,57.93 153.81,57.93 RV323.1
  TOP w0.107: v1(302.36,76.33) UE1.J7
  IN1 w0.089: v1(188.41,26.39) 193.56,26.39 200.25,19.7 200.77,19.7 201.6,18.88 203.8,18.88 204.29,18.39 216.71,18.39 217.56,17.54 219.52,17.54 220.41,18.43 222.51,18.43 223.28,19.2 229.12,19.2 232.72,22.8 242.05,22.8 243.39,24.14 251.28,24.14 251.47,24.33 253.53,26.4 255.3,26.4 258.96,30.05 281.06,30.05 281.88,30.88 283.6,30.88 286.59,33.87 286.59,34.53 290.34,38.28 290.34,39.17 290.66,39.5 292.3,39.5 296.5,43.7 297.25,43.7 298.02,44.47 298.02,45.88 299.79,47.64 301.04,47.64 301.69,48.29 301.69,48.48 302.14,48.92 302.14,49.29 302.71,49.87 303.54,49.87 303.85,50.18 303.85,51.81 305.05,53.01 305.05,55.39 305.6,55.94 305.6,57.54 304.9,58.25 304.55,58.25 304.04,58.76 304.04,60.02 305.57,61.54 305.57,62.57 306.58,63.58 306.58,64.46 307.7,65.57 308.89,65.57 309.44,66.12 310.84,66.12 311.85,67.14 311.85,67.44 312.55,68.14 312.55,73.42 310.84,75.14 310.84,76.22 309.63,77.42 v1(309.31,77.42) 307.66,77.42 307.47,77.62 305.5,77.62 304.81,76.92 303.66,76.92 303.47,76.73 302.76,76.73 v1(302.36,76.33)
  BOTTOM w0.102: v1(163.2,57.8) 182.25,57.8 183.14,56.91 186.95,56.91 187.2,56.66 187.2,53.49 184.85,51.14 184.85,47.9 185.49,47.26 185.49,44.34 183.71,42.56 183.71,33.29 188.41,28.59 v1(188.41,26.39)
3.3V_WWAN_EN: length 57.3
  TOP w0.102: v1(278.12,48.32) 280,48.32 v2(281.31,49.63) 283.15,51.47 283.15,52.25 283.93,53.03 283.93,53.92 284.56,54.55 286.09,54.55 286.42,54.22 286.42,53.46 287.72,52.16 291.5,52.16 292.46,53.12 292.46,53.89 292.22,54.13 v1(292.22,54.2) ; v1(296.76,75.53) UE1.C6
  IN3 w0.122: v1(296.76,75.53) 296.36,75.92 295.52,75.92 295.25,75.66 295.25,73.6 295.05,73.4 295.05,71.14 294.47,70.55 294.47,66.26 294.65,66.08 294.65,63.44 293.47,62.27 293.47,59.97 293.66,59.78 293.66,56.86 292.68,55.88 292.68,54.66 v1(292.22,54.2)
  BOTTOM w0.102: UZ2.3 273.88,49.78 273.54,50.13 273.54,50.82 273.39,50.97 RZ40.2 272.42,50.18 272.42,48.66 272.83,48.25 275.54,48.25 275.61,48.32 v1(278.12,48.32)
3V5V_EN: length 35.1
  TOP w0.254: v1(153.04,112.92) 153.35,112.61 PU100.12
  IN4 w0.254: v1(153.04,112.92) 153.88,113.76 153.88,118.28 154.68,119.08 168.39,119.08 169.67,117.8 173.12,117.8 174.06,116.86 174.06,115.6 v1(174.07,115.59)
  BOTTOM w0.102: v1(153.04,112.92) v2(152.34,112.92)
  BOTTOM w0.254: PU102.12 170,115.07 170.52,115.59 PC128.1 PR116.1 PR114.2 v1(174.07,115.59)
3V_FB: length 2.7
  TOP w0.102: PC113.1 152.45,113.06 v2(152.07,113.44)
  TOP w0.254: PC113.1 152.76,112.16 153.89,112.16 PU100.13
3V_SN: length 1.9
  BOTTOM w0.102: PR106.2 v2(158.95,110.95)
3V_VIN:
  vias: v1(157.97,115.02) v1(157.95,114.41) v1(158.27,113.89) v1(158.56,115.02) v1(158.56,114.41) v2(158.42,115.51)
5V_FB: length 2
  BOTTOM w0.254: PC127.1 v1(170.29,114.63) 170.28,114.62 PU102.13
5V_SN: length 0.9
  TOP w0.102: v1(161.68,107.1) v3(161.68,106.24)
5V_VIN: length 0.9
  TOP w0.102: v1(164.03,116.35) v3(164.03,115.44)
  vias: v1(163.52,116.67) v1(164.03,116.99)
+0.6V_DDR_VTT: length 5.6
  TOP w0.127: 49.92,52.34 v3(50.81,52.34)
  BOTTOM w0.254: v1(106.73,6.75) 105.89,6.75 105.53,6.39 JDIMM1.258 ; JDIMM2.258 186.53,5.82 v1(187.05,6.34)
  vias: v1(49.6,52.79) v1(49.6,52.15) v1(107.4,6.65) v1(107.45,7.23) v1(189.84,7.31) v1(190.46,7.32)
+0.6VSP:
  vias: v1(46.84,51.9) v1(47.47,51.91) v2(46.68,52.43)
+0.9V_LAN: length 12.3
  TOP w0.203: v1(282.2,87.98) 282.2,87.86 281.75,87.42 UL1.11 ; UL1.37 276.06,82.16 v1(275.76,81.86) ; UL1.22 v1(276.86,89.68) ; v1(282.3,86.3) 282.22,86.22 UL1.8 ; UL1.40 v1(277.26,81.7) ; UL1.43 v1(278.46,81.61)
  TOP w0.254: CL8.1 273.95,80.57 v1(273.52,80.14) ; v1(279.28,90.06) 279.15,89.93 279.15,89.43 279.26,89.32 UL1.16
  BOTTOM w0.254: CL11.1 278.77,89.55 v1(279.28,90.06) ; v1(275.76,81.86) 275.98,81.86 276.23,82.11 CL9.1 ; CL10.1 276.99,81.97 v1(277.26,81.7)
  vias: v1(280.71,81.41) v1(280.98,81.93) v1(284.74,87.5) v1(285.32,87.47) v1(285.88,87.22) v2(280.54,82.76)
+1.0V_AMPHYPLL: length 9
  TOP w0.127: 147.35,69.23 147.35,68.29 v2(147.2,68.14)
  IN3 w0.508: 138.18,69.74 138.31,69.74 139.02,70.45 v1(144.63,70.45)
  BOTTOM w0.254: UC1.K15 v1(129.68,63.86) UC1.L15
+1.0V_APLL: length 12.1
  TOP w0.508: LC2.2 145.47,61.31 CC323.1 142.98,61.31 142.27,60.6 137.17,60.6 136.47,59.9 134.73,59.9 134.61,60.02
  BOTTOM w0.254: UC1.V15 129.62,60.09 129.77,60.24 v1(129.86,60.24)
  vias: v2(133.74,60.65)
+1.0V_APLLEBB: length 2.8
  TOP w0.127: CC325.1 126.44,61.07 v2(127.08,60.42)
  TOP w0.381: CC325.1 126.48,61.51 127.06,62.09 v1(127.06,62.19)
  BOTTOM w0.254: v1(127.06,62.19) UC1.N18
  vias: v1(143.69,72.87)
+1.0V_CLK1: length 20.1
  TOP w0.508: RC302.2 131.6,86.17 131.6,83.84 130.18,82.42 130.18,79.96 132.21,77.93 132.21,76.97 v1(133.09,76.08)
  BOTTOM w0.203: 130.9,72.08 130.4,71.59 130.4,71.21 129.66,70.47 129.66,69.5 129.66,69.5 UC1.A14
  BOTTOM w0.508: v1(133.09,76.08) 132.47,75.46 132.47,73.65 v2(131.63,72.81) 130.9,72.08
+1.0V_CLK2: length 15.2
  TOP w0.508: 127.92,67.38 127.92,69.64 129.47,71.19 129.47,74.66 127.45,76.68 127.45,79.71 126.85,80.31
  BOTTOM w0.254: UC1.K19 126.74,64.18 v1(127.06,63.86)
  vias: v2(126.85,64.61)
+1.0V_CLK3: length 7.9
  TOP w0.508: RC303.2 v1(128.26,77.97)
  IN3 w0.508: v1(128.26,77.97) 128.26,76.53 129.67,75.11 129.67,73.86
  BOTTOM w0.127: v1(128.26,77.97) 128.15,77.86 128.15,77.44 v2(128.11,77.4)
  BOTTOM w0.254: v1(125.76,63.86) UC1.L21
+1.0V_CLK4: length 17.3
  IN3 w0.254: 125.25,69.16 125.25,67.92 124.7,67.37 124.7,64.98 124.78,64.9 124.78,64.23 124.6,64.05 124.6,62.84 125.26,62.18 v1(125.76,62.18)
  IN3 w0.508: v1(125.4,77.48) 125.4,75.82 125.74,75.48 125.74,72.83 125.25,72.35 125.25,69.16
  BOTTOM w0.254: v1(125.76,62.18) UC1.N20
  vias: v2(124.45,78.49)
+1.0V_CLK5: length 21.7
  TOP w0.305: RC52.2 125.17,62.39 125.69,62.91 126.3,62.91 v1(126.41,63.02)
  IN3 w0.508: 127.93,68.59 130.03,70.69 130.03,71.41 131.96,73.34 131.96,77.74 132.91,78.69 134.56,78.69 135.32,79.46 135.32,83.38 v1(135.12,83.58)
  BOTTOM w0.254: v1(126.41,63.02) UC1.L19
  vias: v2(136.56,83.28)
+1.0V_CLK6: length 24.4
  TOP w0.508: v1(133.93,76.16) 133.1,77 133.1,77.91 130.79,80.22 130.79,81.48 131.32,82.01 136.35,82.01 136.97,82.63 137.36,82.63 137.77,83.05 137.77,83.89 137.69,83.98 CC106.1 CC107.1 137.6,85.02 RC300.2
  BOTTOM w0.203: UC1.A10 132.14,69.84 132.54,70.24 132.54,71.15 133.74,72.35 133.74,74.31
  BOTTOM w0.508: v1(133.93,76.16) v2(133.93,75.33) 133.93,74.51 133.74,74.31
+1.0V_DTS: length 9.7
  TOP w0.508: v1(138.5,62.31) 138.6,62.31 v2(141.95,65.66) 143.74,67.46 RC301.2
  BOTTOM w0.203: v1(138.5,62.31) 137.75,61.56 UC1.T1
+1.0V_MPHYAON: length 7.5
  TOP w0.508: 135.36,69.36 136.66,68.06 136.66,65.46 v1(137.88,64.23)
  BOTTOM w0.254: v1(127.71,63.86) UC1.K17 ; v1(137.88,64.23) 137.65,64.23 137.63,64.21 UC1.L1
  vias: v1(133.88,77.88) v1(133.88,77.25) v1(134.52,77.88) v1(134.52,77.25) v1(135.1,77.88) v1(135.1,77.24) v2(133.14,77.98)
+1.0V_MPHYGT: length 2.8
  BOTTOM w0.254: UC1.N15 129.03,62.29 v1(129.03,62.18) 129.03,62.07 UC1.P15 ; UC1.N16 129.01,62.92 v1(129.01,63.02) ; UC1.P16 128.69,61.8 128.38,62.11 v1(128.38,62.18) 128.38,62.26 UC1.N17
  vias: v1(119.99,78.86) v1(120.53,79.16) v1(120.53,78.55) v1(120.91,79.75) v1(121.14,79.16) v1(121.14,78.55) v1(136.33,89.94) v1(136.33,89.29) v1(136.96,89.96) v1(136.97,89.28) v1(137.55,89.95) v1(137.59,89.32) v1(155.03,64.44) v1(155.66,64.43) v1(156.16,66.12) v1(156.18,65.53) v3(127.86,62.77)
+1.0V_PRIM: length 98.1
  TOP w0.381: CC92.1 CC93.1 127.94,61.59 v1(127.67,61.32)
  TOP w0.508: LC2.1 145.52,62.11 v1(146.26,62.11) ; v1(132.59,83.11) 132.34,83.36 132.34,85.4 132.59,85.65 RC302.1 ; RC171.1 137.41,86.89 v1(138.82,86.89) ; RC216.1 67.12,24.97 76.52,24.97 83.89,32.34 92.37,32.34 v4(95.23,35.2) ; v1(129.14,82.95) 128.26,82.07 RC303.1 ; v1(126.37,84.35) 126.37,83.94 v3(126,83.57) 125.46,83.04 RC170.1 ; RC300.1 138.51,85.95 v1(138.82,86.25)
  IN1 w0.508: v1(146.26,62.11) 146.21,62.07 144.89,62.07 143.74,63.21 v1(143.74,64.79)
  IN2 w0.508: v4(95.23,35.2) 115.15,35.2 118.85,38.91 118.85,44.98 119.36,45.48 121.82,45.48 122.33,45.99 122.33,47.72 123.32,48.71 123.32,49.68
  BOTTOM w0.203: UC1.AK20 125.71,53.99 125.58,53.86 124.96,53.86 v1(124.92,53.9)
  BOTTOM w0.254: v1(127.71,59.67) 127.39,59.34 UC1.Y18 127.8,58.83 127.8,58.65 UC1.AB17 ; UC1.AB20 126.09,58.36 v1(126.39,57.97) 126.39,58.06 UC1.AB19 126.78,58.41 v1(127.09,58.02) ; UC1.P18 127.67,61.4 v1(127.67,61.32)
  vias: v1(124.37,55.2) v1(124.95,54.86) v1(139.45,86.89) v1(139.45,86.25) v1(140.09,86.89) v1(140.09,86.25) v1(140.72,86.89) v1(140.72,86.25) v1(162.63,83.33) v1(162.63,82.06) v1(163.01,82.7) v1(163.01,81.49) v1(163.33,83.33) v1(163.33,82.06) v1(163.39,80.92) v1(163.71,82.7) v1(163.71,81.49) v1(164.03,82.06) v1(164.09,80.92) v1(164.41,82.7) v1(164.41,81.49)
+1.0V_PRIM_CORE: length 5.6
  TOP w0.127: 135.9,101.87 v3(137.04,101.87)
  TOP w0.381: v1(127.06,56.31) 126.89,56.49 CC90.1 CC91.1
  BOTTOM w0.254: v1(125,60.42) 124.79,60.22 v1(124.79,59.82) 125.23,59.82 UC1.V21 125.51,60.01 126.01,60.01 UC1.V20 ; UC1.AF19 v1(127.06,56.31) UC1.AF18
  vias: v1(134.68,102.15) v1(135.29,102.2) v1(135.34,102.91) v1(135.87,102.63) v1(148.89,53.17) v1(149.51,53.16) v1(150.16,53.16) v1(150.75,53.16)
+1.0V_PRIM_COREP: length 9.3
  TOP w0.254: PU402.1 130.08,110.44 v1(129.61,109.97) ; 133.48,107.97 134.67,109.16 PR423.2
  IN1 w0.254: v1(132.8,107.78) 133.2,108.18 133.2,109.37 132.6,109.97 v1(129.61,109.97)
  vias: v2(132.63,105.42)
+1.0V_PRIM_XDP: length 162.9
  TOP w0.127: v2(128.96,86.25) RC115.2
  TOP w0.254: CC28.1 64.95,27.73 JXDP1.44 ; JXDP1.43 64.95,36.9 64.34,37.52 64.34,38.32 CC29.1 63.95,38.33 63.95,37.91 v1(63.84,37.79)
  TOP w0.305: RC138.2 75.06,39.85 v1(75.21,40) ; CC28.1 64.9,27.88 v1(65.51,28.49)
  TOP w0.508: v1(66.92,28.43) 66.44,28.43 65.92,27.9 RC216.2 ; RC115.2 v1(129.9,85.49)
  IN3 w0.508: v1(129.9,85.49) 128.81,86.58 118.9,86.58 118.32,87.17 117.07,87.17 116.11,86.2 113.51,86.2 112.63,87.08 109.88,87.08 108.44,88.51 101.3,88.51 100.46,89.35 99.04,89.35 98.2,88.51 94.75,88.51 93.99,87.75 93.99,86.76 93.4,86.17 88.79,86.17 87.32,87.65 83.52,87.65 82.44,88.73 71.95,88.73 71,89.68 68.89,89.68 67.85,88.64 65.18,88.64 58.86,82.31 57.79,82.31 55.96,80.49 54.06,80.49 48.52,74.95 47.31,74.95 44.2,71.84 44.2,53.36 42.63,51.78 41.04,51.78 39.7,50.45 39.7,44.72 43.97,40.46 60.7,40.46
+1.0V_SRAM: length 3.4
  TOP w0.381: v1(125.76,57.13) 125.47,57.42 CC109.1 CC108.1
  BOTTOM w0.254: UC1.AF21 125.44,56.8 v1(125.76,57.13) 126.09,56.8 UC1.AF20 ; UC1.T20 126.29,60.72 126.29,60.6 126.32,60.57 126.32,60.52 v1(126.35,60.49) 126.74,60.87 UC1.T19
  vias: v1(121.54,72.82) v1(121.89,72.19) v2(118.24,78.89)
+1.0V_VCCST: length 431.7
  TOP w0.508: RE59.1 v1(305.65,88.11) ; RE90.1 v1(281.31,74.69) ; v1(122.64,82.97) 123.05,82.97 124.27,81.75 CC202.1 124.03,79.96 v3(124.03,78.63) 124.03,77.11 125.78,75.36 125.78,72.67 126.73,71.73 126.73,70.22 v1(126.99,69.96) ; v1(64.9,40.02) 64.39,40.53 RC218.2 ; v1(125.11,63.86) 125.02,63.77 CC195.1
  IN1 w0.508: v1(305.65,88.11) 304.97,87.43 302.86,87.43 300.28,90.01 298.43,90.01 297.67,90.77 292.92,90.77 291.91,91.78 286.14,91.78 283.91,89.55 283.91,86.7 284.36,86.25 284.36,84.79 284.75,84.39 284.75,83.67 283.61,82.53 278.37,82.53 277.86,82.03 277.86,81.22 278.39,80.68 278.81,80.68 280.01,79.48 280.01,76.42 280.6,75.84 280.6,75.15 281.06,74.69 v1(281.31,74.69)
  IN2 w0.508: v1(145.8,86.76) 145.47,86.43 142.34,86.43 138.8,82.89 133.68,82.89 133.19,82.4 132.27,82.4 130.76,83.91 127.97,83.91 127.54,83.48 125.6,83.48 125.46,83.62 v1(122.45,83.62)
  IN3 w0.254: v1(125.11,63.86) 125.16,63.9 125.16,64.57 125.66,65.07 125.66,68.75 126.87,69.96 v1(126.99,69.96)
  IN3 w0.508: 277.99,56.24 276.89,55.14 276.89,54.71 277.19,54.41 277.19,53.09 276.66,52.57 276.66,51.83 275.04,50.22 275.04,49.36 274.77,49.09 274.77,48.73 ; 272.68,48.43 272.1,48.43 271.72,48.05 271.02,48.05 269.34,46.37 268.78,46.37 268.24,45.83 268.24,45.09 265.43,42.28 263.63,42.28 263.07,42.84 257.59,42.84 256.68,41.93 v1(255.63,41.93)
  IN4 w0.508: v1(98.38,78.24) 97.95,78.66 92.25,78.66 89.62,81.3 89.62,82.8 88.91,83.51 88.91,85.18 87.84,86.25 87.83,86.25 87.38,86.7 87.38,88.47 85.98,89.87 68.97,89.87 67.12,88.03 66.36,88.03 65.79,87.46 65.79,84.73 63.64,82.58 62.65,82.58 60.69,80.61 60.69,77.89 58.88,76.09 54.3,76.09 44.61,66.39 44.61,65.21 40.86,61.46 40.86,57.62 42.05,56.43 52.06,56.43 53.62,54.86 58.85,54.86 59.67,55.68 71.34,55.68 73.09,53.93 73.09,53.53 73.54,53.08 73.54,51.13 v1(72.78,50.37) 72.52,50.37 71.38,49.22 71.38,48.42 70.52,47.56 67.28,47.56 66.56,48.28 65.16,48.28 63.51,46.63 63.51,43.15 64.9,41.75 v1(64.9,40.02)
  BOTTOM w0.152: v1(126.99,69.96) 127.18,69.76 UC1.A18
  BOTTOM w0.254: UC1.K20 125.99,64.28 125.95,64.31 125.57,64.31 125.53,64.28 UC1.K21 125.44,64.18 v1(125.11,63.86) ; RC71.2 v1(97.67,80.69) ; v1(98.68,80.6) RC120.2 98.7,79.93 RC80.2
  BOTTOM w0.508: RC157.2 98.68,77.93 v1(98.38,78.24) ; RC79.2 v1(101.61,77.23) ; RC152.2 v1(99.7,78.38) ; PC602.1 72.4,50.37 v1(72.78,50.37) 73.02,50.37 73.43,50.78 PR601.1 PR604.1 PR605.1 ; v1(145.8,86.76) 145.8,88.66 145.04,89.43 RZ151.2 145.04,91.52 147.15,93.63 151.56,93.63 153.04,92.16 153.04,89.93 160.41,82.57 160.41,78.19 162.06,76.54 165.88,76.54 166.36,76.06 171.41,76.06 188.17,59.29 188.17,55.31 200.16,43.32 203.04,43.32 204.09,42.27 204.73,42.27 205.45,41.55 205.87,41.55 210.38,37.04 217.94,37.04 220.44,34.54 240.02,34.54 243.64,38.16 248.78,38.16 252.55,41.93 v1(255.63,41.93)
+1.0V_VCCST_C: length 0.6
  BOTTOM w0.127: v2(125.09,85.03) 125.09,84.47
+1.0V_VCCSTG: length 200.2
  TOP w0.305: v1(50.24,27.82) 50.81,28.39 RC131.2
  TOP w0.508: v1(53.73,37.41) RC135.2 ; 123.22,69.46 123.22,68.04 122.74,67.56 122.74,66.11 122.29,65.66 RC143.2 ; RC134.2 v1(50.82,36.73)
  TOP w0.762: v1(144,89.1) 144,89.45 142.59,90.86 135.34,90.86 134.27,89.79 131.33,89.79 127.84,86.3 118.65,86.3 117.14,84.79 v3(116.18,84.79) 114.83,84.79 113.87,83.84 113.87,81.2 v1(113.06,80.38) ; v1(114.08,79.8) 114.31,79.57 115,79.57 119.41,75.16 119.41,71.8 121.47,69.74
  IN2 w0.508: v1(94.06,81.81) 93.21,81.81 92.4,82.63 84.27,82.63 82.75,84.16 80.02,84.16 78.81,82.95 71,82.95 70.29,83.66 69.27,83.66 67.7,85.24 63.45,85.24 62.49,84.27 61.93,84.27 45.05,67.39 43.19,67.39 39.69,63.9 39.69,44.98 42.42,42.25 42.42,41.65 47.34,36.73 v1(50.82,36.73) 53.05,36.73 v1(53.73,37.41)
  IN3 w0.508: 102.21,79.77 95.76,79.77 94.06,81.48 v1(94.06,81.81)
  IN4 w0.508: v1(50.82,36.73) 50.08,36.73 44.91,31.56 44.91,25.14 46.74,23.31 48.98,23.31 50.61,24.95 50.61,27.44 v1(50.24,27.82)
  BOTTOM w0.203: UC1.A22 124.7,69.89 124.5,70.1 v1(124.39,70.1)
  BOTTOM w0.381: RC81.2 RC130.2 RC87.2
  BOTTOM w0.508: RC82.2 v1(105.8,80.56) ; RC130.2 v1(102.75,80.56) ; v1(94.06,81.81) 93.66,81.42 RC83.2
  vias: v1(143.13,89.12)
+1.0V_VCCSTG_C: length 14.9
  BOTTOM w0.508: UZ19.6 131.89,84.13 132.24,84.47 132.24,85.57 133,86.33 135.26,86.33 v2(136.03,85.56) 136.1,85.49 140.96,85.49 142.49,87.01 143.52,87.01
+1.0V_VCCSTG_R: length 0.5
  BOTTOM w0.254: v1(126.12,65.94) UC1.G20
  vias: v2(125.59,67.75)
+1.0VO_DSW: length 6.9
  TOP w0.254: v1(137.63,53.39) 137.44,53.21 v2(136.07,53.21) 136.02,53.26 134.13,53.26 133.67,53.71 133.22,53.71 CC89.1 133.16,53.98 132.97,54.17 132.05,54.17 CC88.1
  BOTTOM w0.254: v1(137.63,53.39) 137.35,53.39 UC1.AL1
+1.0VS_VCCIO: length 348
  TOP w0.305: RC2.2 108.43,69.07 107.89,69.61 106.18,69.61 105.54,70.25 v1(105.54,73.42)
  TOP w0.508: QE11.1 v1(281.21,70.44) ; RC132.2 v1(63.38,39.9)
  IN2 w0.508: v1(142.37,100.98) 140.47,100.98 139.07,99.59 138.05,99.59 137.65,99.18 116.37,99.18 114.94,97.74 94.98,97.74 93.68,99.05 88.09,99.05 84.08,95.05 84.08,93.93 84.4,93.62 v1(84.78,93.62)
  IN3 w0.508: 281.6,57.66 281.6,58.91 282.35,59.66 282.35,60.32 282.93,60.9 282.93,65.22 281.21,66.94 v1(281.21,70.44) ; v1(255.07,41.32) 255.22,41.17 256.81,41.17 257.81,42.16 262.77,42.16 263.33,41.6 265.66,41.6 267.94,43.88 269.5,43.88 269.82,44.2 270.32,44.2 273.62,47.5 275.36,47.5 275.87,48 275.87,49.31 276.57,50.02 276.57,50.86 277.28,51.56 277.28,52.3 277.84,52.86 277.84,54.35 278.67,55.18 278.93,55.18 279.77,56.02 ; v1(63.38,39.9) 62.49,39.01 62.49,36.94 63.18,36.25 82.03,36.25 85.2,39.42 97.4,39.42 101.97,34.85 110.48,34.85
  IN3 w3.302: 170.25,19.26 170.24,19.25 123.55,19.25 113.92,28.87 113.92,32.86
  IN4 w0.508: v1(105.54,73.42) 105.54,74.08 103.38,76.24 103.38,78.5 104.25,79.37 104.25,81.2 101.73,83.71 101.73,84.6 99.57,86.76 99.57,87.52 98.3,88.79 90.62,88.79 89.67,89.74 88.65,89.74 v1(84.78,93.62)
  BOTTOM w0.254: UC1.AL42 v1(114.23,53.06) UC1.AM42 v1(113.32,53.06)
  BOTTOM w0.508: v1(255.07,41.32) 252.8,41.32 249.02,37.54 243.88,37.54 240.27,33.93 226.33,33.93 225.47,33.07 221.86,33.07 221.2,33.72 214.68,33.72 213.97,33.01 205.41,33.01 203.78,31.39 201,31.39 195.28,37.1 v1(195.28,41.22)
  vias: v1(119.72,53.06) v1(120.63,54.62) v1(120.63,53.06) v1(202.43,13.66) v1(202.42,13.03) v1(203.02,13.66) v1(203.02,13.03) v1(203.63,13.66) v1(203.62,13.05) v3(168.66,83.71)
+1.2V_DDR_B+:
  vias: v1(42.04,46.87) v1(42.76,46.84) v1(43.47,46.84) v1(44.1,46.83) v2(44.1,46.22)
+1.2V_DDRP: length 19.9
  BOTTOM w0.254: PC216.1 48.63,41.86 47,41.86 46.19,42.67 PC217.1 46.19,44.63 PR204.1 PC208.1
  BOTTOM w0.508: 48.84,51.56 55.29,51.56 56.86,49.99 56.86,44.42
  vias: v1(50.86,41.77) v1(51.38,41.17) v1(51.49,41.77) v1(52.01,41.17) v1(52.13,41.77) v1(52.65,41.17) v1(52.76,41.77) v1(53.28,41.17) v1(53.4,41.77) v1(53.92,41.17) v1(54.03,41.77) v1(54.55,41.17) v1(55.69,44.66) v1(55.69,44.02) v1(55.69,43.39) v1(55.69,42.75) v1(55.69,42.12) v3(55.76,41.29)
+1.2V_LDO: length 5.4
  IN4 w0.508: v1(28.33,53.52) 28.33,52.85 27.61,52.14 25.13,52.14 24.77,52.5 24.77,53.23 v1(24.77,53.23)
  vias: v2(27.69,53.29)
+1.2V_MEM: length 113.9
  TOP w0.203: RC231.2 111.37,53.66 111.03,53.32 111.03,51.67
  TOP w0.356: v1(90.78,11.75) 90.52,12.01 CD32.1
  BOTTOM w0.152: UC1.BB32 119.63,46.55 v1(119.64,46.54)
  BOTTOM w0.178: v1(111.06,46.5) 111.02,46.54 UC1.BB47 ; UC1.BB23 124.65,47.46 124.65,46.36 124.8,46.21 v1(124.8,46.16)
  BOTTOM w0.203: UC1.BB41 114.59,47.4 114.59,46.54 114.62,46.51 v1(114.61,46.51) ; UC1.BB51 108.57,46.56 v1(108.52,46.51) ; UC1.AU28 120.96,50.2 120.63,50.53 v1(120.63,50.55)
  BOTTOM w0.254: v1(52.71,6.62) 52.52,6.44 JDIMM1.54 ; v1(47.86,14.55) 47.27,13.96 JDIMM1.33 ; JDIMM2.153 160.28,14.12 161.15,15 v1(162.12,15) ; v1(166.31,7.13) 166.53,6.92 JDIMM2.178 ; v1(116.98,50.52) 117.23,50.27 117.36,50.27 UC1.AU35 ; v1(133.41,6.67) 133.53,6.55 JDIMM2.54 ; JDIMM1.112 v1(67.03,6.08) ; JDIMM2.220 177.03,6.26 v1(176.55,6.73) ; JDIMM1.148 78.03,3.49 v1(77.86,3.32) ; v1(152,14.52) 152.18,14.7 154.5,14.7 155.28,13.92 JDIMM2.141 ; JDIMM1.136 73.03,3.94 73.72,3.24 74.47,3.24 v1(74.53,3.29) ; JDIMM1.160 81.03,5.63 81.27,5.88 81.27,6.38 v1(81.03,6.62) ; v1(113.35,50.52) 113.45,50.52 UC1.AU42 ; JDIMM1.12 42.03,5.91 v1(42.16,6.05) ; v1(138.92,14.27) 138.78,14.12 JDIMM2.75 ; v1(79.27,14.63) 79.28,14.63 JDIMM1.153 ; JDIMM1.96 63.03,6.35 v1(63.47,6.8) ; JDIMM2.12 v1(123.03,6.15) ; v1(181.74,11.1) 182.28,11.63 JDIMM2.241 ; JDIMM2.148 v1(159.03,3.57) ; v1(81.95,14.72) 81.95,14.15 81.78,13.97 JDIMM1.163 ; JDIMM2.199 171.78,12.02 171.52,11.76 v1(171.25,11.76) ; JDIMM2.147 158.78,11.31 v1(158.19,10.72) ; JDIMM2.96 v1(144.03,3.57) ; JDIMM1.178 v1(85.53,6.07) ; JDIMM1.75 v1(57.78,14.78) ; v1(79.38,3.45) 79.53,3.59 JDIMM1.154 ; JDIMM1.130 v1(71.53,3.21) ; v1(162.11,14.39) 162.29,14.39 162.78,13.91 JDIMM2.163 ; v1(123.37,50.55) 123.37,50.55 123.65,50.27 123.76,50.27 UC1.AU23 ; JDIMM1.199 v1(90.78,11.75) ; JDIMM2.33 v1(128.28,11.6) ; JDIMM1.124 v1(70.03,3.15)
  BOTTOM w0.305: JDIMM2.112 v1(148.03,3.57) ; v1(152,14.52) 151.87,14.39 151.21,14.39 150.78,13.96 JDIMM2.123 ; JDIMM2.159 161.78,14.06 v1(162.11,14.39) ; v1(102.78,10.08) 102.49,10.08 101.28,11.3 JDIMM1.241 ; JDIMM2.142 v1(155.53,3.57) ; v1(66.78,14.31) JDIMM1.111 ; JDIMM2.124 v1(151.03,3.57) ; JDIMM2.160 162.03,3.95 161.57,3.49 v1(160.53,3.49) JDIMM2.154 ; JDIMM1.159 80.78,13.86 81.28,14.37 v1(81.41,14.37) ; JDIMM2.129 152.28,13.97 v1(152.47,14.17) 153.54,14.17 153.78,13.93 JDIMM2.135 ; v1(78.73,14.29) 78.21,14.29 77.78,13.86 JDIMM1.147 ; JDIMM1.129 71.27,14.01 71.58,14.32 v1(71.66,14.32) 72.63,14.32 72.78,14.18 JDIMM1.135 ; JDIMM1.141 74.27,14.05 v1(74.6,14.37) ; JDIMM2.118 v1(149.52,3.54) ; JDIMM1.117 68.27,14.06 68.76,14.55 69.75,14.55 v1(69.88,14.42) 69.88,14.24 69.78,14.14 JDIMM1.123 ; JDIMM2.117 149.28,14.03 149.74,14.49 150.58,14.49 151.04,14.95 v1(151.59,14.95) ; JDIMM2.136 v1(154.03,3.57) ; v1(152.53,3.57) JDIMM2.130 ; v1(147.3,14.27) 147.5,14.27 147.78,13.99 JDIMM2.111 ; JDIMM1.220 v1(96.03,6.08)
  BOTTOM w0.381: JDIMM1.142 v1(74.53,3.29) ; JDIMM1.118 v1(68.52,3.13)
  vias: v3(72.14,18.05)
