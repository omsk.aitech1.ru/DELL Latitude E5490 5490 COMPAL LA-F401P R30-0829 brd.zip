# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_ALWP: length 24.8
  IN1 w0.254: v1(169.99,103.71) 171.26,104.98 171.26,112.86 v1(170.57,113.56)
  BOTTOM w0.254: v1(170.57,113.56) 171,113.56 PC132.1 170.77,114.17 PU102.14 ; PC130.1 171.24,104.83 174.12,107.71 174.12,114.39 PR117.2
  vias: v1(169.99,102.82) v1(169.99,101.87) v1(169.99,101.05) v3(169.42,104.29)
+5V_HDD: length 10.2
  TOP w0.127: v3(276.61,37.23) 277.88,37.23 278.37,37.72 v1(279.07,37.72) 279.07,37.27 v3(278.77,36.98)
  TOP w0.381: v1(282.96,40.29) 282.84,40.4 v3(282.2,40.4) 280.8,40.4 280.42,40.02 280.42,39.26 280.17,39.01 280.17,38.43 279.46,37.72 v1(279.07,37.72)
  BOTTOM w0.381: RN1.1 282.67,40.58 v1(282.96,40.29)
+5V_PD_VDD:
  vias: v2(39.93,97.68)
+5V_RUN: length 93.7
  TOP w0.254: JKBTP1.16 213.52,15.15 213.85,14.83 213.85,13.56 214.18,13.23 215.14,13.23 CZ92.1
  TOP w0.508: v1(316.03,73.94) 316.74,73.22 RZ370.1 ; v1(214.64,12.67) 214.84,12.67 CZ92.1
  IN1 w0.508: v1(316.03,73.94) 316.34,73.94 317,74.59 v1(317,77.11) 317,77.36 316.11,78.25 316.11,82.74 307.27,91.59 294.77,91.59 293.89,92.46 282.32,92.46 281.49,91.64 275.74,91.64 274.2,90.1 274.2,88.16 273.12,87.07 273.12,82 275.56,79.55 275.56,78.62 v1(275.26,78.32) ; v1(122.18,85.06) 122.58,85.06 123.7,86.17 125.11,86.17 127.68,88.75 v1(127.68,88.76)
  BOTTOM w0.254: RV6.2 122.78,85.26 122.58,85.06 v1(122.18,85.06)
  BOTTOM w0.508: v1(317,77.11) 317,76.6 UV4.1
  BOTTOM w1.016: 128.53,89.2 128.97,89.64 128.97,96.98
  vias: v1(128.53,98.21) v1(129.11,98.21) v1(191.72,20.89) v1(191.72,20.25) v1(192.26,21.13) v1(192.24,20.52) v1(192.25,19.89) v1(192.86,21.11) v1(192.84,20.52) v1(192.87,19.89) v1(220.29,17.16) v1(220.87,17.16) v1(229.96,15.17) v1(229.96,14.52) v1(230.63,15.87) v1(230.63,15.27) v1(230.66,14.68) v1(230.66,14.06) v1(244.07,34.84) v1(244.66,34.84) v1(245.27,34.84) v1(245.62,35.32) v1(246.23,35.32) v1(259.91,47.49) v1(260.28,48.53) v1(260.52,47.49) v1(260.8,48.85) v1(261.41,48.85) v1(264.86,40.15) v1(265.24,40.59) v1(265.63,40.15) v1(266.01,40.59) v1(270.74,66.13) v1(270.91,68.35) v1(271.15,66.57) v1(271.49,67.61) v1(271.52,68.23) v1(271.56,66.13) v1(275.06,77.74) v1(277.04,74.82) v1(277.12,75.48) v1(277.68,74.9) v1(277.7,75.51) v1(278.12,39.62) v1(278.51,40.16) v1(278.62,39.31) v3(170.57,67.96)
+5V_RUN_AUDIO:
  vias: v1(273.66,67.68) v1(273.66,67.05) v1(273.66,66.36) v1(274.28,67.64) v1(274.28,67.04) v1(274.3,66.41) v1(299.59,46.45) v1(299.99,47.02) v1(300.17,46.45) v1(300.63,47.02) v1(300.77,46.45) v1(308.17,27.45) v1(308.81,27.45) v1(309.4,27.45) v3(308.62,26.82)
+5V_RUN_AUDIO_UZ5:
  vias: v2(277.4,72.48)
+5V_RUN_CHG: length 3.1
  TOP w0.102: RZ370.2 318.74,72.13 v2(319.41,72.13)
  TOP w0.381: RZ370.2 317.44,72.03 QZ4.1
+5V_RUN_PVDD_L:
  vias: v2(300.64,40.15)
+5V_RUN_UZ4: length 1
  TOP w0.127: 193.02,18.83 v2(191.98,18.83)
+5V_TBT_VBUS: length 0.6
  TOP w0.102: v1(34.99,94.06) v3(34.99,93.45)
  vias: v1(25.34,89.81) v1(25.34,89.17) v1(34.99,94.7)
+5V_TBTA_VBUS_D:
  vias: v1(42.76,95.63) v1(43.33,95.88) v2(43.87,95.95)
+5V_TSP:
  vias: v3(121.42,90.12)
+5V_USB_CHG_PWR:
  vias: v1(307.66,41.52) v1(307.8,40.9) v1(308.29,41.52) v1(308.53,40.91) v1(308.93,41.52) v1(311.82,55.67) v1(311.85,55.06) v1(311.87,54.48) v1(312.48,55.06) v1(313.03,54.75) v3(311.41,57.04)
+DV33_18: length 5.1
  TOP w0.127: v2(19.12,51.71) 19.54,51.29 20.76,51.29 CR2202.1
  TOP w0.254: UR1.18 23.06,51.06 22.62,51.49
  TOP w0.381: 22.62,51.49 CR2201.1 CR2202.1
+GND_CHASSIS: length 5.4
  TOP w0.127: v2(299.93,100.4) RL17.2
  TOP w0.508: RL16.2 v1(295.53,99.33) ; RL18.2 v1(302.39,99.33) ; RL15.2 v1(292.99,99.33) ; RL17.2 v1(298.84,99.33)
+VBUS_DC_SS: length 26.8
  TOP w0.508: v1(5.72,29.86) v3(5.72,28.4) 6.37,27.75 8.87,27.75 9.56,27.07 PD903.2
  IN4 w0.508: v1(9.23,47.92) 9.23,38.55 6.66,35.98 6.66,32.64 5.72,31.7 v1(5.72,29.86)
+VCC1V8A_TBTA_LDO: length 4.7
  TOP w0.076: 30.12,83.77 30.64,83.24 UT5.K1
  TOP w0.102: 30.12,83.77 29.95,83.93 29.25,83.93 28.66,84.52 27.73,84.52 v2(27.72,84.53) 27.4,84.85 CT73.1
+VCC1V8D_TBTA_LDO: length 4.1
  TOP w0.203: UT5.A2 35.15,82.54 35.95,83.33 35.95,83.38
  TOP w0.381: RT97.1 CT72.1 37.17,84.6 35.95,83.38
+VCC_1P8: length 22.6
  TOP w0.356: CC113.1 CC112.1 130.14,59.77 130.4,60.03 v1(131.09,60.03)
  TOP w0.508: RC313.2 141.6,69.79 139.63,67.83 v2(138.94,67.83) 138.38,67.83 v1(138.2,67.64)
  IN4 w0.381: v1(131.09,60.03) 131.09,60.16 131.5,60.57 136.11,60.57 136.54,61 136.54,65.66 136.91,66.03 136.91,66.95 137.6,67.64 v1(138.2,67.64)
+VCC_CORE: length 38.8
  TOP w0.457: v1(115.85,61.49) 115.85,61.89 PC1078.1 ; PC1076.1 113.38,59.54 v1(113.38,59.14) ; v1(114.65,61.49) 114.65,61.89 PC1069.1 ; PC1079.1 117.12,61.89 v1(117.12,61.49) ; v1(111.77,61.46) 112.17,61.46 PC1065.1 ; v1(114.65,59.14) 114.65,59.54 PC1082.1 ; v1(111.77,60.19) 112.17,60.19 PC1006.1 ; PC1074.1 117.12,59.54 v1(117.12,59.14) ; PC1068.1 115.85,59.54 v1(115.85,59.14) ; v1(113.38,61.49) 113.38,61.89 PC1003.1 ; PC1064.1 112.17,58.92 v1(111.77,58.92)
  BOTTOM w0.127: UC1.AL40 114.84,53.93 ; UC1.AL40 115.14,54.28 ; UC1.AL40 115.47,53.93 ; UC1.AL40 115.14,53.62 ; UC1.K38 115.6,65.07 ; UC1.K38 115.91,64.76 ; UC1.K38 115.6,64.46 ; UC1.K38 115.3,64.76 ; UC1.AL37 117.31,53.93 ; UC1.AL37 116.97,54.23 ; UC1.AL37 116.97,53.62 ; UC1.AL37 116.66,53.93 ; 117.43,65.07 UC1.K35 ; UC1.K35 117.13,64.76 ; UC1.K35 117.43,64.46 ; UC1.K35 117.74,64.76 ; UC1.J37 116.06,65.53 ; UC1.J37 115.75,65.23 ; UC1.J37 116.06,64.92 ; UC1.J37 116.36,65.23 ; UC1.K40 114.99,64.76 ; UC1.K40 114.69,64.46 ; UC1.K40 114.38,64.76 ; UC1.K40 114.69,65.07 ; UC1.J40 114.54,65.23 ; UC1.J40 113.92,65.23 ; UC1.J40 114.23,65.53 ; UC1.J40 114.23,64.92 ; UC1.AK37 116.52,54.77 ; UC1.AK37 116.52,54.04 ; UC1.AK37 116.8,54.39 ; UC1.J30 119.39,65.23 ; UC1.J30 119.72,65.58 ; UC1.J30 119.72,64.9 ; 118.8,53.62 UC1.AL33 ; UC1.AL33 119.11,53.93 ; UC1.AL33 118.8,54.27 ; UC1.AL33 118.46,53.93 ; UC1.J33 117.89,64.92 ; UC1.J33 118.19,65.23 ; UC1.J33 117.89,65.53 ; UC1.J33 117.58,65.23 ; UC1.AK40 114.38,54.39 ; UC1.AK40 114.99,54.39 ; UC1.AK40 114.69,54.7 ; UC1.AK40 114.69,54.09 ; 115.6,54.8 UC1.AK38 ; UC1.AK38 115.28,54.39 ; UC1.AK38 115.6,54.05 ; UC1.K42 113.77,64.46 ; UC1.K42 113.77,65.07 ; UC1.K42 114.08,64.76 ; UC1.K37 116.82,64.76 ; UC1.K37 116.21,64.76 ; UC1.K37 116.52,65.07 ; UC1.K37 116.52,64.46 ; 112.86,64.34 112.86,64.35 UC1.K43 112.86,65.09 ; 118.34,64.46 UC1.K33 ; UC1.K33 118.34,65.07 ; UC1.K33 118.04,64.76 ; UC1.AK33 118.34,54.03 ; UC1.AK33 118.68,54.39 ; UC1.AK33 118.34,54.74 ; UC1.AK35 117.43,54.03 ; UC1.AK35 117.43,54.76 ; UC1.AK35 117.13,54.39
  BOTTOM w0.203: v1(112.31,70.3) UC1.A44 ; UC1.A39 114.87,69.47 114.87,70.23 v1(114.92,70.28) ; UC1.A30 119.75,69.8 v1(119.54,70.01) ; v1(117.49,69.88) 117.49,69.64 117.27,69.42 UC1.A34
  BOTTOM w0.254: UC1.G38 115.85,65.94 v1(116.05,65.94) 116.27,65.94 UC1.G37 ; UC1.G30 119.94,65.92 v1(119.74,65.92) 119.49,65.92 UC1.G32 ; UC1.G35 117.83,66.09 v1(117.88,66.09) 117.95,66.09 UC1.G33 ; UC1.G42 114.07,65.99 v1(114.22,65.99) 114.39,65.99 UC1.G40
  BOTTOM w0.508: v1(113.27,78.31) 113.29,78.29 RC140.2
  vias: v1(77.09,71.46) v1(77.09,70.69) v1(77.09,69.93) v1(77.09,69.23) v1(77.48,72.79) v1(77.48,72.15) v1(77.79,71.46) v1(77.79,70.69) v1(77.79,69.93) v1(77.79,69.23) v1(78.24,73.42) v1(78.24,72.79) v1(78.24,72.15) v1(78.49,71.46) v1(78.49,70.69) v1(78.49,69.93) v1(78.49,69.23) v1(79.19,71.46) v1(79.19,70.69) v1(79.19,69.93) v1(79.19,69.23) v1(79.89,71.46) v1(79.89,70.69) v1(79.89,69.93) v1(79.89,69.23) v1(80.14,75.39) v1(80.59,71.46) v1(80.59,70.69) v1(80.59,69.93) v1(80.59,69.23) v1(80.84,75.39) v1(80.9,76.15) v1(81.29,71.46) v1(81.29,70.69) v1(81.29,69.93) v1(81.29,69.23) v1(81.54,75.39) v1(81.6,76.85) v1(81.6,76.15) v1(81.98,71.46) v1(81.98,70.69) v1(82.05,73.68) v1(82.05,73.04) v1(82.05,72.41) v1(82.24,75.39) v1(82.3,77.55) v1(82.3,76.85) v1(82.3,76.15) v1(82.68,73.68) v1(82.68,73.04) v1(82.68,72.41) v1(82.68,71.46) v1(82.87,78.25) v1(83,77.55) v1(83,76.85) v1(83,76.15) v1(82.94,75.39) v1(83.25,69.49) v1(83.32,73.68) v1(83.32,73.04) v1(83.32,72.41) v1(83.32,71.71) v1(83.57,78.25) v1(83.7,77.55) v1(83.7,76.85) v1(83.7,76.15) v1(83.63,75.39) v1(83.76,70) v1(84.27,78.25) v1(84.4,77.55) v1(84.4,76.85) v1(84.33,76.15) v1(84.33,70.44) v1(84.46,69.23) v1(84.97,78.25) v1(84.97,69.68) v1(85.1,77.55) v1(85.67,68.79) v1(86.11,69.3) v1(86.87,68.22) v1(87.44,68.6) v1(113.71,64.08) v1(114.22,64.5) v1(114.29,54.85) v1(114.41,63.41) v1(114.51,63.98) v1(114.61,55.41) v1(114.99,64.32) v1(115.14,54.87) v1(115.23,56.79) v1(115.53,64.07) v1(115.61,55.36) v1(116.02,64.43) v1(116.06,53.06) v1(116.29,63.77) v1(116.44,56.79) v1(116.52,55.34) v1(117,64.46) v1(116.96,54.72) v1(116.94,53.03) v1(117.46,64.09) v1(117.43,55.34) v1(117.71,56.79) v1(117.93,64.45) v1(118.14,63.77) v1(118.34,55.34) v1(119.26,61.99) v1(119.26,61.4) v1(119.26,60.13) v1(119.26,58.92) v1(119.26,57.71) v3(78.55,77.74)
+VCC_CORE_G0: length 1.1
  TOP w0.254: T122.1 119.77,64.59 v1(119.62,64.44)
  BOTTOM w0.254: v1(119.62,64.44) 119.54,64.44 119.26,64.73 UC1.K32
+VCC_CORE_G1: length 1.6
  TOP w0.254: v1(119.21,55.36) 119.21,55.22 T123.1
  BOTTOM w0.254: v1(119.21,55.36) 119.26,55.3 UC1.AK32
+VCC_GT: length 34.3
  TOP w0.457: v1(105.33,58.25) 105.33,58.65 PC1134.1 ; v1(104.12,55.83) 104.12,56.24 PC1133.1 ; PC1026.1 106.53,58.65 v1(106.53,58.25) ; PC1022.1 105.33,56.24 v1(105.33,55.83) ; v1(106.53,60.72) 106.53,61.13 PC1132.1 ; PC1016.1 105.33,61.13 v1(105.33,60.72) ; PC1136.1 106.53,56.24 v1(106.53,55.83) ; PC1021.1 107.74,61.13 v1(107.74,60.72) ; PC1015.1 104.12,61.13 v1(104.12,60.72) ; PC1014.1 107.74,58.65 v1(107.74,58.25) ; PC1137.1 104.12,58.65 v1(104.12,58.25)
  BOTTOM w0.127: 102.04,58.66 UC1.AA63 ; UC1.AA63 102.36,59 ; UC1.AA63 102.04,59.3 ; UC1.AA63 101.7,59 ; UC1.R63 102.04,62.08 102.04,62.08 ; UC1.R63 102.04,61.39 ; UC1.R63 102.34,61.74 ; UC1.R63 101.73,61.74 ; 102.04,59.6 UC1.W63 ; UC1.W63 102.36,59.91 ; UC1.W63 101.68,59.91 ; 102.36,63.57 UC1.L63 ; UC1.L63 102.04,63.39 102.08,63.34 102.08,63.26 ; UC1.L63 101.73,63.57 ; 103.71,64.41 UC1.K60 ; UC1.K60 104.02,64.76 ; UC1.K60 103.41,64.76 ; UC1.J58 103.84,65.23 103.81,65.2 ; UC1.J58 104.5,65.23 ; UC1.J58 104.17,64.92 ; 102.04,62.29 UC1.N63 ; UC1.N63 101.7,62.65 ; UC1.N63 102.36,62.65 ; 103.6,65.23 UC1.J60 103.26,64.92 ; UC1.M62 102.82,63.11 ; UC1.M62 102.51,62.77 ; UC1.M62 102.51,63.42 ; UC1.T62 102.51,60.92 102.5,60.91 ; UC1.T62 102.18,61.28 ; UC1.T62 102.51,61.59 ; UC1.T62 102.81,61.28 ; 106.37,65.23 UC1.J55 106,64.92 ; UC1.J53 106.61,65.23 ; UC1.J53 107.32,65.23 ; UC1.J53 106.91,64.92 ; 102.5,59.8 102.51,59.79 UC1.Y62 ; UC1.K55 106.15,64.76 ; UC1.K55 106.76,64.76 ; UC1.K55 106.46,65.07 ; UC1.K55 106.46,64.38 ; UC1.Y62 102.78,59.45 ; UC1.Y62 102.18,59.45 ; UC1.Y62 102.51,59.11 102.5,59.11 ; 104.32,64.76 UC1.K58 ; UC1.K58 104.93,64.76 ; UC1.K58 104.63,65.07 ; UC1.K58 104.63,64.39 ; 102.51,63.72 UC1.L62 ; UC1.L62 102.89,64.02 ; UC1.L62 102.51,64.35 ; UC1.J56 105.09,64.92 ; UC1.J56 104.74,65.23 ; UC1.J56 105.42,65.23 105.42,65.23 ; 105.55,64.39 105.54,64.4 UC1.K56 ; 105.24,64.76 UC1.K56 ; UC1.K56 105.85,64.76 ; UC1.K53 107.37,64.38 ; UC1.K53 107.37,65.1 ; UC1.K53 107.07,64.76
  BOTTOM w0.203: v1(102.4,70.4) UC1.A62 ; v1(99.92,70.4) UC1.A66 ; v1(104.88,70.4) UC1.A58
  BOTTOM w0.381: 89.69,62.38 89.69,63.67 89.97,63.95 RC161.2
  vias: v1(76.65,61.42) v1(76.65,60.79) v1(76.65,60.15) v1(76.65,59.52) v1(76.65,58.88) v1(77.28,62.06) v1(77.28,61.42) v1(77.28,60.79) v1(77.28,60.15) v1(77.28,59.52) v1(77.28,58.88) v1(77.92,62.06) v1(77.92,61.42) v1(77.92,60.79) v1(77.92,60.15) v1(77.92,59.52) v1(77.92,58.88) v1(78.55,61.42) v1(78.55,60.79) v1(78.55,60.15) v1(78.55,59.52) v1(78.55,58.88) v1(79.19,61.42) v1(79.19,60.79) v1(79.19,60.15) v1(79.19,59.52) v1(79.19,58.88) v1(79.82,61.42) v1(79.82,60.79) v1(79.82,60.15) v1(79.82,59.52) v1(79.82,58.88) v1(80.46,61.42) v1(80.46,60.79) v1(80.46,60.15) v1(80.46,59.52) v1(80.46,58.88) v1(81.09,61.42) v1(81.09,60.79) v1(81.09,60.15) v1(81.09,59.52) v1(81.79,61.68) v1(81.79,61.04) v1(81.79,60.41) v1(81.79,59.77) v1(84.97,58.63) v1(87.51,62.25) v1(87.62,59.55) v1(88.38,60.39) v1(89.18,61.46) v1(97.16,63.11) v1(97.16,62.2) v1(97.16,61.28) v1(97.16,60.37) v1(97.16,59.45) v1(97.16,58.54) v1(97.15,57.68) v1(97.81,63.11) v1(97.81,62.2) v1(97.81,61.28) v1(97.81,59.45) v1(97.81,58.54) v1(98.46,63.11) v1(98.46,62.2) v1(98.46,61.28) v1(98.46,60.37) v1(98.46,59.45) v1(98.46,58.54) v1(99.11,63.11) v1(99.11,61.28) v1(99.11,60.37) v1(99.11,59.45) v1(99.76,63.11) v1(99.76,62.2) v1(99.76,61.28) v1(99.76,59.45) v1(99.76,58.54) v1(100.41,63.11) v1(100.41,62.2) v1(100.41,61.28) v1(100.41,60.37) v1(100.41,59.45) v1(100.41,58.54) v1(101.06,60.37) v1(101.71,63.11) v1(101.71,62.2) v1(101.71,58.54) v1(102.83,63.57) v1(102.83,62.65) v1(102.83,61.74) v1(103,59.88) v1(103.26,64.54) v1(104.17,64.54) v1(104.12,63.14) v1(105.09,64.54) v1(105.33,63.14) v1(106.02,64.52) v1(106.53,63.14) v1(106.91,64.51) v3(87.25,58.37)
+VCC_GT_+VCC_CORE: length 29.6
  TOP w0.102: v1(109.99,70.2) 110.44,70.65 v2(110.44,70.76)
  TOP w0.457: PC1322.1 109.69,58.98 v1(109.29,58.98) ; v1(109.29,60.25) 109.69,60.25 PC1327.1 ; PC1323.1 109.69,57.71 v1(109.29,57.71) ; v1(109.29,61.46) 109.69,61.46 PC1326.1 ; PC1324.1 109.69,56.51 v1(109.29,56.51)
  BOTTOM w0.127: 108.4,65.23 UC1.J50 ; UC1.J50 108.74,64.92 ; UC1.J50 109.1,65.23 ; UC1.AK46 110.63,54.39 ; UC1.AK46 111.03,54.02 ; UC1.AK46 111.36,54.39 ; UC1.AK46 111.03,54.71 ; 111.8,53.93 UC1.AL46 ; UC1.AL46 111.14,53.93 ; UC1.AL46 111.49,54.3 ; UC1.AL50 109.66,53.58 ; UC1.AL50 109.33,53.93 ; UC1.AL50 110,53.93 ; UC1.AL50 109.66,54.26 ; 113.32,54.28 UC1.AL43 112.97,53.93 ; UC1.J48 110.02,65.23 ; UC1.J48 109.31,65.23 ; UC1.J48 109.66,64.92 ; UC1.AK43 113.19,54.39 ; UC1.AK43 112.49,54.39 ; UC1.AK43 112.86,54.06 ; UC1.AK43 112.86,54.71 ; 109.51,64.76 UC1.K50 ; UC1.K50 108.9,64.76 ; UC1.K50 109.2,65.07 ; UC1.K50 109.2,64.45 ; UC1.AK48 110.47,54.39 ; UC1.AK48 109.8,54.39 ; UC1.AK48 110.12,54.7 ; UC1.AK48 110.12,54.09 ; UC1.AM50 109.55,53.45 ; UC1.AM50 108.84,53.45 ; UC1.AM50 109.2,53.36 109.5,53.06 v1(109.66,53.06) 109.82,53.06 110.12,53.36 UC1.AM48 ; UC1.AM50 109.2,53.81 ; UC1.J45 111.49,64.92 ; UC1.J45 111.84,65.23 ; UC1.J45 111.14,65.23 ; UC1.AK45 111.94,54.72 ; UC1.AK45 111.65,54.39 ; UC1.AK45 111.94,54.04 ; UC1.AK45 112.27,54.39 ; 110.12,64.39 UC1.K48 ; UC1.K48 109.81,64.76 ; UC1.K48 110.42,64.76 ; UC1.K48 110.12,65.12 ; 110.2,65.23 UC1.J46 ; UC1.J46 110.95,65.23 ; UC1.J46 110.57,64.92 ; 112.4,64.94 UC1.J43 112.1,65.23 ; UC1.AM48 110.47,53.45 ; UC1.AM48 110.12,53.82 ; UC1.AM48 109.75,53.45 ; 108.53,53.7 UC1.AM52 108.63,53.45 ; 109.2,54.05 UC1.AK50 ; UC1.AK50 109.56,54.39 ; UC1.AK50 109.2,54.69 109.38,54.87 ; UC1.AK42 113.47,54.39 ; UC1.AK42 113.77,53.92 ; UC1.AK42 113.77,54.75 ; 107.83,64.92 UC1.J52 108.19,65.23
  BOTTOM w0.203: UC1.A48 109.89,69.44 109.89,70.09 v1(109.99,70.2) ; v1(107.37,70.28) 107.28,70.18 107.28,69.47 UC1.A53
  vias: v1(108.78,64.45) v1(108.79,63.85) v1(109.66,64.45) v1(109.66,63.85) v1(109.66,54.84) v1(110.11,55.33) v1(110.57,64.45) v1(110.57,63.85) v1(110.57,54.84) v1(111,55.33) v1(111.49,64.45) v1(111.49,54.84) v1(111.96,55.33) v1(112.4,64.45) v1(112.4,54.84) v1(112.84,55.33) v1(113.32,54.84)
+VCC_GT_AK52: length 0.5
  BOTTOM w0.254: UC1.AK52 v1(108.29,54.88)
+VCC_GT_K52: length 0.6
  BOTTOM w0.254: v1(107.83,64.51) 108.03,64.51 UC1.K52
  vias: v2(107.83,65.04)
+VCC_GTX: length 12.2
  BOTTOM w0.127: UC1.AM56 105.54,53.78 ; UC1.AM56 105.18,53.45 ; UC1.AM56 105.87,53.45 ; UC1.AK56 105.86,54.39 ; UC1.AK56 105.54,54.1 ; UC1.AK56 105.54,54.8 ; 107.72,53.45 UC1.AM53 ; UC1.AM53 107.37,53.78 ; UC1.AM53 107.22,53.45 107.07,53.61 ; UC1.AL53 107.48,53.93 ; UC1.AL53 108.18,53.93 ; UC1.AL53 107.83,53.6 ; UC1.AL53 107.83,54.26 ; 106.36,53.93 UC1.AL56 ; UC1.AL56 106,54.29 ; UC1.AL56 106,53.6 ; UC1.AL56 105.58,53.93 ; 104.63,54.06 UC1.AK58 ; UC1.AK58 104.63,54.72 ; UC1.AK58 104.31,54.39 ; UC1.AK60 103.71,54.72 ; UC1.AK60 104.05,54.39 ; UC1.AK60 103.71,54.02 ; 107.37,54.06 UC1.AK53 ; UC1.AK53 107.7,54.39 ; UC1.AK53 107.37,54.71 ; 103.85,53.93 UC1.AL60 ; UC1.AL60 104.17,53.6 ; UC1.AL60 104.17,54.26 ; UC1.AL60 104.53,53.93 ; UC1.AK55 106.46,54.75 ; UC1.AK55 106.46,54.04 ; UC1.AK55 106.14,54.39 ; UC1.AM58 104.63,53.76 ; UC1.AM58 104.99,53.45 ; UC1.AM58 104.31,53.45
  vias: v1(104.17,53.06) v1(105.09,53.06) v1(107.83,53.06)
+VCC_SA: length 12.4
  TOP w0.381: PC1148.1 122.15,66.4 121.7,65.94 v1(121.55,65.94) 121.37,66.12 PC1152.1
  TOP w0.508: RC168.1 122.43,82.04 v1(122.68,82.29)
  BOTTOM w0.127: UC1.J27 121.55,64.92 ; UC1.J27 121.85,65.23 ; UC1.J27 121.24,65.23 ; 123.98,65.23 UC1.J22 124.29,64.92 ; UC1.K25 122.92,64.46 ; UC1.K25 122.92,65.07 ; UC1.K25 123.22,64.76 ; 122,65.07 UC1.K27 ; UC1.K27 121.7,64.76 ; UC1.K27 122,64.6 121.89,64.49 ; 123.68,65.23 UC1.J23 ; UC1.J23 123.07,65.23 ; UC1.J23 123.37,64.92 ; 120.17,64.46 UC1.K30 120.17,65.07 ; 123.83,64.46 UC1.K23 ; UC1.K23 123.83,65.07 ; UC1.K23 123.53,64.76 ; UC1.K28 121.39,64.76 ; UC1.K28 121.09,65.07 ; UC1.K28 121.09,64.46
  BOTTOM w0.203: UC1.G23 v1(123.37,65.94) UC1.G25 UC1.G27 v1(121.55,65.94) UC1.G28
  vias: v1(83.83,85.93) v1(83.83,85.24) v1(83.83,84.6) v1(84.52,85.93) v1(84.52,85.24) v1(84.52,84.6) v1(85.22,85.93) v1(85.22,85.24) v1(85.22,84.6) v1(85.92,85.93) v1(85.92,85.24) v1(85.92,84.6) v1(120.81,69.37) v1(121.54,64.41) v1(121.8,60.47) v1(122.53,59.15) v1(122.52,55.53) v1(123.09,61.79) v1(123.09,60.88) v1(123.1,55.43) v1(123.73,55.43) v3(86.49,85.62)
+VCC_SFR_OC: length 27.5
  TOP w0.254: 124.59,51.2 124.08,51.2 123.83,50.95 123.83,49.42
  TOP w0.508: CC288.1 120.78,28.97 120.02,29.74 120.02,32.14 v3(121.49,33.6) 122.64,34.75 122.64,35.91 124.21,37.48 124.21,44.08 125.48,45.36 125.48,47.01 123.83,48.66 123.83,49.42
  BOTTOM w0.254: v1(124.29,54.55) UC1.AL23
+VCCK_12: length 12.8
  TOP w0.203: v1(279.34,57.98) 279.34,57.93 279.09,57.68 UV6.25
  TOP w0.254: UV6.4 275.25,55.27 274.53,56 274.53,56.67 v1(274.32,56.87)
  IN1 w0.254: v1(274.32,56.87) 274.79,56.87 275.45,57.53 276.25,57.53 276.71,57.07 278.82,57.07 279.34,57.59 v1(279.34,57.98)
  BOTTOM w0.102: v1(274.32,56.87) 274.51,56.68 v2(274.51,56.39)
  BOTTOM w0.254: CV104.1 CV105.1 278.71,58.62 v1(279.34,57.98) ; CV103.1 273.8,56.34 v1(274.32,56.87)
+VDD_DAC_33: length 3.4
  TOP w0.127: v2(281.08,54.3) 281.77,54.99 LV30.2
  TOP w0.203: UV6.20 280.27,54.87 280.66,55.26 LV30.2
+VDDA_AVDD1:
  vias: v2(305.44,32.89)
+VSS_PLL:
  vias: v2(300,70.5)
GND: length 4143.5
  TOP w0.102: 28.28,18.23 27.46,17.42 v3(27.31,17.42)
  TOP w0.127: v3(270.41,85.34) 270.64,85.11 v1(271.2,85.11) ; v3(176.05,92.96) v1(175.38,92.96) ; v1(172.22,117.19) 172.78,117.19 v3(172.85,117.11) ; v1(53.7,60.62) 53.68,60.65 v3(53.68,61.69) ; v3(204.5,28.53) v1(205.3,28.53) ; v3(310.65,90.82) 310.16,91.31 v1(310.14,91.31) ; v1(268.2,77.1) v3(268.2,78.12)
  TOP w0.203: UE1.E6 v1(298.36,75.53) ; UZ3.11 204.45,7.61 v1(204.54,7.52) ; UT5.A6 UT5.A7 ; UT5.L1 30.14,83.15 v1(29.79,83.51) ; v1(35.45,83.71) 35.45,83.35 UT5.A1 ; UZ4.11 v1(193.93,16.53)
  TOP w0.254: 116.28,54.18 116.28,54.52 v1(116.05,54.74) 115.66,54.35 PC1098.2 ; 116.28,54.18 116.27,54.18 PC1098.2 ; 116.28,54.18 PC1099.2 115.68,53.61 PC1091.2 115.66,53.61 PC1098.2 ; v1(295.16,81.93) UE1.A13 ; RC436.1 101.68,68.39 101.44,68.64 100.33,68.64 v1(99.92,68.23) ; UZ12.9 168.82,39.17 v1(168.6,38.94) ; v1(299.45,62.04) 299.6,61.89 RI52.2 ; UI5.10 305.17,56.66 v1(305.21,56.62) ; v1(271.05,45.99) 270.88,45.99 270.52,46.35 CZ121.2 ; v1(223.91,9.58) 223.84,9.65 JUSH1.6 ; JLED1.4 285.9,52.17 v1(285.68,52.39) ; JKBTP1.19 212.61,13.65 212.3,13.95 212.3,14.35 v1(212.37,14.42) 212.64,14.15 JKBTP1.18 ; v1(163.63,35.37) 163.63,35.96 163.84,36.17 UZ12.23 ; PR415.2 143.01,113.48 v1(142.77,113.24) ; JXDP1.19 v1(70.95,37.44) ; JUSH1.10 223.6,11.65 v1(223.91,11.96) ; UZ12.16 165.32,39.17 v1(165.55,38.94) ; v1(217.51,21.74) 218.03,21.21 CZ89.2 CZ88.2 ; v1(120.9,82.34) 121.16,82.08 RC166.2 ; v1(288.51,86.03) 288.81,85.73 UE4.3 ; UZ36.7 285.74,61.73 v1(285.26,61.73) ; v1(217.35,23.08) 217.3,23.13 CZ81.2 ; CT71.2 33.98,86.01 33.98,86.02 34.04,86.08 34.04,86.78 33.98,86.84 33.98,87.09 33.72,87.34 RT63.2 ; v1(135.31,111.31) 135.29,111.31 135.29,111.31 PR424.2 ; RC324.2 113.73,66.32 114.03,66.62 v1(114.21,66.62) ; v1(212.3,17.49) 212.64,17.15 JKBTP1.12 ; UI5.21 300.26,56.66 v1(300.51,56.41) ; v1(62.22,39.91) 62.36,39.76 CC33.2 ; PC402.2 v1(135.93,111.41) ; v1(309.36,60.22) 309.61,59.97 UI3.14 ; v1(22.33,94.05) 23.19,94.05 23.53,93.72 CT121.2 ; v1(214.43,17.44) 214.5,17.44 CZ90.2 ; JXDP1.32 v1(67.95,28.49) ; v1(269.62,50.25) UZ8.5 ; UE1.H4 v1(301.56,73.93) ; PR420.2 v1(125.4,115.65) ; v1(11.44,18.65) 12.25,18.65 PR960.1 ; UE1.A6 295.16,75.53 ; JUSH1.7 223.84,10.15 v1(223.93,10.24) ; CC195.2 124.26,64.46 v1(124.3,64.46) ; RI41.2 v1(300.61,62.09) ; RI39.2 302.65,61.94 v1(302.53,62.06) ; v1(291.25,54.84) 291.39,54.71 UN5.7 ; v1(114.4,62.82) 114.04,62.82 PC1096.2 113.84,63.02 PC1094.2 ; PC411.2 127.92,115.31 v1(127.92,115.32) ; v1(66.34,32.38) 66.45,32.26 JXDP1.38 ; UV6.24 279.34,56.47 279.06,56.19 v1(278.81,56.19) ; PR412.1 144.68,109.48 v1(143.91,109.48) ; CZ62.2 v1(219.53,10.43) ; UN4.7 262.15,45.76 v1(262.29,45.89) ; RC167.2 122.52,54.77 v1(121.95,55.34) ; CC179.2 103.69,39.25 v1(103.88,39.44) ; JKBTP1.6 212.67,20.15 212.32,19.8 v1(212.32,19.7) ; JUSH1.25 223.4,19.15 v1(223.81,18.74) 223.72,18.65 JUSH1.24 ; v1(274.96,74.44) UZ5.11 ; v1(276.23,66.83) 275.72,67.34 CA64.2 CA63.2 ; CC29.2 v1(64.14,39.95) ; v1(295.26,32.16) 295.03,32.39 295.03,32.94 CA55.2 ; RN19.2 278.35,58.51 277.63,58.51 v1(277.39,58.75) ; UN7.3 v1(277.14,64.15) ; PR407.2 v1(127.05,115.3) ; PR403.2 135.86,112.3 v1(135.44,111.88) ; v1(122.12,114.99) 122.12,114.99 PR419.2 ; JDB1.6 v1(29.87,98.04) ; RI54.2 v1(301.63,62.06) ; CZ63.2 v1(219.53,11.7)
  TOP w0.305: JDB1.8 28.98,99.21 v1(29.32,98.87) ; RC122.2 76.08,39.77 v1(75.9,39.95) ; CE15.2 v1(300.79,70.06) ; v1(73.95,32.07) JXDP1.8 73.95,28.89 73.68,28.62 72.76,28.62 72.45,28.92 JXDP1.14 ; JXDP1.20 70.95,31.26 v1(70.19,32.02) ; PC1041.2 106.05,65.94 v1(106,65.94) 105.98,65.94 PC1043.2 ; PC1334.2 109.23,65.53 v1(109.64,65.94) 109.69,65.94 PC1330.2 ; PC1042.2 103.67,65.53 v1(103.26,65.94) ; PC1040.2 104.58,65.53 v1(104.17,65.94) ; JXDP1.26 69.45,31.3 v1(69.73,31.58) ; UE1.C4 v1(296.76,73.93) ; PC1153.2 PC1150.2 PC1151.2 124.61,59.31 v1(125.04,58.89) ; DT17.2 11.14,101.33 v1(11.13,101.34) ; JXDP1.7 v1(73.95,34.13) 73.85,34.23 72.93,34.23 72.45,34.71 JXDP1.13 ; v1(63.22,34.23) 63.45,34.47 JXDP1.49 ; JXDP1.31 67.95,34.46 v1(68.1,34.31) 69.07,34.31 69.45,34.69 JXDP1.25 ; v1(116.29,63.16) 115.79,63.16 PC1083.2 ; PC1093.2 PC1092.2 118.02,63.02 v1(118.14,63.14) ; v1(129.03,58.83) 129.58,58.28 RC44.2 ; v1(34.56,100.04) 34.56,99.54 34.25,99.23 33.43,99.23 33.25,99.41 JDB1.7 ; JKBTP1.4 v1(214.13,21.15) ; UD1.3 64.82,16.58 v1(65.16,16.25) ; JXDP1.37 66.45,34.61 66.15,34.31 v1(65.99,34.31) ; JKBTP1.1 213.42,22.65 213.62,22.85 v1(213.62,23.26) ; CD27.2 103.91,9.55 CD28.2 104.07,10.01 v1(103.73,10.35) ; PC1033.2 118.71,65.99 v1(118.71,66) 118.78,66 PC1031.2 ; DT40.3 11.05,92.22 v1(10.86,92.41) ; DT18.2 v1(11.83,99.08) ; v1(76.5,29.86) 76.26,30.11 JXDP1.2 ; v1(60.7,38.85) 60.92,38.85 RC139.2 ; CC30.2 v1(56.88,31.66) ; CA60.2 306.56,28.53 v1(306.27,28.53) ; PC1038.2 v1(116.95,66) 117.41,65.54 PC1039.2 ; PC1089.2 115.42,65.67 v1(115.14,65.94) 114.71,65.51 PC1036.2 ; JXDP1.50 v1(63.45,31.69) ; v1(111.5,65.95) 111.5,65.92 PC1333.2 112.42,65.93 v1(112.42,65.98) ; JXDP1.59 60.95,36.28 v1(60.36,36.87) ; v1(50.81,32.79) UC8.7 ; PC1034.2 PC1050.2 113.12,64.7 v1(113.32,64.51)
  TOP w0.356: v1(207.37,3.6) 207.37,2.96 206.88,2.47 CZ115.2 205.83,2.47 CZ211.2 ; CC103.2 CC102.2 128.06,55.16 v1(128.38,55.48) ; v1(115.14,65.94) 115.27,65.94 115.67,66.34 PC1090.2 ; v1(204.17,10.27) 203.85,9.95 CZ112.2 ; CV83.2 106.8,100.27 v1(106.69,100.27) ; v1(130.59,59.06) 130.59,59.21 130.73,59.34 CC112.2 ; CC223.2 130.55,56.9 v1(130.61,56.97) ; PC1035.2 114.84,57.59 PC1077.2 ; CC113.2 128.9,59.15 129.03,59.02 v1(129.03,58.83) ; 122.15,68.07 121.12,68.07 PC1088.2 ; v1(104.9,68.23) 104.76,68.09 PC1328.2 ; PC1047.2 100.91,62.04 v1(101.06,62.2) ; v1(116.95,66) 116.85,66.1 PC1086.2 ; CD60.2 185.81,13.73 186.27,14.2 v1(186.59,14.2)
  TOP w0.381: CZ122.2 192.37,13.77 191.84,13.24 v1(191.5,13.24) ; PC1332.2 PC1331.2 110.53,53.1 v1(110.57,53.06) ; v1(105.2,98.82) 105.21,98.82 105.66,99.27 CV82.2 ; v1(288.65,70.27) 288.3,69.92 CE12.2 ; CC252.2 119,52.61 v1(118.8,52.41) ; RI37.1 304.7,51.77 v1(304.91,51.57) 305.19,51.29 305.19,50.63 305.64,50.17 RI56.2 ; v1(112.44,93.15) 112.48,93.12 CA7.2 ; CA45.2 299.56,41.46 CA46.2 298.62,41.97 CA47.2 ; v1(166.26,7.78) 166.6,8.11 CD84.2 CD85.2 ; v1(284.54,72.2) 284.54,71.58 CE102.2 CE101.2 ; CL20.2 v1(296.17,94.51) ; CC313.2 125.5,53.69 125.28,53.47 125.28,53.12 ; CR2202.2 20.96,52.67 CR21.2 ; CR2202.2 CR2201.2 ; CR2202.2 20.24,52.08 v1(19.99,51.83) ; 125.28,53.12 125.3,53.14 CC270.2 ; 125.28,53.12 v1(125.2,53.04) ; v1(135.03,6.11) 135.34,5.79 CD90.2 CD91.2 ; CZ104.2 129.97,26.27 129.97,25.25 129.26,24.54 128.44,24.54 127.4,25.58 CZ1003.2 CZ1002.2 ; CE62.2 299.41,66.62 v1(299.6,66.8) CE23.2 ; CD82.2 CD83.2 108.3,4.02 107.66,3.38 v1(107.66,3.34) ; PR1262.2 13.48,35.83 v1(13.48,36.91) ; PR30.2 61.45,94.79 v1(64.22,94.79) ; CD97.2 CD96.2 139.12,11.65 v1(139.28,11.5) ; PQ1201.1 v1(14.95,35.41) ; CN21.2 259.96,50.89 260.38,50.48 CN20.2 ; QN7.3 249.96,37.23 251.66,37.23 252.18,37.75 QN6.3 253,38.18 v1(253.37,37.81) ; v1(112.16,42.89) 112.21,42.84 CC177.2 ; v1(309.25,78.75) CE19.2 308.24,78.16 CE20.2 ; v1(305.44,69.54) 305.76,69.23 CE3.2 ; v1(69.86,11.7) 69.83,11.73 CD111.2 CD110.2 ; CD100.2 CD101.2 188.6,12.83 v1(188.56,12.79) ; 120.48,65.26 120.48,65.86 v1(120.65,66.03) 120.78,66.16 PC1152.2 ; CA31.2 295.41,39.05 CA10.2 ; CD104.2 CD105.2 188.65,4.62 v1(188.85,4.41) ; CL19.2 303.72,96.79 303.45,97.06 302.17,97.06 301.77,96.66 301.77,95.18 302.07,94.88 v1(302.07,94.67) ; v1(281.61,78.95) 281.31,79.25 RL9.2 ; RN39.2 259.78,41.99 259.32,41.53 v1(258.97,41.53) ; CN16.2 281.82,65.44 282.2,65.05 v1(282.2,64.53) ; v1(137.27,31.45) 138.17,31.45 138.64,30.98 CZ82.2 ; CE25.2 v1(304.63,88.11) ; CE22.2 v1(311.09,71.71) ; RT144.2 RT304.2 19.21,97.17 20.1,96.28 v1(20.1,95.47) ; CC214.2 v1(139.2,38.51) ; PQ1201.4 v1(16.25,35.85) ; RT100.2 32.53,86.3 v1(32.45,86.38) ; CL21.2 292.74,94.13 v1(293.12,94.51) ; RE85.2 299.22,94.2 v1(299.22,94.51) ; PQ1214.4 v1(12.59,35.83) ; PC651.1 60.77,51.5 v1(60.77,51.96) ; v1(171.4,14.42) 171.12,14.14 CD87.2 CD86.2 ; PU903.3 32.6,32.29 v1(33.03,32.72) ; v1(62.52,6.09) 62.36,5.93 CD71.2 CD70.2 ; v1(272.67,91.28) UL2.3 ; v1(308.84,64.09) 309.03,63.9 CI19.2 ; CC91.2 CC90.2 126.31,56.75 125.82,56.26 PC1140.2 ; v1(169.93,40.06) CZ50.2 171.11,40.35 CZ75.2 ; v1(310.39,53.65) 310.17,53.87 DI4.3 ; PR427.2 v1(146.28,110.53) ; CD57.2 169.45,5.61 v1(169.03,6.03) ; CC109.2 CC108.2 124.88,58.73 v1(125.04,58.89) ; v1(101.18,57.64) 100.92,57.37 PC1045.2 ; CD80.2 CD81.2 108.3,7.12 v1(108.15,7.27) 108.16,7.28 CD79.2 ; CD89.2 CD88.2 181.45,12.25 181.69,12.01 v1(181.69,11.72) ; CE142.2 CE141.2 289.24,76.35 v1(289.24,76.34) 289.24,76.88 CE11.2 ; RN188.2 219.64,36.59 219.84,36.8 v1(219.84,37.24) ; CN61.2 289.23,27.35 v1(288.83,27.35) ; UZ10.3 278.63,49.62 v1(278.07,50.18) ; v1(322.78,65.23) 322.56,65.02 CE632.2 CE631.2 ; RC1.2 131.5,62.83 131.82,63.15 v1(131.82,63.28) ; v1(281.21,44.93) 281.21,45 280.83,45.38 CZ93.2 ; v1(170.03,6.19) 170.46,5.75 RD29.2 ; CD93.2 CD92.2 126.73,5.91 v1(126.53,6.11) ; PQ1.4 v1(59.13,107.42) ; CC332.2 127.32,31.82 CC105.2 CC104.2 128.23,32.72 v1(128.44,32.5) ; CD65.2 CD64.2 70.31,5.79 v1(70.07,6.03) ; CI46.2 v1(19.24,79.81) ; CC123.2 CC122.2 117.65,52.65 v1(117.89,52.41) ; PC1048.2 101.77,60.42 v1(101.71,60.37) 101.68,60.4 101.68,60.94 PC1055.2 ; CZ61.2 219.18,18.71 CZ71.2 220.3,18.51 CZ66.2 ; v1(273.69,60.74) 273.15,60.74 272.25,61.63 CN17.2 ; v1(19.56,99.21) 19.56,98.66 CT119.2 ; PQ1210.1 v1(28.83,40.53) ; v1(103.78,11.67) 104.32,12.21 105.45,12.21 CD78.2 CD77.2 CD76.2 107.33,11.94 107.46,11.81 CD21.2 ; DI6.3 v1(81.41,105.1) ; CD67.2 CD66.2 71.58,11.94 v1(71.27,11.62) ; CZ54.2 165.93,42.47 v1(165.93,42.82) ; CZ116.2 195.5,17.49 195.9,17.09 CZ117.2 ; PC1329.2 102.46,67.65 102.34,67.53 v1(102.34,67.21) RC114.2 ; v1(291.75,81.9) 291.98,81.68 CE38.2 RE77.2 ; CL17.2 298.58,94.13 v1(298.2,94.51) ; UE3.3 v1(306.06,93.89) ; v1(26.61,37.93) 26.85,38.17 PQ1210.4 ; v1(143.86,75.5) 144.25,75.11 CC111.2 CC110.2 ; UZ34.3 v1(130.02,28.8) ; CZ120.2 272.55,50.29 272,50.84 270.91,50.84 v1(270.9,50.82) ; CE8.2 308.37,83.27 v1(308.54,83.1) ; CC106.2 CC107.2 139.37,84.93 v1(139.45,84.85) ; CV39.2 117.1,105.24 v1(117.29,105.43) ; v1(187.84,4.45) 188.07,4.68 CD106.2 CD107.2 ; PQ1.1 v1(59.38,106.12) ; v1(283.06,60.01) 283.06,58.97 RV116.2 RV117.2 RV118.2 282.66,56.99 281.87,56.2 CV100.2 ; v1(302.34,93.36) 301.82,93.36 301.73,93.27 CL16.2 ; v1(20.67,71.13) 20.43,71.38 DI1.3 v1(17.93,71.38) ; v1(274.96,74.44) 276.48,74.44 276.95,73.97 CZ125.2 ; v1(31.12,43.3) 31.7,43.3 CR17.1 ; PC1148.2 122.15,68.07 v1(122.34,68.26) ; CE302.2 CE301.2 300.04,85.35 299.47,85.92 RE65.2 ; CD74.2 CD75.2 47.48,12 v1(47.78,11.7) ; CL8.2 274.45,79.27 v1(274.76,78.96) ; QN4.4 209.95,34.42 209.55,34.82 v1(209.55,35.26) 209.1,35.72 QN4.1 ; PQ1204.1 v1(13.35,34.05) ; 295.16,75.53 294.92,75.29 CE13.2 293.26,75.29 v1(292.89,74.92) ; v1(303.6,93.94) 303.6,94 303.52,94.08 UE5.3 ; v1(129.07,60.49) 128.97,60.59 CC92.2 CC93.2 ; QN5.1 v1(223.34,33.67) ; PU1200.3 v1(17.49,35.74) ; v1(163.63,35.37) 163.24,35.37 CZ53.2 ; CV102.2 CV101.2 283.1,53.19 282.68,52.77 v1(282.25,52.77) ; CE4.2 RE313.2 v1(311.79,68.6) ; PC1037.2 112.46,68.09 v1(112.31,68.23) ; CD103.2 CD102.2 190.06,10.22 CD53.2 ; CC308.2 RC136.2 55.33,28.39 v1(55.39,28.45) ; PC420.2 134.94,112.18 v1(135.41,112.65) 134.99,113.07 PR428.2 ; v1(169.07,14.24) 169.46,13.86 CD37.2 ; CD109.2 CD108.2 101.82,8.67 v1(102.01,8.48) ; PC410.2 v1(146.28,111.42) ; v1(287.48,87.8) 287.43,87.85 286.82,87.85 286.39,88.28 CL13.2 ; PQ1208.1 v1(27.61,30.12) ; v1(21.21,92.64) 20.58,92 CT118.2 CT120.2 ; v1(20.1,47.77) 20.27,47.95 CR1501.2 CR1502.2 ; PQ1207.1 v1(34.93,37.74) ; CD98.2 CD99.2 176.51,6.02 v1(176.53,6.03) ; v1(129.78,14.32) 128.92,13.47 CD94.2 CD95.2 127.58,13.47 CD40.2 ; v1(281.34,37.38) 281.18,37.54 QN1.1 ; PQ1214.1 v1(11.29,35.32) ; CR6.2 25.8,54.51 v1(26.07,54.78) 26.52,55.23 CR4.2 ; CD32.2 90.52,14.09 v1(90.37,14.24) ; CL15.2 270.35,89.97 v1(270.01,90.32) ; CD73.2 CD72.2 57.55,13.65 57.27,13.92 v1(57.27,14.29) ; v1(101.06,58.54) 100.94,58.66 PC1056.2 ; PC1149.2 123.91,62.89 PC1147.2 123.92,62.92 125.01,62.92 v1(125.11,63.02) ; CC176.2 115.7,40.9 v1(116.09,40.9) ; CD68.2 CD69.2 87.54,7.56 v1(88.04,7.56) ; CC100.2 CC101.2 148.99,59.85 v1(149.26,59.58) ; v1(132.45,59.14) 132.45,59.7 CC314.2 ; PQ1207.4 v1(33.63,37.23) ; QN5.4 v1(221.94,36.52) ; PR653.1 60.22,50.69 v1(60.9,50.69) 60.9,50.11 PC654.1 ; PQ1204.4 v1(15.25,31.51) ; v1(168.03,6.03) 168.43,5.63 CD58.2 ; CI7.2 v1(26.42,76.66) ; CI3.2 v1(20.89,79.66) ; v1(303.97,62.45) 304.02,62.41 304.02,62.22 CI37.2 CI31.2 ; CR19.1 v1(6.74,59.26) ; CE312.2 CE311.2 303.45,68.26 303.08,67.89 RE56.2 302.76,66.42 v1(303.09,66.09) ; PQ1208.4 v1(28.91,32.02) ; CZ128.2 v1(272.29,74.14) ; PQ1209.1 v1(17.71,53.42)
  TOP w0.457: v1(105.95,63.14) 105.95,62.73 PC1024.2 ; v1(115.23,59.14) 115.23,58.73 PC1082.2 ; PC647.1 v1(60.21,54.5) ; CA62.2 296.8,27.96 v1(297.25,27.51) 297.69,27.96 RA45.2 ; v1(107.15,58.25) 107.15,57.84 PC1014.2 ; v1(103.54,63.14) 103.54,62.73 PC1020.2 ; v1(104.74,60.72) 104.74,60.32 PC1016.2 ; v1(111.77,59.61) 111.36,59.61 PC1006.2 ; PC1133.2 103.54,55.43 v1(103.54,55.83) ; v1(116.44,59.14) 116.44,58.73 PC1068.2 ; v1(105.95,60.72) 105.95,60.32 PC1132.2 ; v1(104.74,63.14) 104.74,62.73 PC1019.2 ; v1(105.95,58.25) 105.95,57.84 PC1026.2 ; v1(109.29,58.4) 108.88,58.4 PC1322.2 ; v1(115.23,61.49) 115.23,61.08 PC1069.2 ; v1(309.12,69.3) 308.93,69.11 RE550.2 RE20.2 ; v1(104.74,55.83) 104.74,55.43 PC1022.2 ; v1(23.07,89.32) 22.59,88.84 RT130.2 ; PC1073.2 117.12,57.19 v1(117.12,56.79) ; v1(113.96,59.14) 113.96,58.73 PC1076.2 ; v1(114.65,56.79) 114.65,57.19 PC1077.2 ; v1(75.89,47.14) 75.89,47.84 PC603.2 ; PR611.2 72.55,45.84 72.9,45.49 v1(73.1,45.49) 73.42,45.81 PR608.2 74.44,45.18 PC644.2 ; v1(105.95,55.83) 105.95,55.43 PC1136.2 ; PC1327.2 108.88,59.67 v1(109.29,59.67) ; PC1071.2 119.66,59.54 v1(119.26,59.54) ; CC307.2 66.93,39.74 v1(67.21,40.02) 66.5,40.02 65.88,40.64 RC219.2 ; PC1137.2 103.54,57.84 v1(103.54,58.25) ; PC1134.2 104.74,57.84 v1(104.74,58.25) ; PC116.2 v1(162.74,118.46) ; CN21.2 259.87,51.1 v1(259.87,52.9) ; PC1003.2 113.96,61.08 v1(113.96,61.49) ; v1(28.83,40.53) 29.22,40.15 PC1217.2 ; v1(102.98,57.45) 102.6,57.45 PC1129.2 ; v1(318.5,68.75) 318.09,69.15 QZ4.3 ; PC1079.2 117.71,61.08 v1(117.71,61.49) ; PR927.2 37.79,33.48 v1(37.28,33.99) 36.66,33.37 PQ909.3 ; v1(116.44,61.49) 116.44,61.08 PC1078.2 ; PR961.2 31.63,28.85 v1(31.18,28.4) 30.74,28.85 PC949.1 ; PC1066.2 115.85,57.19 v1(115.85,56.79) ; v1(32.45,86.38) 32.21,86.38 CT74.2 ; v1(107.15,60.72) 107.15,60.32 PC1021.2 ; PC1070.2 119.66,60.81 v1(119.26,60.81) ; PR631.1 71.3,57.39 v1(71.3,56.76) PC621.1 ; RC3.2 129.16,79.36 v1(129.38,79.58) ; CA72.2 299.35,27.51 v1(298.84,27.51) 298.71,27.63 RA51.2 ; v1(111.77,58.34) 111.36,58.34 PC1064.2 ; v1(295.96,51.56) 295.46,51.56 295.36,51.45 RN60.2 ; v1(109.29,57.13) 108.88,57.13 PC1323.2 ; RN53.2 v1(263.66,52.79) ; CZ60.2 CZ59.2 171.39,44.02 v1(170.95,44.47) ; PC1005.2 119.66,58.34 v1(119.26,58.34) ; RN174.2 266.32,52.82 266.81,53.31 267.34,53.31 v1(267.49,53.15) ; PR925.2 32.86,33.5 PR953.2 32.72,33.03 v1(33.03,32.72) ; RN179.2 v1(262.64,52.53) RN176.2 ; PC1065.2 111.36,60.88 v1(111.77,60.88) ; PC1326.2 108.88,60.88 v1(109.29,60.88) ; PC1324.2 108.88,55.92 v1(109.29,55.92) ; CC316.2 139.71,41.42 v1(139.96,41.17) ; v1(103.54,60.72) 103.54,60.32 PC1015.2 ; v1(117.71,59.14) 117.71,58.73 PC1074.2
  TOP w0.508: CC32.2 64.48,26.08 v1(64.9,26.08) CC28.2 ; DA6.1 v1(285.44,29.74) ; v1(129.78,41.27) 129.93,41.41 RC7.2 ; v1(305.21,56.62) 305.26,56.67 305.26,56.68 305.69,57.11 CI33.2 ; PQ1209.4 16.18,54.72 PC1214.2 15.77,54.97 v1(15.33,55.41) ; JUSB2.7 v1(15.19,74.4) ; RC337.2 v1(152.67,35.88) ; v1(24.2,77.55) CT86.2 ; v1(225.91,3.57) 225.91,4.39 JUSH1.28 226.67,4.5 v1(226.67,3.6) ; v1(57.43,78.2) 57.54,78.3 PC3.2 ; JUSH1.27 227.46,21.97 v1(227.71,21.72) ; v1(296.7,45.02) 296.99,44.73 297.44,44.73 ; CR5.2 v1(24.01,56.58) ; CA66.2 CA65.2 v1(271.05,45.99) ; PC943.2 17.27,10.64 PC944.2 17.28,9.98 v1(17.07,9.77) ; v1(38.99,84.28) 38.68,84.6 CT72.2 ; PD2.1 v1(21.04,3.49) ; CC331.2 127.73,37.6 v1(127.26,37.6) ; v1(297.5,52.47) 298.21,51.76 CI38.2 ; v1(45.61,52.78) 45.61,52.1 PC224.2 ; CD38.2 149.93,16.46 v1(149.93,16.78) ; PC1204.2 v1(16.01,56.77) ; CD54.2 v1(190.12,4.39) ; v1(19.16,88.13) 19.16,88.41 19.59,88.84 RT414.2 RT415.2 ; PC645.2 v1(59.33,46.09) ; v1(23.7,91.03) RT413.2 RT410.2 ; QZ8.3 293.66,67.67 v1(293.35,67.98) ; CD36.2 CD33.2 155.58,14.49 v1(156.11,15.02) ; v1(174.44,2.43) 174.3,2.29 RD31.2 ; RE95.1 v1(311.92,78.38) ; CC295.2 120.58,38.44 v1(121.39,38.44) ; QN1.4 279.28,41.1 v1(278.9,41.48) ; RN54.2 RN40.2 269.17,45.48 v1(269.4,45.26) ; SW3.1 v1(323.81,92.65) ; CC340.2 v1(175.65,33.55) ; CD6.2 v1(76.37,12.19) ; CC294.2 110.39,41.39 v1(109.53,41.39) ; CD7.2 71.72,6.03 v1(72.23,6.54) ; RC89.2 131.96,41.58 v1(132.46,41.08) ; RC89.2 RC5.2 RC7.2 ; RC89.2 RC88.2 RC311.2 ; PC1140.2 125.47,55.76 v1(125.76,55.47) ; CC325.2 125.52,60.75 v1(125.74,60.53) ; PC937.1 v1(28.15,7.79) ; v1(195.39,15.28) 195.85,15.74 CZ118.2 CZ117.2 ; v1(30.8,46.94) 31.03,46.94 31.16,47.07 CR18.1 ; v1(285.26,34.42) 285.15,34.31 DA7.1 ; PC1209.2 PR1227.2 v1(16.01,84.19) ; RN185.2 226.58,32.78 v1(226.94,32.43) ; v1(191.5,13.24) 190.8,13.24 CD52.2 ; v1(64.66,104.21) 64.47,104.21 PQ7.3 ; v1(282.33,67.46) 282.38,67.46 CZ134.2 ; v1(60.01,78.19) 60.03,78.2 60.97,78.2 PC2.1 ; RC7.2 RC6.2 128.94,41.89 128.94,41.04 ; QE2.1 298.22,62.36 298.07,62.5 CE54.2 298.35,62.93 v1(298.73,63.31) ; CZ29.2 CZ36.2 v1(216.65,4.39) ; DA1.1 v1(313,35.07) ; v1(155.45,59.4) 155.58,59.53 RC316.2 ; v1(219.23,17.93) 219.14,18.01 CZ61.2 ; CN64.2 CN63.2 292.94,28.85 293.13,29.04 RA37.2 v1(293.55,28.38) ; CZ57.2 CZ58.2 182.96,31.37 v1(183.27,31.07) ; v1(271.02,54.12) 271.61,53.54 CZ197.2 ; PC10.2 v1(75.69,104.73) ; PC605.1 75.68,52.61 v1(75.95,52.34) ; v1(11.56,12.65) 10.11,12.65 PQ1216.3 10.75,13.86 PC918.1 ; v1(134.4,87.06) 134.4,86.52 CC221.2 ; v1(287.07,79.19) 286.92,79.34 CE57.2 ; v1(81.83,3.53) 81.83,4.23 CD25.2 CD26.2 ; RL12.2 v1(271.2,85.11) ; RV86.2 RV84.2 v1(93.25,95.65) ; DI2.1 v1(24.94,72.07) ; RV76.2 v1(111.79,95.46) ; v1(11.72,10.99) 12.29,11.56 PR930.2 PC938.2 ; CD35.2 145.83,15.03 v1(145.83,14.29) ; PC1211.2 v1(67.45,107.71) ; PR24.2 62.18,106.42 v1(61.71,105.95) ; CT85.2 28.02,74.55 v1(27.63,74.95) 26.9,74.95 26.55,75.3 CI6.2 ; v1(130.46,34.69) 130.18,34.97 CC266.2 131.06,35.43 RC220.2 ; CZ85.2 CZ86.2 216.18,15.84 v1(216.63,16.29) ; CC202.2 123.35,79.68 v1(123.2,79.52) ; RD21.2 v1(187.14,1.6) ; RZ10.1 220.05,20.44 v1(219.69,20.8) ; RT136.2 RT305.2 21.4,101.05 21.09,101.36 v1(21.09,101.62) ; RA52.1 CA61.2 291.62,39.92 291.04,39.34 v1(291.04,38.79) 290.84,38.58 CA54.2 CA33.2 ; JSPK1.6 269.92,35.51 v1(269.54,35.13) ; v1(209.96,9.62) 209.75,9.83 JKBTP1.22 ; CZ72.2 219.23,14.5 CZ69.2 CZ73.2 v1(218.63,13.51) ; DA3.1 310.52,39.92 310.52,41.61 311.6,42.69 v1(312.23,42.69) ; CT82.2 v1(37.85,76.15) ; CT84.2 40.39,88.65 v1(40.23,88.82) ; v1(281.2,48.1) 281.3,48 JLED1.7 ; CC323.2 v1(143.77,62.22) ; v1(289.96,47.62) 289.96,47.6 289.4,47.6 JLED1.8 289,48.26 289.65,48.91 290.96,48.91 291.34,49.29 CZ198.2 ; v1(302.54,48.25) 302.2,48.6 RI43.2 RI58.2 RI45.2 ; PC1.2 22.53,5.68 v1(22.74,5.48) ; v1(139.2,38.51) 139.74,38.51 RC349.2 ; v1(293.5,71.14) 293.5,70.75 292.98,70.24 CE28.2 293.1,69.77 293.1,69.27 293.6,68.76 RE55.2 293.8,68.75 RE58.2 ; v1(30.04,74.41) RT103.2 ; CD61.2 140.54,4.3 141.15,4.91 141.15,5.76 v1(141.43,6.03) ; RT86.2 34.61,74.63 v1(34.17,74.19) 33.72,74.63 RT99.2 ; CZ41.2 v1(126.67,101.75) ; CZ55.2 168.98,45.17 v1(169.3,45.48) ; QE17.3 v1(318.65,63.97) ; v1(74.39,6.41) 74.14,6.16 CD3.2 ; PD1.1 v1(18.21,2.78) ; PC931.1 v1(11.66,20.27) ; v1(16.87,20.01) 16.41,20.47 PC926.2 ; JCRT1.6 321.71,84.77 321.71,84.77 v1(321.39,85.08) ; YL1.2 287.51,90.9 v1(286.29,90.9) ; RZ62.2 164.47,33.72 v1(164.47,34.59) ; CZ210.2 207.69,7.77 CZ113.2 208.21,7.24 208.21,5.73 v1(207.92,5.45) ; CZ68.2 v1(218.62,12.62) ; PC321.2 175.98,100.96 v1(176.51,101.49) 176.97,101.03 PC319.2 ; JKBTP1.21 v1(209.75,26.21) ; PC947.2 19.34,10.05 v1(19.98,10.69) 20.07,10.78 PR948.2 20.08,11.49 PC950.1 ; DI5.1 v1(310.06,50.82) ; CD53.2 190.58,8.95 v1(189.75,8.12) ; CC224.2 131.82,56.55 v1(131.82,57.01) ; RN38.2 258.35,44.19 v1(258,44.19) ; CZ104.2 129.88,28.66 v1(130.02,28.8) ; v1(317,91.97) 317.68,92.65 SW3.3 ; v1(204.54,7.52) 205.06,7 CZ114.2 ; v1(68.55,6.16) 68.29,5.91 CD4.2 ; v1(187.18,15.45) 187.24,15.51 RZ38.1 ; v1(60.55,11.62) 59.95,12.22 CD8.2 ; CR26.2 v1(19.91,42.17) ; CC296.2 120.78,40.15 121.28,39.65 v1(121.39,39.65) ; v1(65.79,11.7) 65.63,11.87 CD1.2 ; v1(38.99,77.23) RT65.2 RT64.2 ; v1(284.54,72.2) CE36.2 ; CZ127.2 CZ126.2 275.95,70.17 v1(276.41,70.63) ; CZ91.2 CZ92.2 216.18,12.67 v1(216.46,12.39) 216.03,11.96 CZ84.2 ; RD9.2 88.52,5.74 v1(87.99,6.27) ; RV123.1 277.53,50.18 v1(278.07,50.18) ; v1(119.56,39.46) 119.51,39.41 CC178.2 ; RD23.2 v1(188.09,1.61) ; CC27.2 125.18,35.51 RC411.2 125.06,35.4 v1(125.06,34.84) 125.35,34.55 CC324.2 ; RZ25.2 v1(268.2,77.1) ; PR514.2 197.61,2.19 PC513.2 v1(196.91,2.2) ; RD5.2 v1(101.89,3.05) ; PR1222.2 v1(15.3,39.21) ; CE52.2 v1(304.47,90.7) ; v1(296.36,38.59) 296.03,38.92 296.03,39.28 CA31.2 ; RE541.1 315.73,62.77 CE65.2 v1(315.09,62.82) ; v1(107.66,3.34) 106.88,2.56 CD22.2 ; RD16.2 RD18.2 v1(86.7,2.43) ; RT307.2 RT142.2 19.39,94.76 v1(20.1,94.05) ; PC320.2 177.96,101.06 v1(177.53,101.49) ; CE61.2 303.56,86.47 CE40.2 303.6,86.12 v1(304.21,85.51) ; v1(156.9,38.88) 156.96,38.94 CZ56.2 ; v1(58.03,88.01) 58.5,88.01 58.84,88.35 PQ3.3 58.39,88.89 PR8.1 ; CA59.2 v1(311.47,26.94) ; RV80.2 v1(93.11,100.11) ; CC307.2 CC269.2 ; CT213.2 26.83,92.98 v1(27.18,92.63) 26.68,92.12 RT300.2 RT301.2 ; RT302.2 RT138.2 26.28,98.84 v1(26.93,98.84) ; CA67.2 CA68.2 v1(271.53,80.17) ; v1(305.57,39.39) 305.57,39.96 CA49.2 ; v1(284.36,91.08) CL14.2 RL13.2 ; CR25.2 v1(22.67,42.17) ; CD2.2 79.34,11.54 v1(79.25,11.45) ; PC1075.2 v1(84.02,81.55) ; PC1011.2 v1(81.6,81.55) ; UZ6.3 138.72,27.73 v1(140.47,29.48) ; v1(18.01,22.14) 18.24,21.91 PC927.2 ; v1(292.68,34.78) 292.68,34.78 293.12,34.34 CA56.2 ; PR1210.2 v1(13.48,36.91) ; QC6.3 180.55,36.28 v1(180.15,36.28) ; v1(53.94,6.03) 54.01,5.97 CD5.2 ; v1(54.74,37.36) CC306.2 ; CZ80.2 218.14,26.18 v1(218.17,26.15) ; CA53.2 v1(293.44,36.02) ; RT306.2 26.78,94.68 v1(27.11,95.01) 26.62,95.5 RT140.2 ; CE53.2 309.12,91.51 309.33,91.31 v1(310.14,91.31) ; UV2.2 115.42,106.57 v1(115.89,106.57) ; v1(298.96,43.33) 298.96,42.31 CA46.2 ; CT117.2 21.25,96.84 v1(21.21,96.88) ; CD39.2 140.03,11.85 v1(140.28,11.61) ; RN183.2 v1(211.71,32.4) ; CT73.2 v1(25.9,85.55) ; CC341.2 161.57,55.44 v1(161.78,55.24) ; CD34.2 156.95,14.49 v1(156.81,14.36) ; PC11.2 v1(71.13,102.57) ; CI45.2 v1(20.13,80) ; YL1.4 v1(289.14,87.89) ; CZ67.2 221.52,15.51 v1(221.7,15.33) ; PC1001.2 v1(82.81,81.55) ; PR506.2 v1(121.04,112.29) ; PC111.2 v1(152.1,109.06) ; QE2.4 296.26,60.03 v1(295.9,59.67) 295.69,59.67 295.18,59.16 CN31.2 ; v1(149.37,71.09) 149.37,70.82 CC219.2 ; v1(105.74,2.06) 105.67,2.13 RD7.2 ; CI44.2 CI43.2 310.9,47.39 v1(311.28,47.77) ; v1(138.88,103.52) PC407.2 v1(140.25,103.52) ; v1(57.81,91.98) 57.81,92.25 PQ6.3 ; v1(152.27,61.87) 152.12,61.87 152.06,61.81 v3(151.26,61.81) 150.89,61.81 150.12,61.04 RC96.2 ; v1(306.17,65.65) 306.17,65.65 306.31,65.79 CE16.2 ; CD29.2 64.97,5.62 65.25,5.9 v1(65.25,6.08) ; CR20.1 7.82,59.39 v1(8.64,59.39) ; v1(272.2,26.87) 272.08,26.76 JSPK1.5 267.84,26.76 v1(267.69,26.91) ; v1(291.66,73.61) 291.88,73.61 CE29.2 ; RE65.2 298.98,86.54 298.98,87.74 299.34,88.11 JTAG1.2 299.73,88.91 v1(299.72,88.91) ; v1(22.61,11.12) 22.61,11.83 22.99,12.21 PC946.2 ; PC942.2 22.99,15.64 v1(22.71,15.36) ; CV81.2 v1(96.33,101.19) ; v1(190.09,2.42) PR516.2 ; RV82.2 v1(93.15,98.32) ; DA2.1 v1(309.5,31.01) ; CZ87.2 215.73,16.78 CZ83.2 215.97,17.63 v1(216.54,17.06) ; CV133.2 v1(317.63,77.06) ; RT96.2 v1(30.05,86.7) ; v1(148.72,38.25) RC268.2 ; CL18.2 v1(275.91,104.03) ; CZ64.2 221.26,13.76 v1(221.67,14.17) ; v1(47.44,92.98) 47.99,92.98 PD6.2 ; RT63.2 v1(33.53,88.28) ; RN31.2 RN62.2 295.53,54.31 295.61,54.23 v1(296.02,54.23) 296.02,54.18 296.59,53.61 RI35.1 ; RC338.2 v1(150.75,38.25) ; RZ155.2 v1(282.2,62.25) ; RI36.1 v1(304.3,54.37) ; v1(69.56,108.2) PQ1212.3 68.97,109.65 PC1206.2 68.97,111.26 PR1219.2 68.98,112.1 PR1249.2 69.06,112.58 v1(69.33,112.85) ; CV132.2 318.88,75.44 318.88,75.44 v1(320.57,75.44) ; CD59.2 v1(186.59,14.2) ; RD25.2 v1(170.31,3.45) ; v1(301.63,90.7) CE47.2 ; RN72.2 v1(296.04,56.28) ; CD20.2 CD21.2 ; PC1208.2 v1(13.4,84.14) ; JUSB1.7 v1(313.62,49.85)
  GND1 w0.203: 267.65,56.47 H14.1 ; H14.1 265.88,57.13 ; H14.1 269.42,57.13 ; H14.1 267.65,61.33 ; H14.1 269.42,60.67 ; H14.1 270.08,58.9 ; H14.1 265.22,58.9 ; H14.1 265.88,60.67 ; 88.4,107.6 JUSB3.10 ; JUSB3.10 89.35,107.6 ; JUSB3.10 87.45,107.6 ; JUSB3.10 88.4,111.3 ; JUSB3.10 89.35,111.3 ; JUSB3.10 89.35,109.45 ; 308.22,98.9 H10.1 ; H10.1 310.15,96.97 ; H10.1 308.73,97.48 ; H10.1 310.15,100.83 ; H10.1 308.73,100.32 ; H10.1 311.57,97.48 ; H10.1 312.08,98.9 ; H10.1 311.57,100.32 ; 320.68,42.15 JUSB1.11 ; JUSB1.11 320.68,41.74 ; JUSB1.11 323.42,42.15 ; 294.56,88.99 H8.1 ; H8.1 294.56,86.01 ; H8.1 297.54,88.99 ; H8.1 296.05,85.47 ; H8.1 294.02,87.5 ; H8.1 297.54,86.01 ; H8.1 298.08,87.5 ; H8.1 296.05,89.53 ; 14.92,70.9 JUSB2.4 ; JUSB2.4 15.66,70.16 ; JUSB2.4 15.09,70.33 ; JUSB2.4 15.66,71.64 ; JUSB2.4 16.23,71.47 ; JUSB2.4 16.23,70.33 ; JUSB2.4 15.09,71.47 ; JUSB2.4 16.4,70.9 ; SW1.5 270.79,94.54 ; SW1.5 269.02,95.31 ; SW1.5 270.54,93.78 ; SW1.5 269.78,93.54 ; SW1.5 269.78,95.55 ; SW1.5 270.54,95.31 ; SW1.5 269.02,93.78 ; SW1.5 268.78,94.54 ; JHDMI1.20 96.68,108.67 ; JHDMI1.20 94.92,108.67 ; JHDMI1.20 96.68,110.42 ; JHDMI1.20 94.92,110.42 ; JHDMI1.20 95.8,108.67 ; JHDMI1.20 96.68,112.17 ; H15.1 272.08,101.4 ; H15.1 267.22,101.4 ; H15.1 269.65,98.97 ; H15.1 269.65,103.83 ; H15.1 267.88,103.17 ; H15.1 271.42,99.63 ; H15.1 271.42,103.17 ; H15.1 267.88,99.63 ; 287.03,111.85 JLOM1.14 ; JLOM1.14 286.11,115.35 ; JLOM1.14 287.03,115.35 ; JLOM1.14 286.11,111.85 ; JLOM1.14 286.11,113.6 ; JUSB2.11 15.63,82.25 ; JUSB2.11 12.51,83.2 ; JUSB2.11 15.63,81.3 ; JUSB2.11 12.51,82.25 ; JUSB2.11 14.07,81.3 ; JUSB2.11 14.07,83.2 ; JUSB2.11 15.63,83.2 ; 280.91,109.16 H29.1 ; H29.1 282.15,112.08 ; H29.1 283.39,111.64 ; H29.1 283.83,110.4 ; H29.1 283.39,109.16 ; H29.1 280.47,110.4 ; H29.1 280.91,111.64 ; H29.1 282.15,108.72 ; H20.1 202.75,39.53 ; H20.1 202.75,34.67 ; H20.1 200.98,38.87 ; H20.1 204.52,38.87 ; H20.1 204.52,35.33 ; H20.1 205.18,37.1 ; H20.1 200.32,37.1 ; H20.1 200.98,35.33 ; 79.98,107.95 JUSB3.7 ; JUSB3.7 81.12,107.95 ; JUSB3.7 80.55,107.78 ; JUSB3.7 81.29,108.52 ; JUSB3.7 81.12,109.09 ; JUSB3.7 79.98,109.09 ; JUSB3.7 79.81,108.52 ; 71.75,114.84 JUSB3.12 ; JUSB3.12 71.75,117.66 ; JUSB3.12 71.75,116.25 ; JUSB3.12 72.7,117.66 ; JUSB3.12 72.7,114.84 ; H38.1 149.89,117.4 ; H38.1 145.85,119.1 ; H38.1 145.85,115.7 ; H38.1 147.55,119.74 ; H38.1 145.21,117.4 ; H38.1 149.25,115.7 ; H38.1 147.55,115.06 ; H38.1 149.25,119.1 ; H12.1 324.89,23.64 ; H12.1 321.97,22.4 ; H12.1 323.65,20.72 ; H12.1 325.33,22.4 ; H12.1 322.41,23.64 ; H12.1 324.89,21.16 ; H12.1 322.41,21.16 ; H12.1 323.65,24.08 ; 321.49,79.75 JCRT1.8 ; JCRT1.8 321.63,79.23 ; JCRT1.8 321.63,80.26 ; JUSBC1.6 1.55,103.73 ; JUSBC1.6 0.37,103.73 ; JUSBC1.6 3.43,103.73 ; JUSBC1.6 3.43,102.9 ; JUSBC1.6 0.37,102.9 ; 313.83,49.85 JUSB1.7 ; JUSB1.7 314,49.25 ; JUSB1.7 314,50.45 ; JUSB1.7 314.6,49.07 ; JUSB1.7 315.2,49.25 ; JUSB1.7 314.6,50.63 ; JUSB1.7 315.2,50.45 ; JHDMI1.11 104.01,110.86 ; JHDMI1.11 103.09,110.86 ; JHDMI1.11 104.01,111.78 ; JHDMI1.11 103.09,111.78 ; JHDMI1.11 103.55,111.9 ; JHDMI1.11 103.55,110.74 ; JUSB3.13 89.35,117.66 ; JUSB3.13 89.35,116.25 ; JUSB3.13 89.35,114.84 ; JUSB3.13 88.4,117.66 ; JUSB3.13 88.4,114.84 ; H23.1 6.25,107.78 ; H23.1 7.49,104.86 ; H23.1 6.25,104.42 ; H23.1 5.01,104.86 ; H23.1 7.93,106.1 ; H23.1 4.57,106.1 ; H23.1 7.49,107.34 ; H23.1 5.01,107.34 ; 106.55,110.74 JHDMI1.17 ; JHDMI1.17 106.09,110.86 ; JHDMI1.17 106.55,111.9 ; JHDMI1.17 107.01,111.78 ; JHDMI1.17 106.09,111.78 ; JHDMI1.17 107.01,110.86 ; 320.62,88.65 JCRT1.17 ; JCRT1.17 323.88,87.93 ; JCRT1.17 322.25,87.93 ; JCRT1.17 320.62,89.37 ; JCRT1.17 323.88,89.37 ; JCRT1.17 322.25,89.37 ; JCRT1.17 320.62,87.93 ; JCRT1.17 323.88,88.65 ; 321.49,82.04 JCRT1.7 ; JCRT1.7 321.63,82.55 ; JCRT1.7 321.63,81.52 ; H25.1 5.59,7.26 ; H25.1 4.45,9.94 ; H25.1 3.31,7.26 ; H25.1 5.99,8.4 ; H25.1 3.31,9.54 ; H25.1 5.59,9.54 ; H25.1 2.91,8.4 ; H25.1 4.45,6.86 ; H34.1 91.43,94.4 ; H34.1 89.35,96.48 ; H34.1 89.35,92.32 ; H34.1 87.27,94.4 ; H34.1 87.83,95.92 ; H34.1 90.87,95.92 ; H34.1 90.87,92.88 ; H34.1 87.83,92.88 ; 76.48,106.45 JUSB3.4 ; JUSB3.4 77.05,106.28 ; JUSB3.4 77.79,107.02 ; JUSB3.4 76.48,107.59 ; JUSB3.4 77.62,107.59 ; JUSB3.4 77.62,106.45 ; JUSB3.4 76.31,107.02 ; JUSB3.4 77.05,107.76 ; 116.55,115.31 H26.1 ; H26.1 115.38,118.07 ; H26.1 117.72,118.07 ; H26.1 117.72,115.73 ; H26.1 116.55,118.49 ; H26.1 114.96,116.9 ; H26.1 115.38,115.73 ; H26.1 118.14,116.9 ; 321.63,75.68 JCRT1.10 ; JCRT1.10 321.63,74.65 ; JCRT1.10 321.49,75.17 ; 6.85,91.95 JUSBC1.1 ; JUSBC1.1 8.18,93.51 ; JUSBC1.1 5.52,91.95 ; JUSBC1.1 8.18,91.95 ; JUSBC1.1 8.18,92.73 ; JUSB1.13 323.42,58.38 ; JUSB1.13 323.42,57.55 ; JUSB1.13 320.68,57.55 ; JUSB1.13 320.68,58.38 ; JUSB1.13 322.05,58.38 ; 146.81,47.45 H4.1 ; H4.1 149.15,45.11 ; H4.1 147.45,45.75 ; H4.1 150.85,45.75 ; H4.1 150.85,49.15 ; H4.1 147.45,49.15 ; H4.1 149.15,49.79 ; H4.1 151.49,47.45 ; JUSB2.10 15.63,66.55 ; JUSB2.10 14.07,65.6 ; JUSB2.10 14.07,67.5 ; JUSB2.10 12.51,65.6 ; JUSB2.10 15.63,65.6 ; JUSB2.10 15.63,67.5 ; JUSB2.10 12.51,66.55 ; 67.35,115.31 H16.1 ; H16.1 66.18,118.07 ; H16.1 68.52,115.73 ; H16.1 66.18,115.73 ; H16.1 67.35,118.49 ; H16.1 68.94,116.9 ; H16.1 65.76,116.9 ; H16.1 68.52,118.07 ; 312.33,53.35 JUSB1.4 ; JUSB1.4 312.5,52.75 ; JUSB1.4 313.7,53.95 ; JUSB1.4 313.1,52.57 ; JUSB1.4 313.88,53.35 ; JUSB1.4 313.7,52.75 ; 315.81,20.67 H32.1 ; H32.1 318.05,24.13 ; H32.1 315.81,24.13 ; H32.1 320.29,22.4 ; H32.1 320.29,20.67 ; H32.1 320.29,24.13 ; H32.1 318.05,20.67 ; H32.1 315.81,22.4 ; 109.42,112.17 JHDMI1.21 ; JHDMI1.21 109.42,110.42 ; JHDMI1.21 111.18,108.67 ; JHDMI1.21 109.42,108.67 ; JHDMI1.21 110.3,108.67 ; JHDMI1.21 111.18,110.42 ; 122.23,95.92 H35.1 ; H35.1 125.83,94.4 ; H35.1 122.23,92.88 ; H35.1 123.75,96.48 ; H35.1 123.75,92.32 ; H35.1 125.27,95.92 ; H35.1 121.67,94.4 ; H35.1 125.27,92.88 ; JUSBC1.5 3.43,90.37 ; JUSBC1.5 0.37,90.37 ; JUSBC1.5 0.37,91.2 ; JUSBC1.5 3.43,91.2 ; JUSBC1.5 1.55,90.37 ; 144.25,79.41 H3.1 ; H3.1 145.95,80.05 ; H3.1 144.25,84.09 ; H3.1 142.55,83.45 ; H3.1 142.55,80.05 ; H3.1 141.91,81.75 ; H3.1 145.95,83.45 ; H3.1 146.59,81.75 ; 98.59,110.28 JHDMI1.2 ; JHDMI1.2 99.05,110.4 ; JHDMI1.2 99.51,110.28 ; JHDMI1.2 99.05,109.24 ; JHDMI1.2 99.51,109.36 ; JHDMI1.2 98.47,109.82 ; JHDMI1.2 98.59,109.36 ; 102.05,109.24 JHDMI1.8 ; JHDMI1.8 102.51,109.36 ; JHDMI1.8 102.51,110.28 ; JHDMI1.8 102.05,110.4 ; JHDMI1.8 101.59,110.28 ; JHDMI1.8 101.59,109.36 ; JUSB2.7 14.73,74.97 ; JUSB2.7 14.16,73.66 ; JUSB2.7 14.16,75.14 ; JUSB2.7 14.73,73.83 ; JUSB2.7 14.9,74.4 ; JCRT1.6 322.15,84.99 ; JCRT1.6 321.63,83.81 ; JCRT1.6 321.63,84.84 ; JCRT1.6 321.49,84.33 ; 3.21,4.24 H18.1 ; H18.1 3.21,1.76 ; H18.1 5.69,4.24 ; H18.1 4.45,4.68 ; H18.1 6.13,3 ; H18.1 2.77,3 ; H18.1 4.45,1.32 ; H18.1 5.69,1.76 ; JUSBC1.3 6.25,93.96 ; JUSBC1.3 6.25,91.95 ; JUSBC1.3 5.53,91.95 ; JUSBC1.3 6.97,93.96 ; JUSBC1.3 6.97,91.95 ; 92.72,115.82 JHDMI1.22 ; JHDMI1.22 94.88,115.82 ; JHDMI1.22 94.88,117.4 ; JHDMI1.22 92.72,118.98 ; JHDMI1.22 92.72,117.4 ; JHDMI1.22 94.88,118.98 ; JHDMI1.22 93.8,118.98 ; JHDMI1.22 93.8,115.82 ; JUSB2.13 6.57,83.2 ; JUSB2.13 8.03,82.25 ; JUSB2.13 5.11,82.25 ; JUSB2.13 8.03,83.2 ; JUSB2.13 5.11,83.2 ; JCRT1.16 322.25,69.27 ; JCRT1.16 323.88,68.55 ; JCRT1.16 320.62,68.55 ; JCRT1.16 323.88,69.27 ; JCRT1.16 320.62,69.27 ; JCRT1.16 323.88,67.83 ; JCRT1.16 322.25,67.83 ; JCRT1.16 320.62,67.83 ; H1.1 89.99,73.4 ; H1.1 85.31,73.4 ; H1.1 85.95,71.7 ; H1.1 87.65,75.74 ; H1.1 89.35,71.7 ; H1.1 85.95,75.1 ; H1.1 89.35,75.1 ; H1.1 87.65,71.06 ; 268.78,88.24 SW1.4 ; SW1.4 270.79,88.24 ; SW1.4 270.54,89 ; SW1.4 269.78,87.24 ; SW1.4 270.54,87.48 ; SW1.4 269.02,87.48 ; SW1.4 269.02,89 ; 312.13,42.62 JUSB1.10 ; JUSB1.10 314.87,44.28 ; JUSB1.10 312.13,44.28 ; JUSB1.10 313.5,42.62 ; JUSB1.10 314.87,43.45 ; JUSB1.10 312.13,43.45 ; JUSB1.10 314.87,42.62 ; JUSB1.10 313.5,44.28 ; 5.01,89.24 H24.1 ; H24.1 6.25,89.68 ; H24.1 7.49,89.24 ; H24.1 5.01,86.76 ; H24.1 4.57,88 ; H24.1 7.49,86.76 ; H24.1 7.93,88 ; H24.1 6.25,86.32 ; H2.1 89.35,47.1 ; H2.1 89.99,45.4 ; H2.1 85.95,43.7 ; H2.1 87.65,47.74 ; H2.1 89.35,43.7 ; H2.1 85.31,45.4 ; H2.1 87.65,43.06 ; H2.1 85.95,47.1 ; JUSBC1.2 6.85,102.15 ; JUSBC1.2 5.52,102.15 ; JUSBC1.2 8.18,101.37 ; JUSBC1.2 8.18,102.15 ; JUSBC1.2 8.18,100.59 ; JUSB2.12 8.03,65.6 ; JUSB2.12 6.57,65.6 ; JUSB2.12 5.11,66.55 ; JUSB2.12 5.11,65.6 ; JUSB2.12 8.03,66.55 ; 321.63,73.5 JCRT1.5 ; JCRT1.5 322.15,73.36 ; JCRT1.5 321.49,74.02 ; JCRT1.5 321.63,74.54 ; 233.41,14.01 H7.1 ; H7.1 232.87,15.5 ; H7.1 234.9,13.47 ; H7.1 236.93,15.5 ; H7.1 236.39,14.01 ; H7.1 234.9,17.53 ; H7.1 233.41,16.99 ; H7.1 236.39,16.99 ; JUSB1.12 314.87,57.08 ; JUSB1.12 312.13,57.08 ; JUSB1.12 314.87,56.25 ; JUSB1.12 313.5,57.08 ; 100.09,111.78 JHDMI1.5 ; JHDMI1.5 100.09,110.86 ; JHDMI1.5 100.55,110.74 ; JHDMI1.5 101.01,111.78 ; JHDMI1.5 100.55,111.9 ; JHDMI1.5 101.01,110.86 ; 111.22,118.98 JHDMI1.23 ; JHDMI1.23 113.38,117.4 ; JHDMI1.23 112.3,118.98 ; JHDMI1.23 113.38,118.98 ; JHDMI1.23 113.38,115.82 ; JHDMI1.23 111.22,117.4 ; JHDMI1.23 111.22,115.82 ; JHDMI1.23 112.3,115.82 ; JLOM1.15 306.99,113.6 ; JLOM1.15 306.99,111.85 ; JLOM1.15 306.08,111.85 ; JLOM1.15 306.08,115.35 ; JUSB3.11 72.7,111.3 ; JUSB3.11 71.75,107.6 ; JUSB3.11 73.65,107.6 ; JUSB3.11 72.7,107.6 ; JUSB3.11 71.75,109.45 ; JUSB3.11 71.75,111.3 ; 6.25,100.14 JUSBC1.4 ; JUSBC1.4 6.25,102.15 ; JUSBC1.4 6.97,102.15 ; JUSBC1.4 6.97,100.14 ; JUSBC1.4 5.53,102.15
  GND2 w0.203: H24.1 6.25,89.68 ; H24.1 6.25,86.32 ; H24.1 4.57,88 ; H24.1 7.49,86.76 ; H24.1 7.93,88 ; H24.1 5.01,86.76 ; H24.1 7.49,89.24 ; H24.1 5.01,89.24 ; 320.68,58.38 JUSB1.13 ; JUSB1.13 320.68,57.55 ; JUSB1.13 322.05,58.38 ; JUSB1.13 323.42,57.55 ; JUSB1.13 323.42,58.38 ; 306.08,111.85 JLOM1.15 ; JLOM1.15 306.99,111.85 ; JLOM1.15 306.99,113.6 ; JLOM1.15 306.08,115.35 ; JCRT1.16 322.25,69.27 ; JCRT1.16 323.88,69.27 ; JCRT1.16 320.62,67.83 ; JCRT1.16 320.62,68.55 ; JCRT1.16 323.88,68.55 ; JCRT1.16 322.25,67.83 ; JCRT1.16 320.62,69.27 ; JCRT1.16 323.88,67.83 ; 294.56,86.01 H8.1 ; H8.1 297.54,86.01 ; H8.1 296.05,85.47 ; H8.1 296.05,89.53 ; H8.1 298.08,87.5 ; H8.1 294.56,88.99 ; H8.1 297.54,88.99 ; H8.1 294.02,87.5 ; JUSBC1.1 8.18,93.51 ; JUSBC1.1 8.18,92.73 ; JUSBC1.1 6.85,91.95 ; JUSBC1.1 8.18,91.95 ; JUSBC1.1 5.52,91.95 ; 147.45,49.15 H4.1 ; H4.1 147.45,45.75 ; H4.1 149.15,49.79 ; H4.1 150.85,49.15 ; H4.1 149.15,45.11 ; H4.1 150.85,45.75 ; H4.1 146.81,47.45 ; H4.1 151.49,47.45 ; JUSB2.4 16.23,71.47 ; JUSB2.4 16.4,70.9 ; JUSB2.4 15.66,70.16 ; JUSB2.4 15.09,70.33 ; JUSB2.4 16.23,70.33 ; JUSB2.4 15.09,71.47 ; JUSB2.4 15.66,71.64 ; JUSB2.4 14.92,70.9 ; JHDMI1.22 94.88,118.98 ; JHDMI1.22 92.72,117.4 ; JHDMI1.22 92.72,118.98 ; JHDMI1.22 93.8,115.82 ; JHDMI1.22 94.88,115.82 ; JHDMI1.22 93.8,118.98 ; JHDMI1.22 94.88,117.4 ; JHDMI1.22 92.72,115.82 ; 115.38,115.73 H26.1 ; H26.1 116.55,118.49 ; H26.1 117.72,115.73 ; H26.1 116.55,115.31 ; H26.1 115.38,118.07 ; H26.1 118.14,116.9 ; H26.1 117.72,118.07 ; H26.1 114.96,116.9 ; 85.31,45.4 H2.1 ; H2.1 87.65,47.74 ; H2.1 89.35,43.7 ; H2.1 85.95,47.1 ; H2.1 87.65,43.06 ; H2.1 89.99,45.4 ; H2.1 85.95,43.7 ; H2.1 89.35,47.1 ; H16.1 68.94,116.9 ; H16.1 68.52,115.73 ; H16.1 66.18,118.07 ; H16.1 67.35,115.31 ; H16.1 67.35,118.49 ; H16.1 66.18,115.73 ; H16.1 65.76,116.9 ; H16.1 68.52,118.07 ; JUSB3.4 77.62,106.45 ; JUSB3.4 76.31,107.02 ; JUSB3.4 77.05,106.28 ; JUSB3.4 77.79,107.02 ; JUSB3.4 76.48,106.45 ; JUSB3.4 77.62,107.59 ; JUSB3.4 77.05,107.76 ; JUSB3.4 76.48,107.59 ; JUSB1.10 313.5,44.28 ; JUSB1.10 312.13,42.62 ; JUSB1.10 314.87,44.28 ; JUSB1.10 313.5,42.62 ; JUSB1.10 312.13,43.45 ; JUSB1.10 314.87,43.45 ; JUSB1.10 312.13,44.28 ; JUSB1.10 314.87,42.62 ; 111.22,117.4 JHDMI1.23 ; JHDMI1.23 111.22,115.82 ; JHDMI1.23 113.38,118.98 ; JHDMI1.23 113.38,115.82 ; JHDMI1.23 112.3,115.82 ; JHDMI1.23 113.38,117.4 ; JHDMI1.23 112.3,118.98 ; JHDMI1.23 111.22,118.98 ; 14.07,65.6 JUSB2.10 ; JUSB2.10 12.51,65.6 ; JUSB2.10 12.51,66.55 ; JUSB2.10 15.63,67.5 ; JUSB2.10 14.07,67.5 ; JUSB2.10 15.63,65.6 ; JUSB2.10 15.63,66.55 ; JHDMI1.2 99.51,109.36 ; JHDMI1.2 98.59,110.28 ; JHDMI1.2 99.05,109.24 ; JHDMI1.2 98.47,109.82 ; JHDMI1.2 98.59,109.36 ; JHDMI1.2 99.05,110.4 ; JHDMI1.2 99.51,110.28 ; 3.21,1.76 H18.1 ; H18.1 6.13,3 ; H18.1 5.69,1.76 ; H18.1 5.69,4.24 ; H18.1 4.45,1.32 ; H18.1 2.77,3 ; H18.1 3.21,4.24 ; H18.1 4.45,4.68 ; 87.27,94.4 H34.1 ; H34.1 87.83,92.88 ; H34.1 89.35,92.32 ; H34.1 91.43,94.4 ; H34.1 90.87,92.88 ; H34.1 89.35,96.48 ; H34.1 87.83,95.92 ; H34.1 90.87,95.92 ; 71.75,114.84 JUSB3.12 ; JUSB3.12 71.75,117.66 ; JUSB3.12 71.75,116.25 ; JUSB3.12 72.7,117.66 ; JUSB3.12 72.7,114.84 ; 100.09,111.78 JHDMI1.5 ; JHDMI1.5 101.01,110.86 ; JHDMI1.5 100.09,110.86 ; JHDMI1.5 101.01,111.78 ; JHDMI1.5 100.55,110.74 ; JHDMI1.5 100.55,111.9 ; JHDMI1.21 111.18,108.67 ; JHDMI1.21 110.3,108.67 ; JHDMI1.21 111.18,110.42 ; JHDMI1.21 109.42,110.42 ; JHDMI1.21 109.42,108.67 ; JHDMI1.21 109.42,112.17 ; JUSBC1.3 6.97,91.95 ; JUSBC1.3 6.97,93.96 ; JUSBC1.3 5.53,91.95 ; JUSBC1.3 6.25,93.96 ; JUSBC1.3 6.25,91.95 ; 5.11,83.2 JUSB2.13 ; JUSB2.13 5.11,82.25 ; JUSB2.13 8.03,82.25 ; JUSB2.13 8.03,83.2 ; JUSB2.13 6.57,83.2 ; 142.55,83.45 H3.1 ; H3.1 146.59,81.75 ; H3.1 144.25,84.09 ; H3.1 142.55,80.05 ; H3.1 145.95,83.45 ; H3.1 144.25,79.41 ; H3.1 141.91,81.75 ; H3.1 145.95,80.05 ; H25.1 5.99,8.4 ; H25.1 3.31,9.54 ; H25.1 4.45,9.94 ; H25.1 4.45,6.86 ; H25.1 5.59,9.54 ; H25.1 3.31,7.26 ; H25.1 5.59,7.26 ; H25.1 2.91,8.4 ; H29.1 283.39,109.16 ; H29.1 282.15,108.72 ; H29.1 283.39,111.64 ; H29.1 283.83,110.4 ; H29.1 280.91,111.64 ; H29.1 280.91,109.16 ; H29.1 280.47,110.4 ; H29.1 282.15,112.08 ; JUSB1.11 323.42,42.15 ; JUSB1.11 320.68,42.15 ; JUSB1.11 320.68,41.74 ; 121.67,94.4 H35.1 ; H35.1 125.83,94.4 ; H35.1 123.75,92.32 ; H35.1 123.75,96.48 ; H35.1 125.27,95.92 ; H35.1 122.23,92.88 ; H35.1 122.23,95.92 ; H35.1 125.27,92.88 ; 322.25,87.93 JCRT1.17 ; JCRT1.17 320.62,87.93 ; JCRT1.17 320.62,89.37 ; JCRT1.17 323.88,87.93 ; JCRT1.17 320.62,88.65 ; JCRT1.17 323.88,89.37 ; JCRT1.17 323.88,88.65 ; JCRT1.17 322.25,89.37 ; 314.6,49.07 JUSB1.7 ; JUSB1.7 315.2,49.25 ; JUSB1.7 314,49.25 ; JUSB1.7 313.83,49.85 ; JUSB1.7 314,50.45 ; JUSB1.7 315.2,50.45 ; JUSB1.7 314.6,50.63 ; 103.09,110.86 JHDMI1.11 ; JHDMI1.11 103.55,111.9 ; JHDMI1.11 103.55,110.74 ; JHDMI1.11 104.01,110.86 ; JHDMI1.11 103.09,111.78 ; JHDMI1.11 104.01,111.78 ; H15.1 271.42,99.63 ; H15.1 267.22,101.4 ; H15.1 269.65,103.83 ; H15.1 269.65,98.97 ; H15.1 267.88,99.63 ; H15.1 271.42,103.17 ; H15.1 272.08,101.4 ; H15.1 267.88,103.17 ; JUSB1.12 313.5,57.08 ; JUSB1.12 314.87,57.08 ; JUSB1.12 312.13,57.08 ; JUSB1.12 314.87,56.25 ; 265.88,60.67 H14.1 ; H14.1 265.22,58.9 ; H14.1 269.42,60.67 ; H14.1 269.42,57.13 ; H14.1 267.65,56.47 ; H14.1 265.88,57.13 ; H14.1 267.65,61.33 ; H14.1 270.08,58.9 ; 200.32,37.1 H20.1 ; H20.1 204.52,35.33 ; H20.1 200.98,35.33 ; H20.1 204.52,38.87 ; H20.1 200.98,38.87 ; H20.1 202.75,34.67 ; H20.1 205.18,37.1 ; H20.1 202.75,39.53 ; 12.51,83.2 JUSB2.11 ; JUSB2.11 15.63,83.2 ; JUSB2.11 15.63,82.25 ; JUSB2.11 14.07,81.3 ; JUSB2.11 14.07,83.2 ; JUSB2.11 15.63,81.3 ; JUSB2.11 12.51,82.25 ; H38.1 149.25,115.7 ; H38.1 149.25,119.1 ; H38.1 149.89,117.4 ; H38.1 145.21,117.4 ; H38.1 147.55,115.06 ; H38.1 145.85,119.1 ; H38.1 147.55,119.74 ; H38.1 145.85,115.7 ; 4.57,106.1 H23.1 ; H23.1 7.49,107.34 ; H23.1 5.01,107.34 ; H23.1 6.25,104.42 ; H23.1 6.25,107.78 ; H23.1 7.93,106.1 ; H23.1 7.49,104.86 ; H23.1 5.01,104.86 ; JUSBC1.2 8.18,101.37 ; JUSBC1.2 8.18,100.59 ; JUSBC1.2 5.52,102.15 ; JUSBC1.2 6.85,102.15 ; JUSBC1.2 8.18,102.15 ; JUSBC1.5 3.43,90.37 ; JUSBC1.5 1.55,90.37 ; JUSBC1.5 0.37,91.2 ; JUSBC1.5 0.37,90.37 ; JUSBC1.5 3.43,91.2 ; H10.1 311.57,100.32 ; H10.1 308.73,100.32 ; H10.1 311.57,97.48 ; H10.1 310.15,100.83 ; H10.1 310.15,96.97 ; H10.1 308.22,98.9 ; H10.1 312.08,98.9 ; H10.1 308.73,97.48 ; JUSBC1.6 3.43,102.9 ; JUSBC1.6 0.37,102.9 ; JUSBC1.6 1.55,103.73 ; JUSBC1.6 0.37,103.73 ; JUSBC1.6 3.43,103.73 ; 79.98,109.09 JUSB3.7 ; JUSB3.7 81.12,107.95 ; JUSB3.7 79.98,107.95 ; JUSB3.7 80.55,107.78 ; JUSB3.7 81.29,108.52 ; JUSB3.7 79.81,108.52 ; JUSB3.7 81.12,109.09 ; JUSB3.13 89.35,114.84 ; JUSB3.13 89.35,116.25 ; JUSB3.13 88.4,114.84 ; JUSB3.13 89.35,117.66 ; JUSB3.13 88.4,117.66 ; 312.5,52.75 JUSB1.4 ; JUSB1.4 313.88,53.35 ; JUSB1.4 313.7,53.95 ; JUSB1.4 312.33,53.35 ; JUSB1.4 313.1,52.57 ; JUSB1.4 313.7,52.75 ; 94.92,108.67 JHDMI1.20 ; JHDMI1.20 96.68,110.42 ; JHDMI1.20 94.92,110.42 ; JHDMI1.20 96.68,108.67 ; JHDMI1.20 95.8,108.67 ; JHDMI1.20 96.68,112.17 ; H1.1 89.35,75.1 ; H1.1 85.31,73.4 ; H1.1 85.95,75.1 ; H1.1 87.65,71.06 ; H1.1 87.65,75.74 ; H1.1 89.35,71.7 ; H1.1 89.99,73.4 ; H1.1 85.95,71.7 ; 321.63,81.52 JCRT1.7 ; JCRT1.7 321.63,82.55 ; JCRT1.7 321.49,82.04 ; 318.05,20.67 H32.1 ; H32.1 315.81,22.4 ; H32.1 318.05,24.13 ; H32.1 320.29,22.4 ; H32.1 320.29,24.13 ; H32.1 315.81,20.67 ; H32.1 315.81,24.13 ; H32.1 320.29,20.67 ; 232.87,15.5 H7.1 ; H7.1 234.9,17.53 ; H7.1 233.41,16.99 ; H7.1 234.9,13.47 ; H7.1 233.41,14.01 ; H7.1 236.39,16.99 ; H7.1 236.93,15.5 ; H7.1 236.39,14.01 ; JUSBC1.4 6.25,102.15 ; JUSBC1.4 6.25,100.14 ; JUSBC1.4 5.53,102.15 ; JUSBC1.4 6.97,102.15 ; JUSBC1.4 6.97,100.14 ; 106.09,111.78 JHDMI1.17 ; JHDMI1.17 107.01,111.78 ; JHDMI1.17 106.55,110.74 ; JHDMI1.17 106.09,110.86 ; JHDMI1.17 107.01,110.86 ; JHDMI1.17 106.55,111.9 ; 321.63,83.81 JCRT1.6 ; JCRT1.6 321.63,84.84 ; JCRT1.6 322.15,84.99 ; JCRT1.6 321.49,84.33 ; 323.65,20.72 H12.1 ; H12.1 323.65,24.08 ; H12.1 322.41,23.64 ; H12.1 325.33,22.4 ; H12.1 324.89,21.16 ; H12.1 321.97,22.4 ; H12.1 324.89,23.64 ; H12.1 322.41,21.16 ; 71.75,109.45 JUSB3.11 ; JUSB3.11 73.65,107.6 ; JUSB3.11 72.7,107.6 ; JUSB3.11 71.75,107.6 ; JUSB3.11 71.75,111.3 ; JUSB3.11 72.7,111.3 ; 321.49,74.02 JCRT1.5 ; JCRT1.5 321.63,73.5 ; JCRT1.5 321.63,74.54 ; JCRT1.5 322.15,73.36 ; JUSB2.7 14.73,74.97 ; JUSB2.7 14.9,74.4 ; JUSB2.7 14.73,73.83 ; JUSB2.7 14.16,73.66 ; JUSB2.7 14.16,75.14 ; 87.45,107.6 JUSB3.10 ; JUSB3.10 88.4,111.3 ; JUSB3.10 89.35,107.6 ; JUSB3.10 88.4,107.6 ; JUSB3.10 89.35,111.3 ; JUSB3.10 89.35,109.45 ; 269.78,87.24 SW1.4 ; SW1.4 269.02,89 ; SW1.4 270.54,87.48 ; SW1.4 270.54,89 ; SW1.4 270.79,88.24 ; SW1.4 268.78,88.24 ; SW1.4 269.02,87.48 ; JHDMI1.8 102.05,110.4 ; JHDMI1.8 102.51,110.28 ; JHDMI1.8 101.59,110.28 ; JHDMI1.8 102.51,109.36 ; JHDMI1.8 101.59,109.36 ; JHDMI1.8 102.05,109.24 ; SW1.5 269.78,95.55 ; SW1.5 269.02,95.31 ; SW1.5 270.54,95.31 ; SW1.5 270.54,93.78 ; SW1.5 268.78,94.54 ; SW1.5 269.78,93.54 ; SW1.5 269.02,93.78 ; SW1.5 270.79,94.54 ; 321.49,75.17 JCRT1.10 ; JCRT1.10 321.63,74.65 ; JCRT1.10 321.63,75.68 ; JLOM1.14 287.03,115.35 ; JLOM1.14 286.11,113.6 ; JLOM1.14 286.11,115.35 ; JLOM1.14 286.11,111.85 ; JLOM1.14 287.03,111.85 ; 321.49,79.75 JCRT1.8 ; JCRT1.8 321.63,79.23 ; JCRT1.8 321.63,80.26 ; JUSB2.12 8.03,65.6 ; JUSB2.12 5.11,65.6 ; JUSB2.12 5.11,66.55 ; JUSB2.12 8.03,66.55 ; JUSB2.12 6.57,65.6
  IN2 w0.254: v1(287.07,79.19) 286.25,79.19 282.83,75.77 282.83,75.52 282.16,74.84 282.16,72.97 279.75,70.56 279.75,67.16 280.32,66.58 280.32,65.75 281.01,65.06 282.45,65.06 283.14,64.37 283.14,60.09 v1(283.06,60.01) 283.06,59.35 282.1,58.39 282.1,56.84 281.26,56 280.5,56 279.56,56.94 279.56,57.47 280.04,57.95 280.04,59.43 v1(280.36,59.75) 280.37,59.76 280.37,60.85 279.91,61.31 279.07,61.31 277.65,62.74 277.65,67 277.85,67.2 277.85,70.23 277.34,70.74 277.34,71.89 278.35,72.91 278.35,73.44 278.38,73.44 278.9,73.97 279.13,73.97 279.69,74.52 279.69,77.34 280.7,78.35 282.37,78.35 284.41,80.4 284.41,82.2 285.39,83.19 287.22,83.19 289.8,85.77 289.8,86.81 291.03,88.03 291.03,91.12 292.91,93 297.95,93 299.93,91.02 299.93,90.72 300.87,89.78 313.61,89.78 314.9,91.07 317,91.07 317.5,90.57 317.5,80.79 317.25,80.54 316.57,80.54 315.18,81.92 v1(314.65,81.92)
  VCC w0.203: JUSBC1.6 3.43,103.73 ; JUSBC1.6 0.37,102.9 ; JUSBC1.6 0.37,103.73 ; JUSBC1.6 3.43,102.9 ; JUSBC1.6 1.55,103.73 ; 92.72,118.98 JHDMI1.22 ; JHDMI1.22 92.72,115.82 ; JHDMI1.22 93.8,118.98 ; JHDMI1.22 94.88,115.82 ; JHDMI1.22 92.72,117.4 ; JHDMI1.22 94.88,118.98 ; JHDMI1.22 93.8,115.82 ; JHDMI1.22 94.88,117.4 ; 269.02,93.78 SW1.5 ; SW1.5 270.79,94.54 ; SW1.5 269.02,95.31 ; SW1.5 269.78,95.55 ; SW1.5 270.54,95.31 ; SW1.5 269.78,93.54 ; SW1.5 268.78,94.54 ; SW1.5 270.54,93.78 ; JUSB2.12 8.03,66.55 ; JUSB2.12 6.57,65.6 ; JUSB2.12 5.11,66.55 ; JUSB2.12 8.03,65.6 ; JUSB2.12 5.11,65.6 ; JUSB3.11 72.7,111.3 ; JUSB3.11 71.75,111.3 ; JUSB3.11 71.75,107.6 ; JUSB3.11 72.7,107.6 ; JUSB3.11 71.75,109.45 ; JUSB3.11 73.65,107.6 ; 308.73,100.32 H10.1 ; H10.1 308.73,97.48 ; H10.1 311.57,100.32 ; H10.1 310.15,100.83 ; H10.1 311.57,97.48 ; H10.1 308.22,98.9 ; H10.1 310.15,96.97 ; H10.1 312.08,98.9 ; H23.1 7.93,106.1 ; H23.1 5.01,104.86 ; H23.1 4.57,106.1 ; H23.1 7.49,104.86 ; H23.1 7.49,107.34 ; H23.1 6.25,107.78 ; H23.1 6.25,104.42 ; H23.1 5.01,107.34 ; 321.49,84.33 JCRT1.6 ; JCRT1.6 321.63,83.81 ; JCRT1.6 321.63,84.84 ; 12.51,65.6 JUSB2.10 ; JUSB2.10 15.63,65.6 ; JUSB2.10 14.07,65.6 ; JUSB2.10 12.51,66.55 ; JUSB2.10 15.63,66.55 ; JUSB2.10 14.07,67.5 ; JUSB2.10 15.63,67.5 ; JHDMI1.2 99.05,110.4 ; JHDMI1.2 98.59,109.36 ; JHDMI1.2 98.47,109.82 ; JHDMI1.2 99.51,110.28 ; JHDMI1.2 99.51,109.36 ; JHDMI1.2 99.05,109.24 ; JHDMI1.2 98.59,110.28 ; H29.1 283.39,111.64 ; H29.1 280.91,111.64 ; H29.1 283.39,109.16 ; H29.1 283.83,110.4 ; H29.1 282.15,108.72 ; H29.1 280.91,109.16 ; H29.1 280.47,110.4 ; H29.1 282.15,112.08 ; JUSB3.10 89.35,109.45 ; JUSB3.10 87.45,107.6 ; JUSB3.10 88.4,111.3 ; JUSB3.10 89.35,107.6 ; JUSB3.10 88.4,107.6 ; JUSB3.10 89.35,111.3 ; 77.05,106.28 JUSB3.4 ; JUSB3.4 76.31,107.02 ; JUSB3.4 77.62,107.59 ; JUSB3.4 77.79,107.02 ; JUSB3.4 77.62,106.45 ; JUSB3.4 76.48,106.45 ; JUSB3.4 77.05,107.76 ; JUSB3.4 76.48,107.59 ; 321.63,74.54 JCRT1.5 ; JCRT1.5 321.49,74.02 ; JCRT1.5 321.63,73.5 ; JHDMI1.21 111.18,110.42 ; JHDMI1.21 109.42,112.17 ; JHDMI1.21 109.42,110.42 ; JHDMI1.21 111.18,108.67 ; JHDMI1.21 109.42,108.67 ; 14.07,81.3 JUSB2.11 ; JUSB2.11 12.51,82.25 ; JUSB2.11 15.63,82.25 ; JUSB2.11 15.63,83.2 ; JUSB2.11 15.63,81.3 ; JUSB2.11 14.07,83.2 ; JUSB2.11 12.51,83.2 ; 5.53,102.15 JUSBC1.4 ; JUSBC1.4 6.25,102.15 ; JUSBC1.4 6.97,100.14 ; JUSBC1.4 6.97,102.15 ; JUSBC1.4 6.25,100.14 ; 320.62,69.27 JCRT1.16 ; JCRT1.16 320.62,67.83 ; JCRT1.16 320.62,68.55 ; JCRT1.16 322.25,67.83 ; 321.49,75.17 JCRT1.10 ; JCRT1.10 321.63,75.68 ; JCRT1.10 321.63,74.65 ; 5.53,91.95 JUSBC1.3 ; JUSBC1.3 6.25,93.96 ; JUSBC1.3 6.25,91.95 ; JUSBC1.3 6.97,91.95 ; JUSBC1.3 6.97,93.96 ; 147.45,49.15 H4.1 ; H4.1 150.85,45.75 ; H4.1 149.15,49.79 ; H4.1 147.45,45.75 ; H4.1 149.15,45.11 ; H4.1 146.81,47.45 ; H4.1 150.85,49.15 ; H4.1 151.49,47.45 ; JUSBC1.2 8.18,100.59 ; JUSBC1.2 8.18,102.15 ; JUSBC1.2 6.85,102.15 ; JUSBC1.2 8.18,101.37 ; JUSBC1.2 5.52,102.15 ; 101.59,109.36 JHDMI1.8 ; JHDMI1.8 102.51,110.28 ; JHDMI1.8 102.05,109.24 ; JHDMI1.8 102.51,109.36 ; JHDMI1.8 102.05,110.4 ; JHDMI1.8 101.59,110.28 ; H18.1 5.69,1.76 ; H18.1 2.77,3 ; H18.1 3.21,1.76 ; H18.1 6.13,3 ; H18.1 5.69,4.24 ; H18.1 4.45,1.32 ; H18.1 3.21,4.24 ; H18.1 4.45,4.68 ; JUSB2.4 16.23,71.47 ; JUSB2.4 16.4,70.9 ; JUSB2.4 15.09,71.47 ; JUSB2.4 14.92,70.9 ; JUSB2.4 15.66,71.64 ; JUSB2.4 15.66,70.16 ; JUSB2.4 16.23,70.33 ; JUSB2.4 15.09,70.33 ; 94.92,110.42 JHDMI1.20 ; JHDMI1.20 96.68,108.67 ; JHDMI1.20 96.68,112.17 ; JHDMI1.20 96.68,110.42 ; JHDMI1.20 94.92,108.67 ; 269.65,98.97 H15.1 ; H15.1 267.88,103.17 ; H15.1 269.65,103.83 ; H15.1 272.08,101.4 ; H15.1 271.42,103.17 ; H15.1 271.42,99.63 ; H15.1 267.88,99.63 ; H15.1 267.22,101.4 ; JUSB1.13 322.74,58.38 ; JUSB1.13 322.05,58.38 ; JUSB1.13 320.68,58.38 ; 71.75,116.25 JUSB3.12 ; JUSB3.12 71.75,117.66 ; JUSB3.12 72.7,114.84 ; JUSB3.12 71.75,114.84 ; JUSB3.12 72.7,117.66 ; JUSB2.13 8.03,82.25 ; JUSB2.13 5.11,83.2 ; JUSB2.13 6.57,83.2 ; JUSB2.13 5.11,82.25 ; JUSB2.13 8.03,83.2 ; JHDMI1.11 104.01,111.78 ; JHDMI1.11 103.09,110.86 ; JHDMI1.11 103.09,111.78 ; JHDMI1.11 103.55,110.74 ; JHDMI1.11 103.55,111.9 ; JHDMI1.11 104.01,110.86 ; 100.55,110.74 JHDMI1.5 ; JHDMI1.5 100.09,110.86 ; JHDMI1.5 101.01,111.78 ; JHDMI1.5 100.09,111.78 ; JHDMI1.5 101.01,110.86 ; JHDMI1.5 100.55,111.9 ; JUSB2.7 14.16,75.14 ; JUSB2.7 14.73,73.83 ; JUSB2.7 14.16,73.66 ; JUSB2.7 14.9,74.4 ; JUSB2.7 14.73,74.97 ; H25.1 4.45,9.94 ; H25.1 5.59,7.26 ; H25.1 3.31,7.26 ; H25.1 4.45,6.86 ; H25.1 5.99,8.4 ; H25.1 3.31,9.54 ; H25.1 5.59,9.54 ; H25.1 2.91,8.4 ; 321.63,81.52 JCRT1.7 ; JCRT1.7 321.49,82.04 ; JCRT1.7 321.63,82.55 ; H2.1 89.99,45.4 ; H2.1 87.65,47.74 ; H2.1 85.95,43.7 ; H2.1 85.31,45.4 ; H2.1 89.35,47.1 ; H2.1 89.35,43.7 ; H2.1 85.95,47.1 ; H2.1 87.65,43.06 ; 115.38,115.73 H26.1 ; H26.1 116.55,118.49 ; H26.1 114.96,116.9 ; H26.1 118.14,116.9 ; H26.1 116.55,115.31 ; H26.1 115.38,118.07 ; H26.1 117.72,118.07 ; H26.1 117.72,115.73 ; JUSBC1.1 8.18,91.95 ; JUSBC1.1 6.85,91.95 ; JUSBC1.1 8.18,92.73 ; JUSBC1.1 8.18,93.51 ; JUSBC1.1 5.52,91.95 ; JUSB3.13 89.35,117.66 ; JUSB3.13 89.35,114.84 ; JUSB3.13 88.4,117.66 ; JUSB3.13 89.35,116.25 ; JUSB3.13 88.4,114.84 ; JCRT1.17 322.25,89.37 ; JCRT1.17 320.62,88.65 ; JCRT1.17 320.62,89.37 ; JCRT1.17 320.62,87.93 ; 111.22,117.4 JHDMI1.23 ; JHDMI1.23 113.38,117.4 ; JHDMI1.23 112.3,115.82 ; JHDMI1.23 111.22,118.98 ; JHDMI1.23 113.38,115.82 ; JHDMI1.23 111.22,115.82 ; JHDMI1.23 113.38,118.98 ; JHDMI1.23 112.3,118.98 ; 106.09,110.86 JHDMI1.17 ; JHDMI1.17 107.01,111.78 ; JHDMI1.17 106.55,110.74 ; JHDMI1.17 106.09,111.78 ; JHDMI1.17 107.01,110.86 ; JHDMI1.17 106.55,111.9 ; 4.57,88 H24.1 ; H24.1 6.25,89.68 ; H24.1 5.01,86.76 ; H24.1 5.01,89.24 ; H24.1 7.93,88 ; H24.1 7.49,89.24 ; H24.1 6.25,86.32 ; H24.1 7.49,86.76 ; 80.55,107.78 JUSB3.7 ; JUSB3.7 81.12,109.09 ; JUSB3.7 81.29,108.52 ; JUSB3.7 79.98,109.09 ; JUSB3.7 81.12,107.95 ; JUSB3.7 79.81,108.52 ; JUSB3.7 79.98,107.95 ; 0.37,90.37 JUSBC1.5 ; JUSBC1.5 1.55,90.37 ; JUSBC1.5 0.37,91.2 ; JUSBC1.5 3.43,91.2 ; JUSBC1.5 3.43,90.37 ; 321.63,80.26 JCRT1.8 ; JCRT1.8 321.63,79.23 ; JCRT1.8 321.49,79.75 ; 67.35,115.31 H16.1 ; H16.1 67.35,118.49 ; H16.1 65.76,116.9 ; H16.1 68.94,116.9 ; H16.1 66.18,118.07 ; H16.1 68.52,118.07 ; H16.1 68.52,115.73 ; H16.1 66.18,115.73
  GND3 w0.203: H34.1 90.87,95.92 ; H34.1 87.27,94.4 ; H34.1 91.43,94.4 ; H34.1 89.35,92.32 ; H34.1 90.87,92.88 ; H34.1 89.35,96.48 ; H34.1 87.83,95.92 ; H34.1 87.83,92.88 ; JCRT1.16 323.88,68.55 ; JCRT1.16 320.62,67.83 ; JCRT1.16 320.62,68.55 ; JCRT1.16 322.25,67.83 ; JCRT1.16 323.88,67.83 ; JCRT1.16 322.25,69.27 ; JCRT1.16 320.62,69.27 ; JCRT1.16 323.88,69.27 ; 94.92,110.42 JHDMI1.20 ; JHDMI1.20 95.8,108.67 ; JHDMI1.20 96.68,112.17 ; JHDMI1.20 94.92,108.67 ; JHDMI1.20 96.68,110.42 ; JHDMI1.20 96.68,108.67 ; H20.1 204.52,38.87 ; H20.1 200.98,35.33 ; H20.1 205.18,37.1 ; H20.1 204.52,35.33 ; H20.1 200.32,37.1 ; H20.1 202.75,34.67 ; H20.1 202.75,39.53 ; H20.1 200.98,38.87 ; JUSB3.10 89.35,111.3 ; JUSB3.10 87.45,107.6 ; JUSB3.10 88.4,111.3 ; JUSB3.10 89.35,107.6 ; JUSB3.10 89.35,109.45 ; JUSB3.10 88.4,107.6 ; 268.78,94.54 SW1.5 ; SW1.5 269.02,95.31 ; SW1.5 269.78,95.55 ; SW1.5 270.79,94.54 ; SW1.5 269.78,93.54 ; SW1.5 269.02,93.78 ; SW1.5 270.54,95.31 ; SW1.5 270.54,93.78 ; 85.95,71.7 H1.1 ; H1.1 85.31,73.4 ; H1.1 87.65,71.06 ; H1.1 89.35,75.1 ; H1.1 89.35,71.7 ; H1.1 85.95,75.1 ; H1.1 87.65,75.74 ; H1.1 89.99,73.4 ; JHDMI1.11 104.01,110.86 ; JHDMI1.11 104.01,111.78 ; JHDMI1.11 103.09,110.86 ; JHDMI1.11 103.55,111.9 ; JHDMI1.11 103.09,111.78 ; JHDMI1.11 103.55,110.74 ; 314.6,49.07 JUSB1.7 ; JUSB1.7 314.6,50.63 ; JUSB1.7 315.2,50.45 ; JUSB1.7 314,50.45 ; JUSB1.7 314,49.25 ; JUSB1.7 315.2,49.25 ; JUSB1.7 313.83,49.85 ; JUSBC1.2 8.18,100.59 ; JUSBC1.2 8.18,101.37 ; JUSBC1.2 6.85,102.15 ; JUSBC1.2 5.52,102.15 ; JUSBC1.2 8.18,102.15 ; 0.37,102.9 JUSBC1.6 ; JUSBC1.6 3.43,102.9 ; JUSBC1.6 1.55,103.73 ; JUSBC1.6 3.43,103.73 ; JUSBC1.6 0.37,103.73 ; JLOM1.14 287.03,115.35 ; JLOM1.14 287.03,111.85 ; JLOM1.14 286.11,113.6 ; JLOM1.14 286.11,115.35 ; JLOM1.14 286.11,111.85 ; JHDMI1.23 113.38,115.82 ; JHDMI1.23 113.38,117.4 ; JHDMI1.23 111.22,117.4 ; JHDMI1.23 112.3,115.82 ; JHDMI1.23 112.3,118.98 ; JHDMI1.23 111.22,118.98 ; JHDMI1.23 111.22,115.82 ; JHDMI1.23 113.38,118.98 ; H25.1 4.45,9.94 ; H25.1 5.59,9.54 ; H25.1 4.45,6.86 ; H25.1 2.91,8.4 ; H25.1 5.99,8.4 ; H25.1 3.31,7.26 ; H25.1 5.59,7.26 ; H25.1 3.31,9.54 ; JUSB1.10 314.87,42.62 ; JUSB1.10 314.87,44.28 ; JUSB1.10 313.5,42.62 ; JUSB1.10 312.13,44.28 ; JUSB1.10 313.5,44.28 ; JUSB1.10 312.13,43.45 ; JUSB1.10 314.87,43.45 ; JUSB1.10 312.13,42.62 ; 294.02,87.5 H8.1 ; H8.1 296.05,85.47 ; H8.1 297.54,88.99 ; H8.1 297.54,86.01 ; H8.1 296.05,89.53 ; H8.1 294.56,88.99 ; H8.1 294.56,86.01 ; H8.1 298.08,87.5 ; JUSB1.13 323.42,57.55 ; JUSB1.13 320.68,57.55 ; JUSB1.13 320.68,58.38 ; JUSB1.13 322.05,58.38 ; JUSB1.13 323.42,58.38 ; 321.49,84.33 JCRT1.6 ; JCRT1.6 321.63,84.84 ; JCRT1.6 321.63,83.81 ; JCRT1.6 322.15,84.99 ; 14.16,73.66 JUSB2.7 ; JUSB2.7 14.73,73.83 ; JUSB2.7 14.16,75.14 ; JUSB2.7 14.9,74.4 ; JUSB2.7 14.73,74.97 ; 72.7,114.84 JUSB3.12 ; JUSB3.12 71.75,114.84 ; JUSB3.12 71.75,117.66 ; JUSB3.12 72.7,117.66 ; JUSB3.12 71.75,116.25 ; 12.51,82.25 JUSB2.11 ; JUSB2.11 14.07,83.2 ; JUSB2.11 15.63,83.2 ; JUSB2.11 12.51,83.2 ; JUSB2.11 15.63,82.25 ; JUSB2.11 15.63,81.3 ; JUSB2.11 14.07,81.3 ; 310.15,96.97 H10.1 ; H10.1 308.73,100.32 ; H10.1 310.15,100.83 ; H10.1 308.73,97.48 ; H10.1 311.57,100.32 ; H10.1 308.22,98.9 ; H10.1 312.08,98.9 ; H10.1 311.57,97.48 ; H7.1 236.93,15.5 ; H7.1 232.87,15.5 ; H7.1 236.39,14.01 ; H7.1 233.41,16.99 ; H7.1 234.9,13.47 ; H7.1 236.39,16.99 ; H7.1 234.9,17.53 ; H7.1 233.41,14.01 ; 312.13,56.25 JUSB1.12 ; JUSB1.12 314.87,57.08 ; JUSB1.12 313.5,57.08 ; JUSB1.12 313.5,55.42 ; JUSB1.12 312.13,57.08 ; JUSB1.12 314.87,56.25 ; JUSB1.12 314.87,55.42 ; JHDMI1.8 102.51,110.28 ; JHDMI1.8 101.59,109.36 ; JHDMI1.8 102.05,109.24 ; JHDMI1.8 101.59,110.28 ; JHDMI1.8 102.51,109.36 ; JHDMI1.8 102.05,110.4 ; 109.42,112.17 JHDMI1.21 ; JHDMI1.21 109.42,108.67 ; JHDMI1.21 109.42,110.42 ; JHDMI1.21 111.18,110.42 ; JHDMI1.21 111.18,108.67 ; JHDMI1.21 110.3,108.67 ; JHDMI1.22 94.88,118.98 ; JHDMI1.22 92.72,115.82 ; JHDMI1.22 92.72,118.98 ; JHDMI1.22 93.8,118.98 ; JHDMI1.22 94.88,115.82 ; JHDMI1.22 94.88,117.4 ; JHDMI1.22 92.72,117.4 ; JHDMI1.22 93.8,115.82 ; 5.01,89.24 H24.1 ; H24.1 7.49,89.24 ; H24.1 4.57,88 ; H24.1 7.49,86.76 ; H24.1 6.25,86.32 ; H24.1 5.01,86.76 ; H24.1 6.25,89.68 ; H24.1 7.93,88 ; H2.1 89.99,45.4 ; H2.1 85.31,45.4 ; H2.1 85.95,43.7 ; H2.1 87.65,43.06 ; H2.1 89.35,47.1 ; H2.1 87.65,47.74 ; H2.1 85.95,47.1 ; H2.1 89.35,43.7 ; 1.55,90.37 JUSBC1.5 ; JUSBC1.5 3.43,91.2 ; JUSBC1.5 3.43,90.37 ; JUSBC1.5 0.37,90.37 ; JUSBC1.5 0.37,91.2 ; 65.76,116.9 H16.1 ; H16.1 68.52,118.07 ; H16.1 67.35,118.49 ; H16.1 66.18,115.73 ; H16.1 67.35,115.31 ; H16.1 66.18,118.07 ; H16.1 68.52,115.73 ; H16.1 68.94,116.9 ; 265.88,60.67 H14.1 ; H14.1 267.65,56.47 ; H14.1 267.65,61.33 ; H14.1 265.88,57.13 ; H14.1 269.42,60.67 ; H14.1 269.42,57.13 ; H14.1 270.08,58.9 ; H14.1 265.22,58.9 ; 14.07,65.6 JUSB2.10 ; JUSB2.10 14.07,67.5 ; JUSB2.10 12.51,66.55 ; JUSB2.10 12.51,65.6 ; JUSB2.10 15.63,67.5 ; JUSB2.10 15.63,66.55 ; JUSB2.10 15.63,65.6 ; 100.09,110.86 JHDMI1.5 ; JHDMI1.5 100.09,111.78 ; JHDMI1.5 101.01,111.78 ; JHDMI1.5 100.55,110.74 ; JHDMI1.5 100.55,111.9 ; JHDMI1.5 101.01,110.86 ; 5.52,91.95 JUSBC1.1 ; JUSBC1.1 8.18,92.73 ; JUSBC1.1 8.18,93.51 ; JUSBC1.1 6.85,91.95 ; JUSBC1.1 8.18,91.95 ; JUSB3.13 89.35,116.25 ; JUSB3.13 88.4,114.84 ; JUSB3.13 88.4,117.66 ; JUSB3.13 89.35,117.66 ; JUSB3.13 89.35,114.84 ; 2.77,3 H18.1 ; H18.1 4.45,1.32 ; H18.1 5.69,1.76 ; H18.1 3.21,4.24 ; H18.1 3.21,1.76 ; H18.1 4.45,4.68 ; H18.1 6.13,3 ; H18.1 5.69,4.24 ; SW1.4 270.54,87.48 ; SW1.4 269.02,89 ; SW1.4 270.54,89 ; SW1.4 268.78,88.24 ; SW1.4 269.02,87.48 ; SW1.4 270.79,88.24 ; SW1.4 269.78,87.24 ; 322.41,23.64 H12.1 ; H12.1 321.97,22.4 ; H12.1 322.41,21.16 ; H12.1 323.65,24.08 ; H12.1 325.33,22.4 ; H12.1 323.65,20.72 ; H12.1 324.89,23.64 ; H12.1 324.89,21.16 ; H35.1 123.75,96.48 ; H35.1 122.23,95.92 ; H35.1 125.27,95.92 ; H35.1 121.67,94.4 ; H35.1 123.75,92.32 ; H35.1 122.23,92.88 ; H35.1 125.83,94.4 ; H35.1 125.27,92.88 ; JLOM1.15 306.99,113.6 ; JLOM1.15 306.99,111.85 ; JLOM1.15 306.08,111.85 ; JLOM1.15 306.08,115.35 ; JUSB1.11 323.42,42.15 ; JUSB1.11 320.68,41.32 ; JUSB1.11 323.42,41.32 ; JUSB1.11 320.68,42.15 ; JUSB1.11 322.05,41.32 ; 321.63,81.52 JCRT1.7 ; JCRT1.7 321.63,82.55 ; JCRT1.7 321.49,82.04 ; 72.7,107.6 JUSB3.11 ; JUSB3.11 71.75,107.6 ; JUSB3.11 73.65,107.6 ; JUSB3.11 71.75,111.3 ; JUSB3.11 72.7,111.3 ; JUSB3.11 71.75,109.45 ; H15.1 272.08,101.4 ; H15.1 271.42,103.17 ; H15.1 267.88,99.63 ; H15.1 269.65,103.83 ; H15.1 267.22,101.4 ; H15.1 267.88,103.17 ; H15.1 269.65,98.97 ; H15.1 271.42,99.63 ; 114.96,116.9 H26.1 ; H26.1 117.72,118.07 ; H26.1 116.55,115.31 ; H26.1 117.72,115.73 ; H26.1 115.38,118.07 ; H26.1 116.55,118.49 ; H26.1 115.38,115.73 ; H26.1 118.14,116.9 ; H29.1 283.39,111.64 ; H29.1 283.83,110.4 ; H29.1 280.91,109.16 ; H29.1 283.39,109.16 ; H29.1 280.91,111.64 ; H29.1 280.47,110.4 ; H29.1 282.15,108.72 ; H29.1 282.15,112.08 ; JUSBC1.3 6.97,91.95 ; JUSBC1.3 5.53,91.95 ; JUSBC1.3 6.25,93.96 ; JUSBC1.3 6.97,93.96 ; JUSBC1.3 6.25,91.95 ; 315.81,22.4 H32.1 ; H32.1 315.81,20.67 ; H32.1 315.81,24.13 ; H32.1 320.29,20.67 ; H32.1 320.29,24.13 ; H32.1 318.05,24.13 ; H32.1 318.05,20.67 ; H32.1 320.29,22.4 ; JCRT1.17 323.88,89.37 ; JCRT1.17 320.62,88.65 ; JCRT1.17 323.88,88.65 ; JCRT1.17 320.62,87.93 ; JCRT1.17 320.62,89.37 ; JCRT1.17 322.25,87.93 ; JCRT1.17 322.25,89.37 ; JCRT1.17 323.88,87.93 ; 80.55,107.78 JUSB3.7 ; JUSB3.7 81.12,109.09 ; JUSB3.7 79.98,109.09 ; JUSB3.7 81.12,107.95 ; JUSB3.7 79.81,108.52 ; JUSB3.7 79.98,107.95 ; JUSB3.7 81.29,108.52 ; JUSB2.13 8.03,83.2 ; JUSB2.13 6.57,83.2 ; JUSB2.13 5.11,83.2 ; JUSB2.13 5.11,82.25 ; JUSB2.13 8.03,82.25 ; 321.63,79.23 JCRT1.8 ; JCRT1.8 321.63,80.26 ; JCRT1.8 321.49,79.75 ; 106.09,111.78 JHDMI1.17 ; JHDMI1.17 107.01,111.78 ; JHDMI1.17 106.09,110.86 ; JHDMI1.17 107.01,110.86 ; JHDMI1.17 106.55,110.74 ; JHDMI1.17 106.55,111.9 ; JUSBC1.4 6.97,100.14 ; JUSBC1.4 5.53,102.15 ; JUSBC1.4 6.25,102.15 ; JUSBC1.4 6.97,102.15 ; JUSBC1.4 6.25,100.14 ; 4.57,106.1 H23.1 ; H23.1 7.93,106.1 ; H23.1 6.25,104.42 ; H23.1 5.01,107.34 ; H23.1 7.49,107.34 ; H23.1 5.01,104.86 ; H23.1 6.25,107.78 ; H23.1 7.49,104.86 ; 321.63,75.68 JCRT1.10 ; JCRT1.10 321.49,75.17 ; JCRT1.10 321.63,74.65 ; 149.15,45.11 H4.1 ; H4.1 150.85,45.75 ; H4.1 149.15,49.79 ; H4.1 146.81,47.45 ; H4.1 150.85,49.15 ; H4.1 151.49,47.45 ; H4.1 147.45,49.15 ; H4.1 147.45,45.75 ; H3.1 146.59,81.75 ; H3.1 141.91,81.75 ; H3.1 145.95,80.05 ; H3.1 144.25,84.09 ; H3.1 144.25,79.41 ; H3.1 142.55,83.45 ; H3.1 142.55,80.05 ; H3.1 145.95,83.45 ; H38.1 149.89,117.4 ; H38.1 147.55,115.06 ; H38.1 145.21,117.4 ; H38.1 147.55,119.74 ; H38.1 145.85,115.7 ; H38.1 149.25,115.7 ; H38.1 145.85,119.1 ; H38.1 149.25,119.1 ; 312.33,53.35 JUSB1.4 ; JUSB1.4 313.1,52.57 ; JUSB1.4 312.5,53.95 ; JUSB1.4 313.1,54.13 ; JUSB1.4 313.7,52.75 ; JUSB1.4 313.88,53.35 ; JUSB1.4 312.5,52.75 ; JUSB1.4 313.7,53.95 ; JUSB2.4 15.66,71.64 ; JUSB2.4 16.23,70.33 ; JUSB2.4 15.09,70.33 ; JUSB2.4 16.23,71.47 ; JUSB2.4 15.09,71.47 ; JUSB2.4 14.92,70.9 ; JUSB2.4 16.4,70.9 ; JUSB2.4 15.66,70.16 ; 99.05,109.24 JHDMI1.2 ; JHDMI1.2 98.59,110.28 ; JHDMI1.2 98.47,109.82 ; JHDMI1.2 99.51,110.28 ; JHDMI1.2 99.51,109.36 ; JHDMI1.2 98.59,109.36 ; JHDMI1.2 99.05,110.4 ; 321.49,74.02 JCRT1.5 ; JCRT1.5 321.63,73.5 ; JCRT1.5 322.15,73.36 ; JCRT1.5 321.63,74.54 ; 77.05,106.28 JUSB3.4 ; JUSB3.4 77.62,107.59 ; JUSB3.4 76.48,106.45 ; JUSB3.4 77.79,107.02 ; JUSB3.4 76.31,107.02 ; JUSB3.4 76.48,107.59 ; JUSB3.4 77.62,106.45 ; JUSB3.4 77.05,107.76 ; 6.57,65.6 JUSB2.12 ; JUSB2.12 8.03,66.55 ; JUSB2.12 5.11,65.6 ; JUSB2.12 8.03,65.6 ; JUSB2.12 5.11,66.55
  BOTTOM w0.102: UC1.D34 117.8,67.19 117.8,66.69 117.45,66.34 UC1.F35 ; UC1.F37 116.47,66.34 116.02,66.79 116.02,67.65 115.58,68.09 115.09,68.09 v1(114.97,68.21) ; 116.34,70.39 116.36,70.39 116.97,69.78 116.97,69.04 UC1.B34 ; UC1.B39 115.12,69.07 115.12,69.89 115.38,70.15 115.38,70.59
  BOTTOM w0.127: v1(96.53,87.2) 96.53,86.38 96.72,86.19 96.72,85.68 96.37,85.34 v1(95.31,85.34) 94.92,85.34 v1(94.57,85.69) 94.48,85.69 93.67,86.51 93.67,86.87 93.35,87.19 93.35,91.08 ; UC1.C1 137.8,68.41 137.8,67.91 137.65,67.76 137.32,67.76 137.14,67.58 UC1.F1 ; UC1.F1 137.34,67.07 v1(137.77,67.07) ; UC1.F1 UC1.F2 ; v1(268.2,77.1) v3(268.2,78.05) ; 276.61,44.37 277.24,44.37 278.43,43.18 280.97,43.18 281.49,42.66 v1(281.49,42.36) ; v3(87.38,81.97) v1(88.91,81.97) ; UC1.F4 135.51,67.3 v1(135.64,67.43) ; v1(277.27,45.87) 277.27,45.29 278.71,43.85 280.83,43.85 281.21,44.23 v1(281.21,44.93) ; CZ124.2 275.74,47.39 275.18,47.95 271.92,47.95 v1(269.62,50.25) 269.25,50.61 268.51,50.61 267.11,49.22 JFAN1.5 267.62,47.8 269.83,47.8 270.34,47.28 274.76,47.28 275.14,46.9 CN3.2 ; v1(284.36,91.08) v3(283.49,91.08)
  BOTTOM w0.152: CC335.2 145.09,76.95 144.2,76.95 143.86,76.62 v1(143.86,75.5)
  BOTTOM w0.178: v1(127.09,46.49) 127.06,46.52 UC1.BB18 ; UC1.AG71 96.67,55.9 95.99,55.9 v1(95.87,55.78) ; v1(123.37,46.45) 123.31,46.5 123.31,47.01 UC1.BB26 ; v1(101.26,46.5) 101.26,46.5 101.26,46.88 UC1.BB64 ; v1(113.35,46.46) 113.38,46.48 UC1.BB43 ; UC1.AT71 96.24,50.89 v1(96.06,50.89) ; UC1.BB55 106.21,47.02 106.21,46.54 v1(106.25,46.5) ; v1(121.09,46.24) 120.96,46.37 120.96,46.76 UC1.BB30 ; v1(96.2,65.39) 96.3,65.5 UC1.H71 ; UC1.AM71 96.88,53.24 96.13,53.24 v1(96.07,53.19) ; v1(118.36,45.8) 118.33,45.83 118.33,47.14 UC1.BB34 ; UC1.BB60 103.61,46.54 v1(103.57,46.5) ; UC1.BB38 115.99,47.4 115.99,46.45 v1(116.02,46.43)
  BOTTOM w0.203: CN3.2 275.4,46.38 275.93,45.86 275.93,44.75 ; UC1.AF63 102.14,56.15 102.14,55.44 UC1.AH63 ; PU200.15 46.64,46.1 46.65,46.09 46.65,44.43 46.98,44.1 v1(47.07,44.1) ; UC1.AM55 106.46,53.47 UC1.AL55 106.91,55.11 106.69,55.34 106.18,55.34 105.95,55.57 v1(105.95,55.83) ; UC1.K61 102.32,64.76 UC1.K63 ; v1(115.14,49.87) 115.65,49.36 UC1.AW38 116.37,49.36 116.4,49.39 116.69,49.39 116.72,49.36 UC1.AW36 117.59,49.36 117.62,49.39 117.92,49.39 117.95,49.36 UC1.AW34 118.43,49.49 v1(118.8,49.85) 119.29,49.36 UC1.AW32 120.12,49.36 120.15,49.39 120.45,49.39 120.48,49.36 UC1.AW30 121.35,49.36 121.38,49.39 121.67,49.39 121.7,49.36 UC1.AW28 122.57,49.36 122.6,49.39 122.9,49.39 122.93,49.36 UC1.AW26 123.8,49.36 123.83,49.39 124.13,49.39 124.16,49.36 UC1.AW23 125.13,49.36 125.16,49.39 125.45,49.39 125.48,49.36 UC1.AW21 126.27,49.36 126.3,49.39 126.6,49.39 126.63,49.36 UC1.AW18 127.55,49.36 127.58,49.39 127.87,49.39 127.9,49.36 UC1.AW16 128.35,49.36 128.8,49.81 128.92,49.81 129.37,49.36 UC1.AW14 129.97,49.36 130,49.39 130.29,49.39 130.32,49.36 UC1.AW12 131.1,49.36 v1(131.6,49.87) 131.9,49.57 UC1.AW10 132.39,49.36 132.42,49.39 132.71,49.39 132.74,49.36 UC1.AW8 ; UC1.AV68 99.15,49.69 v1(99.6,49.23) ; UC1.AV68 99.11,49.7 99.11,50.07 99.16,50.12 99.16,50.3 99.11,50.47 UC1.AT68 99.11,51.28 99.14,51.31 99.14,51.6 99.11,51.63 UC1.AP68 99.11,52.5 99.14,52.53 99.14,52.83 99.11,52.86 UC1.AM68 ; UC1.AV68 98.83,49.69 v1(98.64,49.5) ; v1(104.74,55.83) 104.74,55.33 105.09,54.98 UC1.AL58 ; UC1.AL66 100.18,53.55 100.23,53.51 100.61,53.51 100.65,53.55 UC1.AL65 100.82,53.55 100.86,53.51 101.24,53.51 101.29,53.55 UC1.AL64 ; UC1.J25 122.46,64.49 v1(122.29,64.32) ; UC1.D44 UC1.D45 111.25,67.76 111.19,67.71 110.57,67.71 UC1.D47 ; UC1.AK68 98.53,54.83 98.07,54.83 UC1.AK69 ; UC1.AK68 98.81,54.57 99.14,54.9 v1(99.17,54.9) ; UC1.AK68 98.79,54.5 99.2,54.09 99.2,53.82 99.11,53.73 UC1.AM68 ; v1(110.57,67.24) 110.51,67.29 UC1.D47 ; v1(99.6,49.23) 99.79,49.23 UC1.AW66 100.14,49.41 101.11,49.41 UC1.AW64 101.64,49.36 101.67,49.39 101.97,49.39 102,49.36 UC1.AW62 102.87,49.36 102.9,49.39 103.19,49.39 103.22,49.36 UC1.AW60 104.1,49.36 104.13,49.39 104.42,49.39 104.45,49.36 UC1.AW57 105.37,49.36 105.4,49.39 105.7,49.39 105.73,49.36 UC1.AW55 106.6,49.36 106.63,49.39 106.92,49.39 106.95,49.36 UC1.AW53 107.82,49.36 107.85,49.39 108.15,49.39 108.18,49.36 UC1.AW51 108.99,49.36 109.02,49.39 109.31,49.39 109.34,49.36 UC1.AW49 110.25,49.36 110.28,49.39 110.57,49.39 110.6,49.36 UC1.AW47 111.41,49.36 111.44,49.39 111.74,49.39 111.77,49.36 UC1.AW45 112.64,49.36 112.69,49.41 112.84,49.41 112.86,49.39 112.92,49.39 112.92,49.4 112.93,49.39 112.96,49.39 112.99,49.36 113.48,49.36 UC1.AW43 ; v1(99.6,49.23) UC1.AY66 UC1.BA66 ; v1(121.95,55.34) 122,55.28 UC1.AK27 ; v1(131.6,65.94) UC1.G10 ; UC1.AD20 125.98,57.68 125.55,57.68 UC1.AD21 ; v1(136.02,70.3) 137.44,70.3 142.65,75.5 v1(143.86,75.5) ; UC1.AV1 137.99,49.57 v1(138.12,49.44) ; UC1.J28 120.63,64.56 120.68,64.51 v1(120.68,64.41) ; UC1.AM68 99.3,53.34 v1(99.6,53.04) ; UC1.AM60 103.62,53.55 102.89,53.55 UC1.AM61 ; UC1.K70 98.15,64.14 98.3,64.35 ; v1(146.21,76.75) 146.21,77.06 146.39,77.23 149.64,77.23 149.87,77.01 v1(149.87,76.35) v1(149.87,74) 149.87,73.32 149.64,73.09 146.82,73.09 CC334.2 145.93,72.2 145.14,72.2 144.89,72.46 144.89,72.99 144.56,73.32 143.54,73.32 139.56,69.34 v1(139.04,69.34) 138.45,68.75 UC1.C1 ; v1(98.99,46.14) 99.25,46.4 UC1.BB67 ; v1(109.29,55.92) 108.74,55.38 UC1.AL52 ; UC1.D47 109.88,67.76 UC1.D48 ; v1(118.8,64.54) UC1.J32 ; v1(95.99,63.89) 96.31,63.89 96.53,64.11 97.13,64.11 UC1.K71 ; UZ2.11 v1(278.07,50.18) ; UC1.D34 117.27,68.1 v1(117.39,68.23) ; UC1.F40 v1(115.14,65.94) UC1.F38 ; v1(116.05,54.74) 116.06,54.73 UC1.AL38 ; UC1.BA1 UC1.BA2
  BOTTOM w0.254: v1(112.44,93.15) 112.8,92.79 JEDP1.8 ; 104.3,93.31 104.3,93.31 JEDP1.25 ; UC1.N68 98.79,62.52 v1(99.11,62.2) ; UC1.G52 108.18,65.69 v1(107.88,66) ; v1(135.34,48.85) 135.46,48.74 135.6,48.74 135.96,48.37 UC1.AY3 UC1.BA2 ; UC1.F27 121.91,66.44 121.18,66.44 UC1.F28 120.96,66.34 v1(120.65,66.03) ; v1(97.81,57.66) UC1.AE69 98.19,57.12 98.74,57.12 UC1.AE68 ; UC1.AT42 v1(113.32,51.14) UC1.AR42 ; UC1.AK27 121.78,54.62 v1(121.55,54.62) UC1.AL28 ; UC1.BA71 96.33,47.55 v1(96.08,47.3) 96.3,47.09 UC1.BB70 ; UC1.F2 136.16,66.87 v1(135.99,66.7) 135.68,66.7 UC1.F4 ; 127.71,56.31 UC1.AF17 ; 127.71,56.31 128.04,55.99 UC1.AG17 ; 127.71,56.31 UC1.AG18 127.29,55.89 127.25,55.86 126.87,55.86 126.83,55.89 UC1.AG19 126.64,55.89 126.6,55.86 126.22,55.86 126.18,55.89 UC1.AG20 126.09,55.79 v1(125.76,55.47) ; JAPS1.8 v1(318.65,65.75) ; UC1.AU38 v1(115.14,49.87) ; v1(133.07,54.88) 133.07,54.76 UC1.AK8 133.44,53.91 UC1.AM8 ; UC1.AP20 126.53,52.15 v1(126.12,52.56) 126.16,52.56 126.44,52.8 UC1.AN20 ; 115.07,80.92 115.07,77.23 v1(115.32,76.98) 116.17,76.13 116.17,73.74 115.71,73.28 v1(115.71,72.43) 115.71,71.4 115.38,71.07 115.38,70.59 ; 115.07,80.92 114.81,81.17 114.81,84.32 115.07,84.57 v1(118.14,84.57) 118.86,84.57 119.13,84.31 119.13,81.11 118.94,80.92 ; 115.07,80.92 v1(115.69,80.92) ; v1(318.8,67.91) 318.64,67.75 JAPS1.12 ; v1(109.66,51.14) UC1.AR48 ; CN9.2 278.1,36.41 278.4,36.1 JSATA1.14 ; UC1.R6 134.74,61.61 v1(134.95,61.25) ; 119.72,48.85 119.63,48.76 UC1.BA32 ; 119.72,48.85 v1(119.72,48.86) ; 119.72,48.85 119.63,48.94 UC1.AW32 ; UC1.BB6 UC1.BA6 v1(134.32,48.85) 134.28,48.9 UC1.AW6 ; UC1.D58 104.9,67.74 v1(104.9,68.23) 104.9,68.72 UC1.B58 ; UC1.F35 117.43,66.4 117.19,66.64 116.82,66.64 UC1.F37 ; UC1.K63 v1(101.69,64.05) UC1.K64 UC1.K65 v1(100.39,64.05) UC1.K66 99.8,64.18 v1(99.8,63.99) 99.8,63.98 UC1.K67 UC1.K68 98.3,64.35 ; UC1.G58 v1(104.17,65.94) 103.92,65.69 UC1.G60 ; v1(133.72,58.08) UC1.AB8 ; CV103.2 271.96,55.7 v1(271.96,55.66) ; v1(124.23,65.97) 124.18,65.97 123.83,66.32 UC1.F23 ; v1(124.23,65.97) 124.51,65.69 UC1.G22 ; v1(124.23,65.97) 124.23,65.98 124.4,66.15 124.55,66.15 UC1.F22 ; UC1.AJ15 129.34,55.13 129.68,55.47 v1(129.68,55.48) ; UC1.AH13 129.93,55.33 129.79,55.48 v1(129.68,55.48) ; v1(126.12,51.22) 126.19,51.22 126.55,51.5 UC1.AR20 ; UC1.B30 119.84,68.65 v1(119.84,68.23) 119.84,67.82 UC1.D30 ; UC1.AT4 135.82,50.96 v1(136,50.78) 136.18,50.96 UC1.AT2 ; UC1.AN42 113.34,52.43 v1(113.32,52.41) ; UC1.AF4 135.78,56.52 136.23,56.52 UC1.AF2 UC1.AF1 137.24,56.36 137.77,56.36 137.78,56.35 138.16,56.35 138.17,56.36 138.36,56.36 v1(138.52,56.52) ; UC1.B18 127.1,68.66 v1(127.1,68.23) 127.1,67.8 UC1.D18 ; UC1.T17 127.89,60.78 127.54,60.78 UC1.T18 v1(127.08,61.34) UC1.P19 ; UC1.B14 v1(129.66,68.23) UC1.D14 ; v1(127.03,65.31) UC1.H18 UC1.K18 ; UC1.AW23 v1(124.62,48.85) UC1.BA23 ; v1(130.59,59.06) 130.5,59.06 130.17,59.48 UC1.W13 ; UC1.D48 v1(109.84,68.23) UC1.B48 ; UC1.W6 134.75,59.6 134.79,59.54 135.01,59.16 ; 135.01,59.16 v1(135.01,59.08) ; 135.01,59.16 135.01,59.16 135.26,58.91 UC1.AA4 UC1.AA2 ; JSATA1.7 274.9,35.87 274.67,36.1 v1(274.67,36.14) ; 122.27,67.76 UC1.D25 ; 122.27,67.76 UC1.D26 ; 122.27,67.76 122.34,67.84 122.34,68.26 ; UC1.AG21 125.44,55.79 v1(125.76,55.47) ; UC1.AH67 v1(99.17,54.9) ; 122.34,68.26 122.74,68.26 UC1.C25 ; 122.34,68.26 v1(122.34,68.26) ; UC1.BA14 v1(129.48,48.77) UC1.AW14 ; UC1.AE68 UC1.AE67 v1(99.78,57.62) UC1.AE66 UC1.AE65 101.18,57.61 v1(101.18,57.64) UC1.AE64 UC1.AF63 ; UC1.AE68 v1(98.46,57.6) ; UC1.AG17 127.39,55.24 UC1.AJ18 127.38,55.06 127.2,54.87 127.2,54.41 UC1.AK18 127.34,54.21 v1(127.02,53.73) ; UC1.AG17 128.04,55.81 v1(128.38,55.48) UC1.AG16 UC1.AF15 129.61,56.46 129.61,56.19 129.75,56.05 129.75,55.55 v1(129.68,55.48) ; v1(123.37,52.41) UC1.AN23 ; UC1.AW18 v1(127.06,48.67) UC1.BA18 ; v1(101.69,54.88) UC1.AH64 ; v1(101.69,54.88) UC1.AK63 UC1.AM61 v1(102.34,53.06) ; v1(101.69,54.88) UC1.AH63 ; UC1.AR55 106.46,51.43 106.06,51.11 v1(105.99,51.12) ; v1(116.95,66) 116.97,65.98 UC1.J35 ; v1(177.72,11.65) 177.78,11.7 JDIMM2.223 ; UC1.B10 UC1.D10 UC1.D11 130.72,67.24 v1(130.71,67.21) 130.72,67.2 UC1.E11 ; v1(99.6,53.04) UC1.AL66 ; UC1.E53 107.36,67 UC1.D53 v1(107.36,68.23) UC1.B53 ; UC1.A5 135.78,70.3 v1(136.02,70.3) ; UC1.AB15 v1(129.03,58.83) UC1.AB16 ; UC1.U63 v1(101.71,60.37) UC1.U64 ; CZ129.2 279.37,40.2 278.9,40.67 v1(278.9,41.48) ; UC1.E6 133.89,66.96 133.51,66.58 v1(133.46,66.58) ; UC1.AW10 v1(131.9,48.85) UC1.BA10 ; 126.6,49.39 126.57,49.42 UC1.AU20 126.47,50.2 v1(126.15,50.53) 126.47,50.85 UC1.AT20 ; UC1.D39 114.97,67.9 v1(114.97,68.21) 114.97,68.56 UC1.B39 ; v1(117.89,52.41) UC1.AN33 ; JEDP1.4 v1(114.8,94.12) ; CN8.2 280.4,35.86 JSATA1.18 ; UC1.AA68 v1(99.11,58.54) ; UC1.BA57 v1(104.91,48.85) UC1.AW57 ; UC1.G6 133.5,65.91 133.49,65.94 133.46,65.96 v1(133.46,65.96) ; UC1.V17 127.82,60.3 127.6,60.3 UC1.V18 127.39,59.99 v1(127.06,59.67) 127.06,59.51 126.8,59.25 UC1.Y19 ; UC1.L8 v1(133.72,63.28) ; UC1.G43 112.57,65.98 v1(112.42,65.98) 112.24,65.98 UC1.G45 111.76,65.69 v1(111.5,65.95) ; v1(281.49,42.36) 281.36,42.23 UZ23.5 ; UC1.U70 v1(97.81,60.37) UC1.U69 ; 7.93,94.43 JUSBC1.A1 ; UC1.U10 132.13,60.39 132.32,60.13 132.32,60.1 132.78,59.64 UC1.W9 132.78,59.47 v1(132.45,59.14) ; v1(127.03,67.21) UC1.E18 ; v1(96.11,48.2) UC1.AY71 ; v1(132.53,64.72) 132.98,64.44 UC1.J8 ; v1(112.2,48.85) UC1.BA45 ; JEDP1.24 104.8,93.24 104.75,93.29 ; v1(105.09,50.5) UC1.AT56 ; v1(132.55,66.64) 132.95,66.43 UC1.F8 ; UC1.BA62 v1(102.43,48.85) UC1.AW62 ; UC1.P21 UC1.T21 125.44,60.84 v1(125.74,60.53) ; JAPS1.10 v1(316.74,66.75) ; UC1.AF10 131.82,56.72 v1(131.82,57.01) ; v1(101.33,65.94) UC1.G63 ; UC1.AD13 130.55,57.01 130.61,56.94 v1(130.61,56.97) ; UC1.Y20 UC1.Y21 125.31,59.25 125.04,58.98 v1(125.04,58.89) 125.44,58.49 UC1.AB21 UC1.AD21 ; v1(109.79,48.72) UC1.BA49 ; JNGFF3.21 302.95,35.02 302.65,35.32 v1(301.57,35.32) 301.45,35.21 JNGFF3.27 ; UC1.AM13 130.75,53.97 131.06,53.97 UC1.AK11 131.63,54.25 v1(131.63,53.05) ; UC1.N10 131.82,63.12 v1(131.82,63.28) UC1.L11 ; UC1.A67 99.17,69.8 99.17,70 98.96,70.2 v1(98.96,70.31) ; UC1.N6 134.25,62.32 v1(134.24,62.32) ; UC1.AK22 124.78,54.36 125.11,54.36 125.25,54.22 UC1.AK21 125.76,54.54 125.76,54.64 125.87,54.75 126.09,54.96 UC1.AJ20 126.09,55.14 v1(125.76,55.47) ; v1(102.34,67.21) 102.4,67.27 UC1.D62 UC1.B62 ; UC1.AL2 136.29,53.8 v1(135.98,53.8) 135.71,53.8 UC1.AL4 ; UC1.T4 135.82,61.56 v1(136.01,61.37) 136.2,61.56 UC1.T2 ; 116.34,70.39 116.27,70.46 116.27,70.8 v1(117.52,72.05) 117.92,72.45 v1(117.92,74.36) 117.92,76.98 v1(118.31,77.36) 119.13,78.19 119.13,80.73 118.94,80.92 ; v1(105.09,67.21) UC1.E56 ; UC1.Y17 128.26,59.54 128.4,59.71 UC1.V16 128.77,60.09 129.07,60.46 v1(129.07,60.49) 129.07,60.6 129.34,60.87 UC1.T15 ; UC1.N13 130.18,62.78 129.78,62.37 v1(129.78,62.34) 129.78,62.02 130.07,61.73 UC1.R13 ; UC1.AT28 v1(120.63,51.14) UC1.AR28 ; v1(134.35,65.94) UC1.G5 ; UC1.AR35 v1(116.97,51.14) UC1.AT35 ; UC1.H15 129.07,65.04 v1(128.82,65.29) ; v1(133.72,57.01) UC1.AD8 ; v1(106,65.94) UC1.G55 ; v1(128.92,49.84) 128.92,49.81 128.94,49.93 UC1.AU15 ; UC1.N65 100.74,62.52 v1(101.06,62.2) ; UC1.AR50 v1(108.74,51.14) UC1.AR52 v1(107.83,51.14) ; v1(96.2,67.43) 96.33,67.3 UC1.E71 ; UC1.AL48 110.57,53.91 UC1.AM46 v1(110.57,53.06) ; v1(299.6,35.32) 299.79,35.13 299.79,34.88 299.95,34.72 JNGFF3.33 299.95,33.1 299.7,32.85 298.65,32.85 298.45,33.04 JNGFF3.39 ; UC1.E46 110.82,66.99 v1(110.57,67.24) ; v1(117.89,54.71) UC1.AL35 ; v1(129.03,63.86) UC1.K16 ; UC1.AR8 133.17,51.7 v1(133.45,51.7) ; UC1.E50 v1(108.74,67.22) ; UC1.AT23 v1(123.37,51.14) UC1.AR23 ; v1(118.8,52.41) UC1.AN32 ; UC1.F32 119.05,66.34 v1(118.71,66) 118.68,66 UC1.F33 ; UC1.AD20 126.29,57.36 126.53,57.36 UC1.AD19 ; JNGFF2.5 287.8,42.58 v1(287.37,43.01) 287.3,42.94 JNGFF2.3 ; UC1.J13 v1(130.69,64.67) UC1.J11 ; v1(98.06,67.37) 98.06,67.37 UC1.D69 UC1.F68 ; JEDP1.15 v1(109.3,93.55) ; UC1.F42 114.05,66.62 v1(114.21,66.62) ; v1(128.81,53.69) 128.81,53.74 128.66,54.17 UC1.AK16 ; QV7.3 120.5,81.94 v1(120.9,82.34) ; UC1.D22 124.7,68.1 v1(124.57,68.24) 124.7,68.38 UC1.B22 ; v1(131.6,49.87) UC1.AU10 ; UC1.L20 126.09,63.38 125.64,62.94 125.64,62.81 UC1.N21 125.11,62.92 v1(125.11,63.02) ; CZ130.2 281.31,38.56 281.81,38.06 v1(281.88,38.06) ; JSATA1.4 v1(273.4,35.69) ; v1(121.55,53.06) UC1.AM27 ; 102.8,93.29 102.8,93.29 JEDP1.28 ; CZ101.2 123.75,84.65 v1(123.96,84.85) ; UC1.U66 v1(99.76,60.37) UC1.U67 ; v1(125.2,53.04) 125.27,53.04 125.66,53.39 UC1.AM21 ; v1(109.64,65.94) 110.1,65.69 UC1.G48 ; v1(115.14,65.94) UC1.J38 ; UC1.AR15 129.19,51.5 v1(128.86,51.24) 128.77,51.24 128.5,51.5 UC1.AR16 ; v1(106.91,51.14) UC1.AR53 ; v1(114.23,52.41) UC1.AN40 ; JNGFF3.57 293.95,34.47 293.65,34.78 v1(292.68,34.78) ; JAPS1.14 v1(318.5,68.75) ; v1(104.17,51.77) UC1.AP58 ; UC1.A70 UC1.B71 96.82,69.27 96.3,69.27 v1(96.26,69.31) ; v1(46.43,53.41) 46.3,53.28 46.3,50.81 46.19,50.7 PU200.4 ; UC1.AW53 v1(107.39,48.85) UC1.BA53 ; UC1.AN58 v1(104.17,52.41) ; UC1.AN37 v1(116.06,52.41) UC1.AN38 ; UC1.L16 v1(128.36,63.02) UC1.L17 ; UC1.D66 v1(99.92,68.23) UC1.B66 ; v1(115.14,51.77) UC1.AP38 ; v1(124.3,64.46) 124.6,64.76 UC1.K22 ; UC1.AR58 v1(104.17,51.14) UC1.AT58 ; 118.94,80.92 v1(118.38,80.92) ; UC1.AR46 v1(111.49,51.14) UC1.AR45 ; v1(111.49,53.06) UC1.AM45 112.4,53.91 UC1.AL45 112.86,53.47 UC1.AM43 ; v1(113.32,64.51) UC1.J42 ; UC1.P20 v1(126.41,62.2) UC1.N19 v1(127.07,63.02) UC1.L18 ; UC1.AP68 v1(98.5,52.07) UC1.AP70 ; JDEG1.10 276.35,73.4 v1(276.74,73.01) ; v1(101.43,52.41) 101.61,52.56 101.63,52.56 101.77,52.71 UC1.AN63 ; UC1.AB18 127.72,57.99 128.27,57.99 UC1.AD16 v1(128.38,57.15) ; UC1.L4 135.67,64.05 v1(136,64.05) 136.33,64.05 UC1.L2 ; UC1.B44 v1(112.31,68.23) UC1.D44 ; UC1.AT63 v1(101.43,51.14) UC1.AR63 ; v1(296.25,32.64) 296.46,32.64 296.95,33.13 JNGFF3.45 ; UC1.AR43 v1(113.32,51.77) UC1.AP42 ; UC1.BA28 v1(122.14,48.85) UC1.AW28 ; v1(101.43,51.77) UC1.AP63 ; v1(116.97,52.41) UC1.AN35 ; v1(125.2,67.22) UC1.E21 ; JEDP1.39 97.3,93.38 97.29,93.39 ; UC1.AP18 127.47,52.13 127.47,52.13 v1(127.04,51.78) ; JEDP1.27 103.3,93.31 103.31,93.31 ; UC1.AN28 v1(120.63,52.41) UC1.AN30 ; v1(119.72,54.62) UC1.AL32 ; v1(98.64,49.5) UC1.AV69 UC1.AV70 UC1.AV71 96.29,49.5 v1(96.11,49.32) ; v1(116.97,51.77) UC1.AP35 ; UC1.AU32 v1(118.8,49.85) ; UC1.AL64 v1(101.43,53.04) ; JNGFF3.51 295.45,33.16 295.04,32.74 295.04,32.38 v1(295.26,32.16) ; JSATA1.12 277.4,35.62 277.27,35.75 v1(277.27,35.83) ; UC1.AJ4 135.37,54.44 v1(135.01,54.88) UC1.AH6 ; v1(123.37,51.77) UC1.AP23 ; UC1.AW36 v1(117.16,48.85) UC1.BA36 ; v1(122.46,53.06) UC1.AM25 ; v1(99.29,65.94) UC1.G66 ; JDIMM1.252 104.03,5.95 v1(104.24,6.16) ; 105.31,93.29 105.3,93.27 JEDP1.23 ; v1(127.71,62.18) UC1.P17 ; UC1.AP10 132.01,52.16 v1(131.6,51.83) 131.28,51.5 UC1.AR11 ; v1(100.31,67.25) UC1.E65 ; UC1.AW41 v1(114.68,48.85) UC1.BA41 ; v1(102.98,57.45) 102.68,57.45 UC1.AD62 ; UC1.E15 129.75,66.6 v1(129.78,66.6) 129.97,66.6 UC1.F13 ; v1(120.63,51.77) UC1.AP28 ; UC1.AR5 134.8,51.42 134.43,51.13 v1(134.35,51.14) ; UC1.AA65 v1(101.06,58.54) ; JEDP1.6 v1(113.8,93.22) ; v1(118.8,51.77) UC1.AP32
  BOTTOM w0.305: JNGFF1.23 199.78,19.25 v1(199.33,19.7) ; v1(305.92,32.62) 305.95,32.65 JNGFF3.9 ; v1(289.98,40.42) 289.3,41.1 JNGFF2.11 ; v1(11.87,90.21) 11.4,90.68 DT13.2 ; v1(198.54,7.88) 198.66,7.75 JNGFF1.69 ; JNGFF1.51 v1(199.76,12.25) ; JNGFF1.77 202.4,5.5 202.4,6.03 202.18,6.25 201.28,6.25 JNGFF1.75 ; JNGFF2.57 300.8,42.88 v1(301.17,43.25) ; DT14.2 11.05,92.69 10.86,92.5 v1(10.86,92.41) ; v1(298.96,43.33) 299.3,42.99 JNGFF2.51 ; PU1201.4 68.87,108.41 v1(68.91,108.37) ; v1(207.72,17.7) 207.92,17.5 JNGFF1.30 ; UE6.3 268.09,73.21 268.74,73.86 v1(268.74,74.92) ; JNGFF1.1 200.08,24.75 v1(200.08,24.75) ; DT18.2 v1(11.83,99.08) ; JNGFF3.15 304.45,32.76 v1(304.55,32.66) ; v1(266.01,66.25) 267.34,66.25 267.53,66.44 268.99,66.44 269.09,66.34 JESPI.9 ; JNGFF1.29 201.28,17.75 202.27,17.75 202.48,17.97 202.48,19.41 v1(202.38,19.51) ; JUSBC1.A1 v1(8.96,94.42) ; JNGFF1.39 v1(202.63,15.25) ; JNGFF1.18 207.94,20.5 v1(207.7,20.26) ; JNGFF1.7 201.94,23.25 202.59,22.6 v1(202.59,22.53) ; v1(11.13,101.34) 11.14,101.33 DT17.2 ; JNGFF1.45 199.91,13.75 v1(199.83,13.84) ; DT6.2 v1(11.31,95.47) ; JNGFF1.36 v1(207.69,16) ; v1(293.03,42.94) 293.3,42.67 JNGFF2.27 ; v1(277.55,36.72) CN9.2 ; JNGFF1.63 200.11,9.25 v1(199.96,9.4) ; v1(296.73,43.05) 296.3,42.62 JNGFF2.39 296.3,41.04 296.02,40.76 295.1,40.76 294.8,41.06 JNGFF2.33 ; v1(10.93,93.87) 11.03,93.77 DT5.2 ; JNGFF1.24 v1(207.67,19) ; JNGFF1.33 199.94,16.75 v1(199.84,16.64) ; JNGFF2.45 297.8,41.88 v1(297.8,43.13) ; JNGFF1.57 v1(200,10.75)
  BOTTOM w0.356: CC127.2 CC126.2 151.62,57.88 v1(152.03,57.47) ; UZ35.3 135.47,84.09 134.21,84.09 133.91,83.8 CZ1005.2 CZ1004.2 133.33,83.57 v1(132.99,83.91)
  BOTTOM w0.381: v1(11.61,97.4) 11.77,97.4 11.92,97.55 DT39.3 ; v1(136.49,87.58) 137.2,86.86 CZ1000.2 CZ1001.2 ; PC601.2 65.47,44.83 65.47,45.23 v1(65.6,45.36) ; PR658.1 68.65,56.66 68.33,56.98 PC641.2 v1(67.77,57.66) ; RN73.2 288.76,55.71 v1(289.02,55.96) ; v1(274.67,36.14) 274.5,36.31 CN11.2 CN10.2 ; UZ19.5 129.86,84.13 v1(129.42,84.56) ; v1(288.41,62.97) 288.66,63.21 CZ133.2 ; v1(17.33,15.84) 16.82,15.33 PR932.2 ; PR103.2 v1(173.17,118.83) ; CZ106.2 v1(145.14,87.19) ; v1(271.4,72.79) 271.4,72.54 272.41,71.53 JESPI.11 ; v1(289.02,54.84) 288.68,54.5 CN30.2 ; RT81.2 35.45,84.79 v1(35.45,83.71) ; UZ21.5 125.06,81.78 v1(124.84,82) ; JDEG1.12 278.63,72.02 v1(278.39,71.77) ; v1(32.3,79.06) 32.3,79.62 RT71.2 32.17,80.63 RT101.2 31.93,80.64 31.45,81.12 v1(31.16,81.12) 30.97,81.31 RT377.2 ; CC10.2 149.64,58.57 149.26,58.95 v1(149.26,59.58) 148.8,59.58 148.32,60.06 CC318.2 ; v1(273.68,65.01) 273.36,65.01 273.18,64.84 JESPI.12 272.04,64.47 RN15.1 ; PC619.1 70.44,54.96 v1(69.98,54.5) ; CV18.2 121.07,87.89 120.66,88.31 CZ2.2 v1(120.4,87.68) ; CT87.2 30.66,78.62 31.16,79.11 v1(31.16,79.37) ; CC312.2 v1(100.72,80.6) ; 171.39,116.99 v1(171.39,116.29) ; v1(41.91,97.85) 41.36,97.3 CT88.2 ; UC12.3 150.23,89.6 v1(150.75,89.07) ; PC636.1 65.02,47.19 PC629.1 v1(65.02,45.67) ; CC26.2 151.49,43.68 v1(152.15,44.34) ; UC7.3 v1(158.83,51.47) ; v1(277.27,45.87) 276.83,46.31 CZ119.2 276.41,47.05 CZ124.2 ; RZ165.2 RZ357.2 287.91,68.51 287.34,69.08 287.34,69.54 287.71,69.92 288.13,69.92 288.13,69.92 288.3,69.92 v1(288.65,70.27) ; CV23.2 CV22.2 112.73,88.56 CZ1.2 112.44,88.96 v1(113.04,89.55) ; PR116.2 172.47,116.93 v1(172.22,117.19) ; CZ111.2 276.03,53.41 v1(276.57,53.95) ; v1(151.38,66.61) 151.62,66.36 CC9.2 ; CE66.2 305.71,74.43 v1(306.02,74.11) ; PU1.3 v1(64.22,94.79) ; v1(289.02,57.08) 288.27,57.83 RN74.2 ; v1(70.08,58.5) 70.08,58.27 70.44,57.92 PC618.1
  BOTTOM w0.457: v1(293.35,67.98) 292.88,68.46 RZ359.2 ; RT82.2 31.81,86.05 32.14,86.38 v1(32.45,86.38) ; CC21.2 v1(115.69,80.92) ; v1(99.83,104.03) 99.7,103.9 RV73.2 ; PR310.2 v1(185.68,95.84) ; v1(75.89,47.14) 75.11,47.92 PC604.2 ; RZ167.2 293.67,64.66 v1(293.93,64.39) ; PR209.2 41.15,52.34 v1(41.6,52.79) 42.04,52.34 PC221.2 ; v1(19.56,16.96) 19.69,16.83 PC932.1 ; RC4.2 150.7,51.96 151.34,52.6 v1(151.34,53.16) ; RN59.2 291.85,52.7 291.63,52.92 v1(291.63,53.13) ; PC1215.2 15.31,90.44 v1(15.63,90.76) ; PR311.2 v1(185.68,94.89) ; PC216.2 v1(48.65,43.39) ; v1(146.21,76.75) 145.95,76.5 CC335.2 ; RN61.2 RZ159.2 294.72,61.8 v1(294.84,61.68) ; JSD1.22 v1(31.88,34.15) ; PR206.2 v1(44.39,43.9) 44.5,43.79 PC217.2 ; v1(162.06,118.45) 161.69,118.81 PC138.2 ; CC22.2 v1(118.38,80.92) ; CV11.1 109.91,85.22 CV15.2 110.31,85.15 110.54,85.38 v1(110.83,85.38) ; PC652.2 68.85,42.92 PC649.2 70.08,42.92 70.43,43.26 v1(70.43,43.71) ; PR302.2 v1(185.68,98.57)
  BOTTOM w0.508: v1(56.18,82.08) JRTC1.3 58.35,83.38 v1(58.58,83.61) ; v1(29.79,83.51) 29.57,83.29 CT83.2 ; v1(312.92,84.87) 313.09,85.04 DV5.1 ; CZ200.2 113.59,85.87 v1(113.01,85.87) ; v1(280.29,50.69) 280.29,50.31 279.91,49.92 CZ109.2 CZ110.2 ; RV1.2 RV2.2 105.1,90.18 v1(105.39,90.47) ; v1(11.46,17.79) 11.47,17.8 PR945.2 PC955.2 ; JNGFF1.77 202.05,4.17 201.48,3.61 v1(200.51,3.61) ; RZ355.2 284.42,68.46 v1(284.29,68.59) ; PC1067.2 v1(86.87,66.82) ; RC86.2 v1(104.91,76.98) ; PC677.2 62.77,77.87 v1(62.31,77.41) ; v1(169.3,45.48) 169.45,45.33 JSPI1.21 ; v1(281.21,44.93) 281.74,44.93 282.1,45.28 CZ20.2 282.96,45.28 CZ212.2 ; PR207.1 v1(43.5,43.9) ; PH603.1 v1(53.7,57.17) ; v1(23.07,89.32) 23.42,88.97 CT93.2 ; PD4.1 v1(61.5,86.36) ; v1(184.98,91.59) 185.36,91.59 PC312.2 ; PC1205.2 68.24,112.16 PR1217.2 68.24,112.2 68.88,112.85 v1(69.33,112.85) ; v1(155.75,45.79) 155.75,43.88 JSPI1.22 ; PC132.2 v1(172.79,113.75) ; UT6.4 28.71,93.11 29.09,93.5 v1(29.09,94) ; v1(84.02,81.55) v1(82.81,81.55) ; v1(84.02,81.55) 85.45,81.55 87.18,83.28 ; v1(84.02,81.55) PC1075.2 ; v1(82.81,81.55) v1(81.6,81.55) PC1011.2 ; v1(82.81,81.55) PC1001.2 ; PC125.2 v1(161.51,105.36) ; RC113.2 RC110.2 v1(94.59,74.67) ; PC939.2 23.63,16.93 v1(23.6,16.91) ; v1(39.92,99.19) 39.5,99.61 CT90.2 40.55,99.89 UT7.2 ; 278.14,61.5 RN17.1 ; 278.14,61.5 RN11.1 278.11,62.4 RN21.2 ; 278.14,61.5 277.64,61.5 277.14,62 v1(277.14,62.5) ; v1(136.95,105.01) JSIM1.14 v1(135.84,106.24) ; v1(96.73,80.66) 96.78,80.61 CC336.2 ; CT94.2 v1(18.55,82.95) ; JNGFF2.76 285.7,43.92 v1(285.23,44.4) ; CZ18.2 CZ17.2 281.59,48.49 v1(281.2,48.1) ; PC688.2 63.43,83.38 v1(63.33,83.28) ; PR1246.2 v1(73.68,106.63) ; CV18.2 CV19.2 ; DT4.1 v1(11.87,90.21) ; RC556.2 145.7,64.84 v1(145.2,64.34) ; v1(19.16,88.13) 18.8,88.49 PC1216.2 18.8,89.25 18.29,89.76 RT416.2 ; v1(316.17,60.15) JAPS1.19 ; v1(317,91.97) 317.4,91.56 CV126.2 ; 67.49,103.04 66.6,103.04 PC1213.2 66.42,103.01 v1(65.97,102.56) ; 67.49,103.04 PC1212.2 ; 67.49,103.04 PR1247.2 ; RN7.1 RN9.1 271.38,63.14 v1(270.9,63.62) ; v1(287.79,58.95) 287.79,59.24 287.91,59.37 RZ161.2 RZ348.2 RZ163.2 ; v1(109.38,89.67) CV24.2 CV25.2 ; CT89.2 v1(41.48,95.6) ; v1(271.09,42.44) 271.21,42.31 CN1.2 ; CC319.2 144.3,62.76 v1(143.77,62.22) ; JDEG1.11 278.5,78.9 v1(278.01,78.4) ; v1(41.91,97.85) 42.35,97.42 CT92.2 ; v1(117.29,86.55) 117.21,86.55 DV4.1 ; v1(281.34,37.38) 281.26,37.3 CN8.2 ; v1(155.23,49.5) 154.87,49.86 RC65.2 ; PC933.2 11.47,18.69 v1(11.44,18.65) ; RZ40.1 272.14,50.82 v1(270.9,50.82) ; JFAN1.1 266.57,45.61 266.37,45.61 v1(266.35,45.64) ; v1(33.91,47.26) 32.98,46.32 JSD1.21 33.84,46.15 v1(34.37,46.68) ; CC303.2 v1(105.8,76.98) ; PC685.2 v1(70.01,82.95) ; PC139.2 158.88,119.08 v1(158.37,118.57) ; v1(264.52,47.01) 264.91,47.4 266.2,47.4 JFAN1.5 ; v1(320.57,75.44) 319.22,75.44 318.46,76.2 CV134.2 ; CV130.2 v1(315.14,88.41) ; v1(297.63,37.29) 297.69,37.36 CA19.2 CA24.2 ; JRTC1.2 60.4,79.53 60.01,79.14 v1(60.01,78.19) ; v1(278.81,56.19) 278.62,56.38 CV106.2 ; DV6.1 314.3,81.57 v1(314.65,81.92) ; v1(34.09,50.47) 33.65,50.47 33.57,50.4 JSD1.6 ; CA12.2 312.31,35.76 v1(313,35.07) 313.7,35.07 314.08,34.69 314.08,30.94 313.12,29.99 v1(313.12,27.51) ; v1(44.72,52.7) PR212.2 44.71,52.06 PC222.2 ; UI2.2 87.11,100.46 v1(87.19,100.54) ; CV20.2 v1(102.01,85.3) ; v1(79.82,98.19) CI11.2 ; JSIM1.10 v1(121.74,119.21) ; CV16.1 98.76,85.37 v1(98.75,85.36) ; v1(123.61,81.16) 123.5,81.16 CC226.2 ; JSD1.23 25.93,60.15 v1(27.25,60.15) ; RV102.2 v1(273.69,60.74) ; v1(138.88,103.52) PC407.2 v1(140.25,103.52) ; JNGFF1.76 v1(199.47,25.85) ; CV127.2 316.08,91.94 v1(316.11,91.97) ; CA13.1 310.65,41.74 311.28,42.37 311.92,42.37 v1(312.23,42.69) ; CC8.2 151.29,65.02 v1(151.95,65.02) ; JSIM1.15 136.29,111.77 v1(135.93,111.41) ; CZ28.2 207.4,31.97 v1(207.4,32.4) 207.35,32.35 206.01,32.35 CZ32.2 ; JUSB3.7 v1(80.55,107.52) ; v1(122.61,103.22) 122.61,102.73 JSIM1.12 123.47,102.77 v1(123.47,103.24) ; CA5.2 CA6.2 114.69,87.37 v1(114.51,87.19) ; RE86.2 v1(271.84,76.41) ; v1(161.78,55.24) 161.32,54.78 UC6.4 ; CC321.2 v1(100.59,77.23) ; v1(160.09,112.54) 159.96,112.67 PC137.2 ; v1(96.98,82.26) 97.73,83.01 UV24.2 ; QV2.3 100.59,82.64 101.1,83.15 v1(101.1,83.35) ; RZ157.2 285.15,58.8 285.48,58.47 287.11,58.47 287.65,57.93 RN74.2 ; PC119.2 v1(171.92,111.46) ; RT393.2 v1(35.37,100.25) ; CC310.2 95.15,80.82 v1(95.51,81.17) ; v1(311.92,78.38) 312.16,78.38 CV131.2 ; v1(118.7,113.06) CZ37.2 118.69,112.4 CZ39.2 ; v1(299.6,37.29) 300.36,38.05 CA22.2 CA23.2 ; PC9.2 v1(62.55,97.67) ; CV135.2 318.9,73.66 v1(318.9,72.93) ; JSD1.24 v1(25.8,33.04) ; v1(160.72,112.54) 160.85,112.67 PC140.2 ; v1(280.36,59.75) 280.11,59.5 CV104.2 CV105.2 ; v1(32.98,58.88) JSD1.20 v1(32.98,56.47) ; UC5.4 v1(159.39,63.42) ; CC7.2 v1(151.34,53.16) ; v1(277.14,64.15) 276.74,64.15 276.23,63.64 RN13.1 ; PC1081.2 v1(83.25,68.09) ; RC141.2 v1(114.16,78.48) ; RC227.2 151.39,88.14 v1(151.08,87.83) ; CC305.2 v1(102.75,76.98) ; CV129.2 v1(318.34,86.81) ; v1(132.21,101.9) 132.85,101.9 JSIM1.13 132.92,102.68 v1(132.15,102.68) ; RT303.2 19.63,101.05 v1(20.07,101.49) 20.52,101.05 RT248.2 ; CA69.2 301.96,36.39 301.57,36.78 v1(301.57,37.29) ; v1(62.94,98.45) 62.32,98.45 61.7,99.06 PJPDC1.7 62.47,99.65 v1(62.91,99.22) ; v1(15.25,31.51) 14.93,31.82 JSD1.26 ; v1(6.55,30.12) 6.1,30.56 JSD1.13 ; v1(78.34,101.54) 78.52,101.72 DI3.1 ; PH601.1 v1(61.6,74.62) ; PC669.2 v1(53.7,60.62) ; CZ40.2 v1(134.52,100.22) ; v1(145.06,66.69) RC401.2 RC372.2 ; CV14.2 v1(104.53,83.46) ; v1(8.84,30.12) 9.4,30.67 JSD1.10 ; CV17.2 97.5,86.26 v1(98,85.77) ; CT70.2 v1(34.56,100.04) ; PC1207.2 v1(64.52,111.32) ; JSD1.3 v1(31.12,43.3) ; CT122.2 v1(17.85,101.43) ; PC1010.2 v1(85.67,67.39) ; JSD1.25 v1(11.7,61.3) ; v1(117.15,109.39) 117.52,109.76 RZ334.2 ; v1(126.07,90.59) 126.24,90.59 CV635.2 ; JFAN1.6 v1(258.97,41.53) ; v1(315.16,79.33) 315.16,78.11 UV4.2 ; CC301.2 v1(96.65,75.22) ; PC112.2 v1(160.57,106.52) ; PC126.2 v1(171.92,112.67) ; PC116.2 v1(162.74,118.46) ; CC302.2 v1(148.98,87.45) ; CC23.2 v1(148.7,41.39) ; PC1201.1 v1(64.85,106.65) ; PC313.2 v1(184.98,90.7) ; v1(120.35,112.64) JSIM1.11 ; RC554.2 v1(144.99,59.02) ; CC304.2 v1(104.02,77.06) ; JSD1.17 v1(9.4,59.39) ; JSIM1.5 v1(123.74,118.35) ; PC1002.2 v1(84.46,67.84)
  vias: v1(0.56,104.03) v1(0.51,90.11) v1(0.98,57.93) v1(0.98,54.12) v1(0.98,50.31) v1(0.98,46.5) v1(0.98,42.69) v1(0.98,38.88) v1(0.98,35.07) v1(1.4,105.91) v1(1.4,85.79) v1(1.66,21.74) v1(1.66,17.93) v1(1.66,14.12) v1(1.66,6.5) v1(1.78,0.65) v1(1.81,109.38) v1(2.48,8.4) v1(2.6,3) v1(2.93,25.67) v1(3.05,63.77) v1(3,31.31) v1(3,28.87) v1(3,11.6) v1(3.5,10.11) v1(3.59,6.92) v1(3.52,4.61) v1(3.52,1.39) v1(3.64,11.6) v1(4.37,109.39) v1(4.4,106.1) v1(4.4,88) v1(4.58,67.07) v1(4.5,12.85) v1(4.5,12.26) v1(4.65,81.76) v1(5.14,25.74) v1(5.14,25.1) v1(5.14,24.02) v1(5.14,23.39) v1(5.14,22.37) v1(5.14,21.74) v1(5.32,107.71) v1(5.32,104.49) v1(5.32,89.61) v1(5.32,86.39) v1(5.31,6.92) v1(5.38,4.61) v1(5.38,1.39) v1(5.4,10.11) v1(6.3,3) v1(6.42,8.4) v1(7.07,100.41) v1(7.18,107.71) v1(7.18,104.49) v1(7.18,89.61) v1(7.18,86.39) v1(7.75,100.42) v1(8.1,106.1) v1(8.1,88) v1(8.23,0.52) v1(8.7,102.06) v1(9.31,101.79) v1(9.59,93.93) v1(9.63,99.46) v1(9.85,102.19) v1(10.06,109.39) v1(10.04,103.46) v1(10.17,104.41) v1(10.21,102.79) v1(10.55,103.97) v1(10.68,103.32) v1(10.72,99.64) v1(10.8,3.57) v1(11.21,81.65) v1(11.87,29.38) v1(11.88,28.79) v1(11.88,27.47) v1(11.88,26.16) v1(11.88,24.84) v1(12.07,67.07) v1(12.4,29.81) v1(12.45,0.53) v1(12.77,9.54) v1(12.77,8.4) v1(12.88,29.38) v1(12.89,28.79) v1(12.89,27.47) v1(12.89,26.16) v1(12.81,24.84) v1(13.06,109.37) v1(13.09,8.97) v1(13.15,7.83) v1(13.44,29.81) v1(13.53,9.54) v1(13.53,8.4) v1(13.9,29.38) v1(13.89,28.79) v1(13.89,27.47) v1(13.89,26.16) v1(13.85,8.97) v1(13.91,7.83) v1(14.07,99.59) v1(14.1,79.98) v1(14.1,68.85) v1(14.29,9.54) v1(14.29,8.4) v1(14.61,8.97) v1(14.67,7.83) v1(14.89,107.56) v1(14.99,9.54) v1(14.99,8.4) v1(15.31,8.97) v1(15.37,7.83) v1(15.58,0.5) v1(15.63,9.54) v1(15.63,8.4) v1(15.88,97.74) v1(15.94,8.97) v1(16.01,7.83) v1(16.69,105.71) v1(17.33,18.08) v1(17.33,16.96) v1(18.29,74.92) v1(18.29,74.31) v1(18.29,73.68) v1(18.45,18.08) v1(18.45,16.96) v1(18.45,15.84) v1(18.7,103.75) v1(18.67,0.53) v1(19.56,18.08) v1(19.56,15.84) v1(20.51,75.17) v1(20.51,74.56) v1(21.24,102.56) v1(21.21,95.47) v1(21.21,94.05) v1(22.18,44.65) v1(22.33,95.47) v1(22.48,0.53) v1(22.99,48.3) v1(23.14,46.89) v1(23.32,44.62) v1(23.56,72.79) v1(24.29,44.65) v1(24.67,51.17) v1(24.67,48.94) v1(24.95,101.44) v1(25.05,102.56) v1(25.79,50.06) v1(26.29,0.53) v1(26.9,51.17) v1(26.9,48.94) v1(27.12,89.32) v1(27.17,13.92) v1(27.17,13.29) v1(27.84,96.72) v1(27.86,95.42) v1(28,90.73) v1(28.15,98.1) v1(28.17,97.43) v1(28.76,55.75) v1(28.76,55.16) v1(28.73,50.97) v1(28.74,20.18) v1(28.74,19.17) v1(28.74,18.17) v1(28.86,102.56) v1(30.06,20.18) v1(30.06,19.17) v1(30.06,18.17) v1(30.1,0.53) v1(30.37,70.98) v1(30.68,42.5) v1(31.3,69.61) v1(31.37,20.18) v1(31.37,19.17) v1(31.37,18.17) v1(32.67,102.56) v1(32.68,19.1) v1(32.68,18.17) v1(32.89,79.06) v1(33.47,82.01) v1(33.91,0.53) v1(34.05,48.58) v1(34.03,9.1) v1(34.03,8.46) v1(34.03,7.8) v1(34,6.72) v1(34,6.09) v1(34.61,9.1) v1(34.61,8.46) v1(34.61,7.8) v1(34.64,6.72) v1(34.64,6.09) v1(35.64,80.18) v1(35.64,79.6) v1(35.89,52.67) v1(35.82,50.64) v1(36.23,80.08) v1(36.48,102.56) v1(36.53,79.57) v1(37.72,0.53) v1(38.85,24.34) v1(39.28,11.75) v1(39.73,102.58) v1(40.28,11.75) v1(40.52,6.03) v1(41.25,49.45) v1(41.37,11.62) v1(41.37,10.35) v1(41.5,7.3) v1(41.6,20.9) v1(41.52,6.03) v1(41.53,0.53) v1(41.66,50.12) v1(41.89,89.49) v1(41.86,49.45) v1(42.08,48.53) v1(42.28,50.12) v1(42.58,102.58) v1(42.54,89.48) v1(42.52,3.5) v1(42.68,48.52) v1(42.92,50.09) v1(43.27,48.52) v1(43.44,89.49) v1(43.4,11.37) v1(43.4,9.46) v1(43.53,50.1) v1(43.53,14.42) v1(43.52,6.22) v1(43.86,48.53) v1(44.07,89.49) v1(44.15,104.49) v1(44.15,50.08) v1(44.52,6.14) v1(44.8,48.72) v1(44.91,101.36) v1(45.26,89.47) v1(45.34,0.53) v1(45.45,106.09) v1(45.56,14.24) v1(45.56,11.24) v1(45.56,9.97) v1(45.56,7.43) v1(45.52,6.12) v1(45.69,48.72) v1(45.99,101.36) v1(45.98,89.49) v1(46.02,100.26) v1(46.65,14.26) v1(46.89,107.92) v1(46.83,8.32) v1(46.83,6.41) v1(47.35,101.32) v1(47.44,53.35) v1(47.85,10.48) v1(47.92,44.09) v1(48.07,73.42) v1(48.07,72.73) v1(48.07,72.03) v1(48.03,6.03) v1(48.39,53.38) v1(48.58,54.63) v1(48.66,44.13) v1(48.72,109.39) v1(49.03,6.06) v1(49.15,0.53) v1(49.47,54.63) v1(49.79,14.9) v1(49.78,14.27) v1(50.09,6.24) v1(50.36,54.63) v1(50.55,88.98) v1(50.55,87.58) v1(50.81,88.41) v1(51.19,88.98) v1(51.12,87.9) v1(51.12,87.31) v1(51.14,6.32) v1(51.31,54.63) v1(51.41,88.41) v1(51.49,10.1) v1(52.01,88.41) v1(52.04,10.99) v1(52.02,6.08) v1(52.53,109.39) v1(52.62,88.41) v1(52.65,73.3) v1(52.65,72.6) v1(52.65,71.9) v1(52.96,0.53) v1(53.03,6.03) v1(53.22,32.54) v1(53.57,14.49) v1(53.62,10.86) v1(53.87,84.97) v1(54.28,70.05) v1(54.28,69.46) v1(54.28,68.88) v1(54.28,68.29) v1(54.95,86.78) v1(54.95,86.15) v1(55.03,6.03) v1(55.59,86.78) v1(55.59,86.15) v1(56.1,11.24) v1(56.1,9.97) v1(56.1,6.03) v1(56.34,109.39) v1(56.77,0.53) v1(57.25,6.16) v1(57.56,44.4) v1(57.56,43.81) v1(57.56,43.2) v1(57.56,42.59) v1(57.56,41.99) v1(58.48,60.26) v1(58.52,6.32) v1(58.61,69.73) v1(59.59,74.31) v1(59.52,6.32) v1(59.63,63.23) v1(59.63,61.93) v1(59.63,60.64) v1(59.76,72.7) v1(59.76,71.41) v1(59.76,70.11) v1(60.08,73.96) v1(60.33,75.15) v1(60.33,74.57) v1(60.36,67.58) v1(60.36,67) v1(60.36,66.41) v1(60.36,65.83) v1(60.36,65.22) v1(60.48,63.88) v1(60.52,6.14) v1(60.58,0.53) v1(60.69,73.96) v1(60.61,73.35) v1(60.76,10.35) v1(60.84,59.79) v1(60.91,75.15) v1(60.91,74.57) v1(60.97,69.26) v1(60.94,67.58) v1(60.94,67) v1(60.94,66.41) v1(60.94,65.83) v1(60.94,65.22) v1(61.12,109.39) v1(61.19,63.23) v1(61.19,61.93) v1(61.19,60.64) v1(61.18,11.62) v1(61.27,73.96) v1(61.32,72.7) v1(61.32,71.41) v1(61.32,70.11) v1(61.55,66.79) v1(61.55,66.21) v1(61.55,65.63) v1(61.55,65.02) v1(61.52,6.07) v1(62.27,11.55) v1(62.57,111.45) v1(63.05,66.72) v1(63.05,66.13) v1(63.05,65.55) v1(63.52,6.09) v1(64.01,119.4) v1(64.01,113.73) v1(64.01,11.58) v1(64.39,0.53) v1(64.52,6.16) v1(65.58,116.9) v1(65.83,76.26) v1(66.47,118.43) v1(66.47,115.37) v1(66.73,82.54) v1(66.73,81.96) v1(66.73,81.35) v1(66.73,80.76) v1(66.77,11.62) v1(66.77,10.35) v1(66.97,79.23) v1(66.97,77.94) v1(66.97,76.64) v1(67.24,51.71) v1(67.24,50.18) v1(67.24,48.66) v1(67.83,79.88) v1(68.13,82.44) v1(68.13,81.86) v1(68.13,81.27) v1(68.13,80.69) v1(68.19,75.79) v1(68.23,118.43) v1(68.23,115.37) v1(68.2,0.53) v1(68.52,86) v1(68.53,79.23) v1(68.53,77.94) v1(68.53,76.64) v1(68.55,7.43) v1(68.71,82.44) v1(68.71,81.86) v1(68.71,81.27) v1(68.71,80.69) v1(68.76,51.71) v1(68.76,50.18) v1(68.76,48.66) v1(69.12,116.9) v1(69.3,81.86) v1(69.3,81.27) v1(69.3,80.69) v1(69.73,86.25) v1(70.29,51.71) v1(70.29,50.18) v1(70.29,48.66) v1(70.87,84.03) v1(71.27,10.38) v1(71.51,84.03) v1(71.84,119.4) v1(72.08,83.9) v1(72.01,0.53) v1(72.23,7.81) v1(72.71,83.9) v1(73.1,114.01) v1(73.22,84.22) v1(73.22,83.58) v1(73.86,84.22) v1(73.86,83.58) v1(74.27,9.67) v1(74.36,93.81) v1(74.49,84.22) v1(74.49,83.58) v1(74.68,94.32) v1(75,93.81) v1(75.04,108.93) v1(75.13,99.59) v1(75.32,94.32) v1(75.46,11.21) v1(75.49,9.12) v1(75.41,7.18) v1(75.63,93.81) v1(75.76,99.59) v1(75.82,0.53) v1(75.95,94.32) v1(75.95,50.37) v1(75.95,49.48) v1(76.7,7.25) v1(77.28,66.95) v1(77.28,66.31) v1(77.28,65.68) v1(77.28,57.61) v1(77.28,56.98) v1(77.28,56.34) v1(77.28,55.71) v1(77.92,66.95) v1(77.92,66.31) v1(77.92,65.68) v1(78.17,57.61) v1(78.17,56.98) v1(78.17,56.34) v1(78.17,55.71) v1(78.92,8.63) v1(79.19,65.11) v1(79.63,0.53) v1(79.82,65.11) v1(80.52,65.11) v1(80.83,94.73) v1(81.16,65.11) v1(82.06,95.27) v1(82.73,10.36) v1(82.85,103.37) v1(82.83,11.58) v1(83.09,97.21) v1(83.06,15) v1(83.14,103.9) v1(83.44,103.37) v1(83.44,0.53) v1(83.7,88.35) v1(84.33,88.35) v1(84.57,11.13) v1(84.55,9.84) v1(84.71,57.23) v1(84.78,17.75) v1(84.97,88.35) v1(84.92,7.3) v1(84.93,6.03) v1(85.43,17.77) v1(85.6,88.35) v1(85.98,108.96) v1(85.95,9.34) v1(86.01,17.77) v1(86.24,88.35) v1(86.43,64.41) v1(86.43,63.77) v1(87.03,6.06) v1(87.25,0.53) v1(87.74,9.97) v1(88.02,113.56) v1(88.01,11.23) v1(88.07,8.81) v1(88.24,83.23) v1(88.27,14.25) v1(88.55,119.35) v1(88.65,64.47) v1(88.65,63.84) v1(89.24,103.88) v1(89.87,103.88) v1(90.02,54.99) v1(90.07,49.76) v1(90.02,6.15) v1(90.12,10.22) v1(90.12,7.56) v1(90.47,51.63) v1(90.51,103.88) v1(91.05,53) v1(91.04,8.55) v1(91.06,0.53) v1(91.14,103.88) v1(91.25,81.79) v1(91.5,119.4) v1(91.42,115.84) v1(91.53,6.28) v1(91.78,103.88) v1(92.09,51.9) v1(92.17,55.47) v1(92.17,11.24) v1(92.17,9.97) v1(92.27,81.88) v1(92.21,8.55) v1(92.7,90.3) v1(93.04,56.57) v1(93.02,52.96) v1(93.27,92.09) v1(93.23,48.75) v1(93.57,7.43) v1(93.53,6.12) v1(93.63,50.01) v1(93.82,10.35) v1(94.77,119.35) v1(94.77,113.71) v1(94.88,56.56) v1(94.87,0.53) v1(95.35,11.62) v1(95.36,10.35) v1(95.35,7.58) v1(95.35,6.16) v1(95.61,89.43) v1(96.14,42.46) v1(96.63,6.19) v1(96.78,11.7) v1(96.74,9.72) v1(97.16,112.16) v1(97.59,100.6) v1(97.82,41.62) v1(98.48,7.43) v1(98.52,94.19) v1(98.6,6.14) v1(98.68,0.53) v1(98.78,11.62) v1(98.77,10.35) v1(99.39,43.09) v1(99.42,41.11) v1(99.6,108.98) v1(99.85,88.77) v1(100.41,104.03) v1(100.55,7.56) v1(100.67,6.06) v1(100.7,96.73) v1(100.7,95.46) v1(100.7,94.19) v1(100.78,10.99) v1(100.81,9.72) v1(101.22,100.42) v1(101.3,41.33) v1(101.3,39.38) v1(101.66,108.98) v1(101.95,11.37) v1(102.08,6.41) v1(102.11,87.46) v1(102.49,0.53) v1(102.78,11.75) v1(102.89,96.73) v1(102.89,95.46) v1(102.89,94.19) v1(103.32,87.46) v1(103.61,6.8) v1(103.79,100.42) v1(103.87,40.69) v1(104.41,104) v1(104.78,112.16) v1(105.07,94.19) v1(105.54,109.1) v1(106.06,41.73) v1(106.07,39.83) v1(106.39,86.95) v1(106.3,0.53) v1(107.28,41.73) v1(107.32,39.7) v1(107.83,52.42) v1(107.93,99.26) v1(108.04,72.22) v1(108.55,73.79) v1(108.78,79.49) v1(109.29,96.67) v1(109.37,43.58) v1(109.56,98.85) v1(109.62,112.2) v1(109.8,93.24) v1(109.86,72.18) v1(110.16,17.96) v1(110.55,2.1) v1(110.65,18.46) v1(110.63,17.5) v1(111.17,18.04) v1(111.11,17.12) v1(111.35,118.86) v1(111.31,114.01) v1(111.68,17.61) v1(111.61,16.74) v1(111.77,109.64) v1(111.85,4.35) v1(112.1,44.67) v1(112.12,17.14) v1(112.27,109.97) v1(112.27,109.34) v1(112.33,72.16) v1(112.51,74.09) v1(113.39,101.34) v1(113.92,103.35) v1(114.37,72.34) v1(114.41,73.83) v1(114.5,44.6) v1(114.47,42.72) v1(114.45,4.35) v1(114.78,116.9) v1(115.4,101.95) v1(115.67,118.43) v1(115.67,115.37) v1(115.7,97.11) v1(115.75,2.1) v1(116.17,44.67) v1(116.16,42.77) v1(116.86,94.09) v1(117.43,118.43) v1(117.43,115.37) v1(117.82,44.16) v1(117.84,42.24) v1(117.82,39.81) v1(118.17,119.78) v1(118.24,0.53) v1(118.32,116.9) v1(118.7,96.35) v1(119.09,106.29) v1(119.26,57.13) v1(119.33,10.33) v1(119.58,43.29) v1(119.6,41.44) v1(119.71,103.98) v1(119.89,11.55) v1(119.98,63.86) v1(119.98,63.28) v1(120.65,6.46) v1(120.94,103.98) v1(121.09,11.27) v1(121.15,31.26) v1(121.15,30.55) v1(121.28,14.25) v1(121.4,43.44) v1(121.4,41.52) v1(121.65,62.02) v1(121.63,7.06) v1(121.72,59.84) v1(121.95,120.29) v1(122.07,11.65) v1(122.05,0.53) v1(122.16,74.27) v1(122.12,9.58) v1(122.53,6.52) v1(123.06,106.84) v1(123.06,43.74) v1(123.07,41.88) v1(123.07,39.91) v1(123.53,6.54) v1(123.78,11.61) v1(123.91,73.56) v1(123.93,70.55) v1(123.9,10.35) v1(124.17,7.3) v1(124.39,107.43) v1(124.38,106.83) v1(124.49,72.13) v1(124.53,6.15) v1(124.95,43.66) v1(124.96,41.85) v1(124.95,39.9) v1(125.43,6.16) v1(125.78,11.62) v1(125.86,70.35) v1(125.81,10.35) v1(125.86,0.53) v1(126.45,77.62) v1(127.15,84.33) v1(127.51,72.01) v1(127.53,6.1) v1(128.02,85.04) v1(128.3,10.94) v1(128.56,110.03) v1(128.68,110.61) v1(128.68,85.03) v1(129.03,6.12) v1(129.15,104.96) v1(129.11,11.49) v1(129.14,10.2) v1(129.27,110.84) v1(129.57,117.24) v1(129.67,0.53) v1(129.95,105.4) v1(129.93,77.02) v1(130,7.56) v1(130.03,6.26) v1(130.35,112.08) v1(130.51,11.62) v1(130.51,10.35) v1(130.64,105.4) v1(130.79,117.67) v1(130.84,112.59) v1(130.83,111.64) v1(131.03,6.15) v1(131.3,112.08) v1(131.47,117.67) v1(131.53,71.62) v1(131.55,14.29) v1(131.65,7.3) v1(131.92,92.39) v1(132.03,6.15) v1(132.18,117.67) v1(132.72,90.57) v1(132.78,11.51) v1(132.79,9.46) v1(132.95,6.14) v1(133.48,0.53) v1(134.09,6.11) v1(134.17,107.61) v1(134.15,106.86) v1(134.12,92.4) v1(134.32,11.62) v1(134.32,10.35) v1(135.06,87.06) v1(135.13,38.25) v1(136.03,6.09) v1(136.22,11.49) v1(136.22,10.22) v1(136.53,14.2) v1(136.68,119.86) v1(136.99,6.03) v1(137.29,0.53) v1(137.33,7.26) v1(138.06,54.32) v1(138.03,6.03) v1(138.75,120.29) v1(139.08,107.99) v1(139.32,10.86) v1(139.45,115.78) v1(139.51,108.44) v1(139.53,8.07) v1(139.52,6.03) v1(140.18,118.9) v1(140.47,114.95) v1(140.52,6.27) v1(140.75,109.72) v1(141.07,117.37) v1(141.1,114.95) v1(141.1,0.53) v1(141.23,110.23) v1(141.22,109.26) v1(141.28,11.62) v1(141.43,7.3) v1(141.51,53.79) v1(141.7,109.72) v1(142.28,11.58) v1(142.7,6.01) v1(142.83,117.37) v1(143.28,11.55) v1(143.52,6.03) v1(143.72,118.9) v1(143.88,120.21) v1(144.58,6.64) v1(144.52,6.03) v1(144.78,11.58) v1(144.91,0.53) v1(145.36,106.06) v1(145.36,105.43) v1(145.49,11.6) v1(146.39,7.05) v1(146.53,14.18) v1(146.87,67.3) v1(147.35,11.57) v1(147.76,9.31) v1(148.24,8.88) v1(148.72,0.53) v1(148.98,108.98) v1(149.02,6.77) v1(149.16,67.73) v1(149.61,108.98) v1(150.74,11.53) v1(150.7,10.17) v1(151.26,106.83) v1(151.91,106.82) v1(152.33,120.29) v1(152.48,11.65) v1(152.48,10.38) v1(152.5,6.1) v1(152.53,0.53) v1(152.61,7.33) v1(153.02,106.8) v1(153.7,106.8) v1(154,6.19) v1(154.44,117.43) v1(154.5,116.73) v1(154.75,118) v1(154.89,118.6) v1(155.07,117.43) v1(155.08,11.45) v1(155.02,9.41) v1(155.14,116.73) v1(155.39,118) v1(155.48,118.6) v1(155.44,112.16) v1(155.53,7.96) v1(155.55,6.01) v1(155.71,117.43) v1(155.77,116.73) v1(156.06,118.59) v1(156.14,120.29) v1(156.26,116.26) v1(156.26,115.63) v1(156.27,115.04) v1(156.39,116.91) v1(156.34,0.53) v1(156.7,7.23) v1(157.87,66.44) v1(157.87,65.8) v1(157.87,65.17) v1(158.17,7.79) v1(158.11,6.21) v1(158.25,45.99) v1(158.63,45.48) v1(159.95,120.29) v1(160.15,0.53) v1(160.48,7.44) v1(160.6,10.44) v1(162.03,6.01) v1(162.69,2.3) v1(163.1,14.9) v1(163.76,120.29) v1(164.06,6.27) v1(164.82,11.76) v1(164.93,10.48) v1(164.95,6.22) v1(165.05,7.3) v1(165.38,118.59) v1(165.38,118) v1(165.38,117.42) v1(165.49,3.51) v1(165.55,37.42) v1(165.55,35.9) v1(165.94,11.62) v1(165.94,9.72) v1(165.99,6.24) v1(166.45,2.58) v1(166.76,0.53) v1(166.97,118.34) v1(166.94,117.38) v1(167.07,38.94) v1(167.07,37.42) v1(167.07,35.9) v1(167.03,6.24) v1(167.14,14.27) v1(167.33,117.85) v1(167.47,117.07) v1(167.57,120.29) v1(167.58,118.56) v1(167.69,114.62) v1(167.92,118.01) v1(167.95,112.29) v1(167.97,7.3) v1(168,117.33) v1(168.33,118.46) v1(168.46,117.75) v1(168.48,10.1) v1(168.51,112.06) v1(168.6,37.42) v1(168.6,35.9) v1(168.98,33.67) v1(169.27,14.8) v1(169.49,33.04) v1(170.01,7.3) v1(170.26,11.49) v1(170.26,10.22) v1(170.57,0.53) v1(171.03,6.08) v1(171.38,120.29) v1(171.32,15.08) v1(172.29,14.29) v1(172.27,11.75) v1(172.55,8.07) v1(172.53,6.14) v1(172.93,16.55) v1(173.17,37.72) v1(173.39,10.51) v1(173.43,17.38) v1(173.5,16.79) v1(173.53,6.03) v1(173.74,104.98) v1(173.74,104.35) v1(173.74,103.21) v1(173.74,102.51) v1(173.74,101.43) v1(173.74,100.73) v1(174.27,10.28) v1(174.32,11.75) v1(174.38,0.53) v1(174.45,7.3) v1(174.53,6.09) v1(175.19,120.29) v1(175.38,93.55) v1(175.43,14.47) v1(175.59,7.3) v1(175.53,6.03) v1(175.77,30.28) v1(176.23,11.49) v1(176.23,9.59) v1(176.58,7.38) v1(177.75,10.35) v1(178.53,6.32) v1(178.57,0.53) v1(179,120.29) v1(179.53,6.49) v1(179.78,11.63) v1(179.78,10.33) v1(180.53,6.07) v1(180.63,7.3) v1(180.73,97.55) v1(180.73,96.92) v1(181.11,94.38) v1(181.18,91.97) v1(181.36,98.19) v1(181.36,97.55) v1(181.36,96.92) v1(181.68,91.65) v1(181.74,120.29) v1(182,98.19) v1(182,97.55) v1(182,96.92) v1(182.38,0.53) v1(182.63,98.19) v1(182.63,97.55) v1(182.63,96.92) v1(182.88,11.72) v1(182.96,10.44) v1(182.96,7.94) v1(182.96,6.03) v1(184.78,11.64) v1(184.99,7.3) v1(185.03,6.05) v1(185.27,49.9) v1(185.55,83.71) v1(185.55,83.08) v1(185.55,82.44) v1(185.55,81.81) v1(185.55,81.17) v1(185.55,80.54) v1(185.55,23.59) v1(186.19,0.53) v1(187.14,118.06) v1(187.15,114.5) v1(187.15,110.69) v1(187.15,106.88) v1(187.15,103.07) v1(187.15,99.26) v1(187.15,95.45) v1(187.15,91.64) v1(187.15,87.83) v1(187.15,84.02) v1(187.15,80.21) v1(187.15,76.4) v1(187.23,72.89) v1(187.34,49.84) v1(187.34,23.69) v1(187.81,68.52) v1(188.01,35.76) v1(188.63,65.27) v1(189.62,62.32) v1(190,0.53) v1(190.99,59.15) v1(191.99,33.31) v1(191.9,16.53) v1(192.87,55.82) v1(192.95,6.7) v1(192.95,6.11) v1(193.81,0.53) v1(194.24,4.74) v1(194.24,2.93) v1(195.28,4.74) v1(195.28,2.93) v1(195.64,52.01) v1(195.84,6.65) v1(195.83,6.03) v1(197.62,0.53) v1(198.51,48.91) v1(200.15,37.1) v1(201.45,39.35) v1(201.45,34.85) v1(201.43,0.53) v1(202.06,45.92) v1(202.76,7.61) v1(204.05,39.35) v1(204.05,34.85) v1(205.24,0.53) v1(205.35,37.1) v1(205.52,43.63) v1(205.75,28.09) v1(209.05,0.53) v1(209.17,41.75) v1(212.83,40.35) v1(212.86,0.53) v1(215.99,7.38) v1(216.36,31.59) v1(216.51,39.39) v1(216.57,7.26) v1(216.67,0.53) v1(220.43,38.78) v1(220.48,0.53) v1(224.16,28.67) v1(224.29,0.53) v1(225.1,18.36) v1(225.48,38.6) v1(228.1,0.53) v1(230.18,38.6) v1(231.91,0.53) v1(232.14,2.43) v1(234.19,3.45) v1(234.52,38.96) v1(235.39,2.35) v1(235.51,0.53) v1(238.4,1.5) v1(238.69,39.85) v1(239.7,3.75) v1(242.3,41.01) v1(242.3,3.75) v1(242.65,11.45) v1(243.54,13.89) v1(243.6,1.5) v1(243.74,9.01) v1(244.73,42.03) v1(246.89,0.53) v1(247.02,15.08) v1(247.05,7.14) v1(247.05,4.16) v1(247.27,42.89) v1(250.68,17.69) v1(252.46,45.59) v1(254.49,17.69) v1(256.21,50.36) v1(256.55,38.75) v1(258.3,17.7) v1(258.81,53.46) v1(261.09,56.91) v1(262.11,17.69) v1(262.29,48.13) v1(262.29,47.01) v1(262.9,60.39) v1(263.4,48.13) v1(263.4,47.01) v1(263.4,45.89) v1(263.86,37.93) v1(264.14,63.57) v1(264.3,54.65) v1(264.5,37.93) v1(264.52,48.13) v1(264.52,45.89) v1(265.08,66.74) v1(265.05,58.9) v1(265.79,70.53) v1(266,17.7) v1(266.2,104.41) v1(266.17,96.59) v1(266.17,92.78) v1(266.17,88.97) v1(266.17,85.16) v1(266.17,81.35) v1(266.15,77.54) v1(266.12,73.75) v1(266.35,61.15) v1(266.35,56.65) v1(267.05,101.4) v1(267.15,118.5) v1(267.14,115.84) v1(267.17,112.92) v1(267.16,110.62) v1(267.29,108.08) v1(267.25,104.55) v1(268.1,22.37) v1(268.35,103.65) v1(268.35,99.15) v1(268.94,118.51) v1(268.95,61.15) v1(268.95,56.65) v1(269.08,107.91) v1(269.08,104.69) v1(270,106.3) v1(270.25,58.9) v1(270.9,22.7) v1(270.95,103.65) v1(270.95,99.15) v1(271.18,110.25) v1(271.63,118.46) v1(271.66,114.85) v1(272.25,101.4) v1(272.5,113.15) v1(274.05,108.43) v1(274.07,22.7) v1(274.62,53.25) v1(274.83,54.32) v1(275.09,42.89) v1(275.63,43.25) v1(275.77,112.97) v1(275.85,50.18) v1(276.57,56.19) v1(276.99,86.89) v1(276.99,85.62) v1(276.99,84.35) v1(277.69,55.07) v1(277.88,22.7) v1(278.26,86.89) v1(278.26,85.62) v1(278.26,84.35) v1(278.81,53.95) v1(278.97,75.89) v1(279.14,64.92) v1(279.44,94.06) v1(279.58,112.97) v1(279.53,86.89) v1(279.53,85.62) v1(279.53,84.35) v1(280.12,81.39) v1(280.3,110.4) v1(281.22,112.01) v1(281.22,108.79) v1(281.42,94.03) v1(281.69,22.7) v1(283.08,112.01) v1(283.08,108.79) v1(283.96,38.2) v1(284,110.4) v1(284.59,113) v1(285.07,85.03) v1(285.5,22.7) v1(285.97,85.05) v1(285.94,83.72) v1(286.18,65.2) v1(286.18,64.08) v1(286.18,62.97) v1(286.26,84.22) v1(286.25,75.8) v1(286.71,83.77) v1(286.87,118.33) v1(286.9,85.06) v1(287.15,48.28) v1(287.3,65.2) v1(287.3,64.08) v1(287.3,62.97) v1(287.53,94.51) v1(287.76,111.52) v1(288.17,94.51) v1(288.12,52.75) v1(288.41,65.2) v1(288.41,64.08) v1(289.31,22.7) v1(290.02,65.92) v1(290.14,57.08) v1(290.14,55.96) v1(290.14,54.84) v1(290.25,94.53) v1(290.47,62.71) v1(290.61,43.76) v1(291.25,57.08) v1(291.25,55.96) v1(291.37,46.98) v1(292.22,94.56) v1(293.12,22.7) v1(295.15,94.51) v1(296.93,22.7) v1(300.51,57.52) v1(300.51,55.29) v1(300.74,22.7) v1(301.63,57.52) v1(301.63,56.41) v1(301.63,55.29) v1(302.29,64.23) v1(302.75,57.52) v1(302.75,56.41) v1(302.75,55.29) v1(304.37,43.92) v1(304.55,22.7) v1(304.6,50.59) v1(304.93,39.39) v1(305,43.91) v1(305.06,40.79) v1(305.12,28.47) v1(305.36,111.14) v1(305.9,118.33) v1(306.17,55.33) v1(306.1,44.82) v1(306.61,90.65) v1(306.68,44.82) v1(307.09,54.37) v1(307.23,90.73) v1(307.27,44.82) v1(308.04,98.9) v1(308.12,60.22) v1(308.36,22.7) v1(308.74,60.84) v1(308.74,59.59) v1(308.87,31.01) v1(309,74.57) v1(309.1,100.73) v1(309.1,97.07) v1(309.5,107.21) v1(309.5,104.49) v1(310.37,110.99) v1(311.2,100.73) v1(311.2,97.07) v1(312.17,22.7) v1(312.26,98.9) v1(312.31,62.46) v1(312.45,106.01) v1(312.67,63.13) v1(312.67,61.94) v1(312.77,61.36) v1(312.92,62.49) v1(313.19,73.42) v1(313.19,72.84) v1(315.14,55.39) v1(315.12,44.06) v1(315.47,20.34) v1(315.64,22.4) v1(317.01,24.23) v1(317.01,20.57) v1(317.66,57.5) v1(319.09,24.23) v1(319.09,20.57) v1(320.46,22.4) v1(321.44,20.21) v1(321.8,22.4) v1(322.25,100.45) v1(322.43,85.74) v1(322.48,72.81) v1(322.72,24.01) v1(322.72,20.79) v1(324.16,67.63) v1(324.13,62.71) v1(324.13,57.32) v1(324.58,24.01) v1(324.58,20.79) v1(325.13,90.34) v1(325.43,40.79) v1(325.5,22.4) v1(326.14,20.34) v1(326.27,96.23) v1(326.29,92.5) v1(326.27,23.89) v1(327.54,26.56) v3(6.69,10.66) v3(10.17,99.75) v3(10.55,83.84) v3(11.44,64.79) v3(14.86,103.65) v3(44.46,100.98) v3(51.77,87.24) v3(52.08,54.6) v3(80.27,56.74) v3(88.78,65.49) v3(88.78,65.49) v3(89.79,100.02) v3(90.12,102.89) v3(93.91,103.5) v3(107.83,88.28) v3(122.69,31.18) v3(124.27,99.59) v3(151.52,108.03) v3(157.99,67.84) v3(174.12,19.07) v3(181.95,98.82) v3(268,32.97) v3(275.91,106.95) v3(276.64,106.83) v3(280.1,86.31) v3(285.83,32.28) v3(309,105.81) v3(318.9,26.43)
