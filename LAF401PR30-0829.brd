# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N38798744: length 3.4
  TOP w0.203: UT5.G4 31.72,81.96 v1(31.72,82.01)
  BOTTOM w0.102: v1(31.72,82.01) 31.63,82.1 30.8,82.1 30.62,82.28 RT85.1 29.98,82.65 v2(29.62,82.29)
N38798745: length 2.8
  TOP w0.076: UT5.F4 32.3,81.88 v1(32.3,82.01)
  BOTTOM w0.102: v2(31.4,81.62) 32.05,81.62 32.3,81.87 v1(32.3,82.01) 31.66,82.65 RT84.1
N38798858: length 7.6
  TOP w0.076: 32.79,84.6 32.57,84.38 32.57,84 32.64,83.93 UT5.F1
  TOP w0.102: v2(33.03,89.87) 33.03,86.71 33.3,86.43 RT63.1 33.53,86.33 33.03,85.82 33.03,84.84 32.79,84.6
N38798904: length 3.5
  TOP w0.076: UT5.K10 30.39,78.29 30.05,78.29 29.46,77.69
  TOP w0.102: RT105.1 28.95,76.24 v2(28.95,76.9) 29.15,77.11 29.15,77.38 29.46,77.69
N38798905: length 4.7
  TOP w0.076: 28.88,78.17 29.13,78.17 29.74,78.79 30.39,78.79 UT5.K9
  TOP w0.102: 28.88,78.17 28.75,78.17 27.87,77.3 RT104.1 v2(27.64,76.35)
N38798908: length 4.4
  TOP w0.102: RT103.1 29.61,75.61 29.61,74.35 v2(29.37,74.11)
  TOP w0.203: 29.86,77.56 29.86,77.75 UT5.L11
  TOP w0.381: 29.86,77.56 29.86,76.22 RT103.1
N38798948: length 2.2
  BOTTOM w0.102: RT85.2 30.62,85.03 30.16,85.49 T220.1
N38798949: length 1.1
  BOTTOM w0.102: RT84.2 31.56,83.65 31.5,83.72 T219.1
N38799002: length 2.7
  TOP w0.076: v1(31.16,79.95) 31.24,80.04 UT5.H7
  BOTTOM w0.102: v1(31.16,79.95) 30.74,79.53 CT87.1 30.35,79.53 29.8,78.99 v2(29.39,78.99)
N38799008: length 2.5
  TOP w0.102: UT5.D6 33.94,80.54 v1(34.17,80.31)
  BOTTOM w0.102: RT101.1 33.84,80.64 v1(34.17,80.31) 34.42,80.31 v2(34.7,80.59)
N38802239: length 4.1
  BOTTOM w0.102: QV2.1 102.17,81.75 102.94,80.98 103.89,80.98 v2(104.02,80.85)
  BOTTOM w0.254: QV2.1 102.89,82.71 RV5.2
N38802260: length 34.6
  BOTTOM w0.102: RV400.1 128.07,97.48 127.89,97.66 127.89,98.44 128.15,98.7 129.65,98.7 v2(131.45,96.89) 134.78,93.57 134.78,90.21 130.82,86.25 128.59,86.25 127.7,85.36 123.82,85.36 122.94,84.48 RV6.1 122.81,84.22 121.29,84.22 QV7.1
N38802262: length 3.9
  BOTTOM w0.102: QV8.2 127.69,90.52 CV635.1 128.07,91.51 RV400.2 127.18,92.02 v2(127.11,92.09)
N38804727: length 3.5
  BOTTOM w0.102: JEDP1.21 106.3,89.54 LV1.1
N39067212: length 3.8
  TOP w0.102: RE58.1 295.33,69.67 RE57.1 v2(295.58,70.53) 295.58,70.87 296.36,71.65 UE1.B1
N39067288: length 14.1
  TOP w0.102: v1(297.09,65.67) 297.09,65.56 296.6,65.06 RE318.1 295.78,64.87 v2(295.66,64.99)
  TOP w0.107: v1(300.58,70.62) 300.74,70.78 300.74,72.34 UE1.G2
  BOTTOM w0.102: v1(300.58,70.62) 299.62,69.66 299.62,67.59 298.75,66.71 298.75,64.25 298.58,64.09 298.14,64.09 297.82,64.41 297.82,64.93 v1(297.09,65.67)
N39070459: length 3.6
  TOP w0.102: RE70.1 279.58,73.04 279.39,72.85 QE11.3 ; RE70.1 RE90.2 ; RE70.1 v2(278.45,73.68)
N39070470: length 5
  TOP w0.102: RE70.2 280.61,73.57 QE4.2 282.86,72.91 282.86,71.79 v2(282.01,70.95)
N39154673: length 4.1
  TOP w0.102: UV6.10 276.69,52.42 276.53,52.27 RV123.2 v2(276.53,48.99)
N39154676: length 3.1
  TOP w0.102: v2(275.35,50.3) 276.13,51.07 RV124.2 276.13,52.24 276.29,52.4 UV6.9
N39317125: length 3.2
  TOP w0.102: v2(133.76,109.48) PR423.1
  TOP w0.254: PU402.5 133.73,111.34 PR424.1 133.76,110.44 PR423.1
N39469798: length 5.1
  BOTTOM w0.102: v2(64.9,83.13) 66.22,83.13 66.4,82.95 66.86,82.95 66.98,83.08 67.98,83.08 68.22,83.32 PR679.1
  BOTTOM w0.254: PR679.1 68.27,83.64 PU614.7
N39469818: length 2
  BOTTOM w0.102: PR630.2 71.75,46.29 v2(71.65,46.18)
  BOTTOM w0.203: PR630.2 PC631.1
N39469863: length 5.1
  TOP w0.203: PC632.1 70.75,45.81 v2(70.69,45.81) 69.96,45.81 69.76,46.02 PU602.28
  TOP w0.254: PR636.1 PC632.1
N39469972: length 3.9
  TOP w0.203: PU602.38 72.38,51.18 v2(72.58,51.39) 72.58,51.85 72.42,52.01 72.42,52.4 72.8,52.78 73.39,52.78 PR678.2
N39469996:
  vias: v2(67.52,88.16)
N39469998: length 1.9
  BOTTOM w0.102: v2(64.98,84.42) 64.98,84.6 65.99,85.62 PR619.1
N39470129: length 1.8
  BOTTOM w0.102: v2(67.1,41.95) PR646.2
  BOTTOM w0.203: PR646.2 67.11,42.91 PC640.1
N39470145: length 2.1
  BOTTOM w0.102: v2(64.14,43.79) PC601.1
  BOTTOM w0.203: PC601.1 65.35,43.78 PR652.2
N39470173: length 0.9
  TOP w0.254: PC632.2 73.56,44.79 PR641.1
N39470189: length 1.9
  TOP w0.102: v1(82.94,83.01) v2(83.58,83.01)
  TOP w0.254: PR642.2 v1(82.94,83.01)
  BOTTOM w0.254: PR642.2 v1(82.94,83.01)
N39470446: length 6
  TOP w0.102: PR602.1 74.31,46.06 v2(74.43,45.95)
  TOP w0.203: PU602.34 71.93,49.58 72.26,49.26 72.46,49.26 72.78,48.94 72.78,48.75 73.07,48.46 73.87,48.46 PC603.1
  TOP w0.254: PC603.1 74.31,47.9 PR602.1
N39470448: length 3.9
  TOP w0.203: PU602.33 71.92,49.18 v1(72.29,48.81)
  BOTTOM w0.102: v1(72.29,48.81) v2(72.29,49.33)
  BOTTOM w0.203: v1(72.29,48.81) 72.29,48.74 72.65,48.38 PC604.1 72.65,46.9 PR603.1
N39470528: length 3.4
  TOP w0.203: PU602.32 71.69,48.78 72.42,48.05 v2(73.35,48.05) 73.42,47.97 PR608.1
N39470532: length 3.1
  TOP w0.203: PU602.31 71.53,48.38 72.32,47.59 v2(72.32,47.14) 72.32,46.89 PR611.1
N40543303: length 1.4
  TOP w0.102: RI36.2 304.9,55.16 UI5.7
N40543312: length 3.7
  TOP w0.102: v2(298.12,52.6) 298.12,53.26 RI35.2 298.39,54.23 298.39,54.47 299.08,55.16 UI5.24
N40719702: length 1.9
  TOP w0.102: v2(284.92,80.41) CE57.1 RE350.2
N41288260: length 4
  TOP w0.102: v1(291.45,42.95) 291.24,42.74 v2(291.24,42.25) 291.29,42.19 RZ326.1
  BOTTOM w0.102: v1(291.45,42.95) 292.45,42.95 292.8,42.6 JNGFF2.25
N41303246: length 2.4
  BOTTOM w0.102: v2(117.8,107.33) RZ334.1 CZ38.2
N41840158: length 5.5
  TOP w0.102: RN183.1 RN192.2 210.77,34.93 QN4.5 210.25,35.07 210.06,35.26 210.06,36.71 RN182.2 v2(211.33,36.85)
N41840194: length 4.8
  TOP w0.102: v2(224.3,31.77) RN186.2 RN185.1 RN184.2 224.21,34.82 QN5.2
N41840238: length 4.6
  TOP w0.102: QN5.5 221.06,34.82 RN189.2 RN187.2 RN188.1 v2(220.55,37.29)
N44315031: length 8.1
  TOP w0.102: PR947.1 v2(16.92,8.27)
  TOP w0.203: PU901.29 18.65,13.91 18.17,13.43 PC947.1
  TOP w0.254: PR947.1 PR935.1 PC947.1
N44519703: length 3.8
  TOP w0.203: PR948.1 PR936.1 18.75,12.75 v2(18.75,13.38) 19.05,13.67 PU901.30
N44621211: length 4.3
  TOP w0.203: PU901.26 17.45,14.54 16.28,13.37 v2(16.12,13.37) 15.54,12.78 PR933.2 15.52,12.36 PR951.2
N45200928: length 3.4
  BOTTOM w0.102: JNGFF2.67 303.3,41.05 301.86,39.6 T225.1
N45269008: length 27
  BOTTOM w0.102: v2(267,66.81) 267.19,67 RE375.1 269,67 269.16,66.84 JESPI.8 270.33,66.84 270.46,66.97 271.81,66.97 272.17,67.33 272.17,68.39 272.57,68.8 278.54,68.8 283.49,73.75 283.49,75.61 283.72,75.84 284.2,75.84 284.51,76.15 284.51,76.88 284.8,77.17 RE560.1
N45589397: length 5.9
  TOP w0.102: CL17.1 299.81,91.46 v2(300.25,91.46) 300.25,91.13 v1(300.42,90.95)
  BOTTOM w0.102: v1(300.42,90.95) 300.11,91.27 299.15,91.27 298.71,91.71 TL1.4
N45589399: length 5.6
  TOP w0.102: CL16.1 303.16,91.16 v1(303.16,90.7)
  BOTTOM w0.102: TL1.1 301.71,91.61 301.99,91.33 302.53,91.33 v1(303.16,90.7)
N45589425: length 8.4
  TOP w0.102: CL20.1 296.53,92.69 v2(297.07,92.14) 298.41,90.81 v1(299.05,90.81)
  BOTTOM w0.102: TL1.7 295.71,91.92 296.23,91.4 297.76,91.4 298.46,90.7 298.94,90.7 v1(299.05,90.81)
N45589439: length 3.1
  TOP w0.102: CL21.1 v2(292.74,91.79) 293.08,91.45 v1(293.22,91.45)
  BOTTOM w0.102: v1(293.22,91.45) 292.71,91.97 TL1.10
N45863109: length 2.1
  TOP w0.102: v2(84.66,2.3) CD31.2
  TOP w0.508: CD31.2 RD18.1
N45863346: length 2.3
  TOP w0.102: T50.1 v1(81.16,3.6)
  BOTTOM w0.102: JDIMM1.162 81.53,3.97 v1(81.16,3.6)
N45879530: length 7.6
  TOP w0.102: v1(162.36,6.6) 163.14,5.81 165.99,5.81 167.02,4.78 T54.1
  BOTTOM w0.102: v1(162.36,6.6) 162.53,6.43 JDIMM2.162
N45879727: length 2.1
  TOP w0.102: RD31.1 174.05,3.2 v2(174.25,3)
  TOP w0.508: CD62.2 RD31.1
N45925426: length 4.9
  TOP w0.076: 34.12,84.36 33.85,84.09 33.85,83.38 33.64,83.17 UT5.D1
  TOP w0.102: 34.12,84.36 34.17,84.41 34.37,84.41 v2(34.47,84.51) 34.47,84.83 34.32,84.98 34.32,87.18 RT378.1
N45925428: length 3.6
  TOP w0.076: 34.25,84.18 34.03,83.95 34.03,83.3 33.89,83.17 33.89,82.79 UT5.D2
  TOP w0.102: RT379.1 34.8,85.39 34.8,84.35 34.64,84.18 34.25,84.18
N45988164: length 1.8
  BOTTOM w0.102: PC119.1 171.2,111.07 v2(172.22,110.05)
N46047516: length 7.2
  BOTTOM w0.254: PR28.1 62.42,103.91 PQ8.3 64.22,102.11 64.22,101.11 v2(65.55,99.78) 66.73,99.78 PR26.2
N46047518: length 9.3
  BOTTOM w0.254: PR22.1 66.43,97.07 v2(66.71,97.35) 66.73,97.38 PR27.1 65.69,98.76 63.63,100.82 63.63,101.45 PQ8.1
N46047526: length 3.6
  BOTTOM w0.102: v2(64.81,101.1) 64.81,102.88 65.05,103.11 PR29.2
  BOTTOM w0.254: PQ8.2 64.87,103.5 PR29.2
N46050852: length 5.3
  TOP w0.102: 28.26,31.32 28.39,31.45 28.77,31.45 28.91,31.31 PQ1208.3 ; 28.26,31.32 PQ1208.2 ; 28.26,31.32 28.14,31.45 26.68,31.45 26.5,31.27 PR1259.1 v2(26.5,29.66)
N46050860: length 118.3
  TOP w0.102: v1(24.52,31.83) 28.07,31.83 28.26,32.02 PQ1208.5 28.26,33.6 PR1261.1 PR1260.2 ; v1(63.91,108.65) v2(64.79,108.65)
  IN1 w0.089: v1(63.91,108.65) 63.92,108.65 64.35,108.22 64.35,107.04 63.83,106.51 63.83,103.87 60.97,101 v1(60.97,91.69)
  IN2 w0.122: v1(60.97,91.69) 60.37,91.09 54.6,91.09 53.45,89.93 48.85,89.93 47.6,88.69 44.61,88.69 41.18,85.26 37.39,85.26 36.64,84.51 36.64,82 36.14,81.49 36.14,80.78 37.17,79.75 37.17,71.09 18.84,52.76 18.84,41.85 19.72,40.97 19.72,34.74 22.63,31.83 v1(24.52,31.83)
  BOTTOM w0.102: PR1244.2 v1(63.91,108.65)
N46050887: length 12.9
  TOP w0.102: PQ1208.6 27.61,33.61 PR1261.2 v1(26.87,33.74) v2(26.09,33.74) ; v1(31.88,38.05) 31.9,38.07 PQ1211.1 31.9,39.77 PR1234.1
  IN1 w0.089: v1(26.87,33.74) 26.87,36.66 27.25,37.04 29.22,37.04 30.23,38.05 v1(31.88,38.05)
N46050911: length 3.3
  TOP w0.102: PQ1211.5 PR1233.1 PR1242.2 29.79,35.72 v2(29.32,36.19)
N46050913: length 3.7
  TOP w0.102: PQ1211.2 31.25,39.76 PR1235.1 PR1257.2 30.04,39.88 29.24,40.68 v2(29.24,41.06)
N46050923: length 2.5
  TOP w0.102: v2(26.09,37.33) 27.14,37.33 PR1245.2 27.5,37.69 PQ1210.5
N46051012: length 9.5
  TOP w0.102: v2(29.34,37.61) v1(30.6,37.61) PQ1211.4 ; v1(32.77,37.61) 32.9,37.74 34.23,37.74 34.93,37.04 PQ1207.6 34.93,35.65 PR1230.1 34.18,34.65 PR1258.2
  IN1 w0.089: v1(32.77,37.61) v1(30.6,37.61)
N46051197: length 2.7
  TOP w0.102: PQ1207.3 PQ1207.2 34.28,39.49 PR1232.1 v2(35.31,39.5)
N46051213: length 1.1
  TOP w0.102: PR1241.2 34.28,35.61 PQ1207.5
N46101144: length 6
  TOP w0.102: PR1219.1 v2(68.07,112.31)
  TOP w0.254: PC1206.1 68.1,110.36 PR1203.1 68.1,108.61 v1(68.22,108.48) ; PC1206.1 68.07,110.41 PR1219.1 ; PC1206.1 67.2,110.4 PR1201.2
  BOTTOM w0.254: PU1201.3 v1(68.22,108.48)
N46101200: length 4.7
  BOTTOM w0.102: PR1208.2 65.98,111.7 65.33,111.7 v2(65.33,111.7)
  BOTTOM w0.254: PR1208.2 66.43,111.28 PC1205.1 ; PU1201.2 67.57,111.04 PC1205.1 ; PC1205.1 67.32,111.28 PR1217.1
N46209617: length 2.4
  TOP w0.102: v2(23.2,30.5) 22.48,30.5 22.1,30.88
  TOP w0.254: 22.1,30.88 22.12,30.89 PQ1205.2
N46209621: length 5.4
  TOP w0.102: v2(19.8,31.6) 19.8,32.26 PQ1205.1
  TOP w0.254: PQ1205.1 20.23,32.66 22.74,32.66 23.02,32.94 PR1226.2 PR1215.1
N46209625: length 4.1
  TOP w0.102: v2(22.76,37.11) 22.76,35.86 PR1224.1
  TOP w0.254: PQ1205.3 22.12,34.3 PR1221.2 22.23,34.46 PR1224.1
N46209711: length 2.2
  TOP w0.102: PR1211.2 19.45,37.73 v2(19.83,38.11)
  TOP w0.254: PU1200.1 18.79,37.58 PR1211.2
N46209717: length 14.4
  TOP w0.102: PR1215.2 23.25,40.15 22.99,40.4 20.96,40.4 v2(20.25,39.69) 20.25,36.96 19.25,35.96 18.55,35.96 18.14,36.36 PU1200.2
N46210543: length 2.3
  TOP w0.102: v2(18.1,33.97) 17.77,33.63 PR1216.1
  TOP w0.254: PR1216.1 17.49,33.98 PU1200.4
N46212351: length 28.8
  TOP w0.254: PR1251.2 4.59,54.5 PQ1215.2 3.74,52.41 3.31,52.41 1.76,50.86 1.76,37.53 2.44,36.85 v2(6.99,36.85) 9.96,36.85 PR1252.1
N46212363: length 2.3
  TOP w0.102: PR1252.2 11.7,38.61 v2(11.68,38.64)
  TOP w0.254: PQ1214.6 11.29,37.09 11.7,37.5 PR1252.2
N46447690: length 3.2
  TOP w0.102: v2(269.12,76.71) RZ25.1 269.12,75.46 269.55,75.02 269.55,74.97 269.58,74.94 QZ3.1
N46814682: length 28.3
  TOP w0.102: v1(72.84,57.93) v2(73.46,57.93)
  TOP w0.254: v1(72.84,57.93) 72.77,57.93 72.24,57.4 PR631.2 PR610.1
  IN2 w0.254: v1(63.25,73.98) 64.14,73.09 67.01,73.09 67.34,72.76 71.91,72.76 72.9,71.77 72.9,59.96 72.33,59.39 72.33,58.31 72.71,57.93 v1(72.84,57.93)
  BOTTOM w0.254: v1(63.25,73.98) 63.12,74.11 PH601.2
N46814700: length 0.9
  TOP w0.254: PC627.1 65.97,56.11 PR632.2
N46814728: length 25
  TOP w0.102: v2(73.41,56.61) 73.41,56.72 v1(72.84,57.3)
  IN3 w0.254: v1(72.84,57.3) 73.09,57.3 73.35,57.55 73.35,59.71 73.03,60.03 73.03,73.17 71.4,74.8 v1(71.18,74.8)
  BOTTOM w0.254: v1(72.84,57.3) 72.84,56.47 72.46,56.09 PR628.2 ; PH602.1 72.57,74.52 72.29,74.8 v1(71.18,74.8)
N46814746: length 3.8
  TOP w0.203: PR638.2 67.09,54.97 v2(67.09,54.19) 67.76,53.52 PU602.8
  TOP w0.254: PC627.2 PR638.2
N46814769: length 0.9
  TOP w0.254: PC617.2 70.45,57.01 PR621.1
N46815156: length 3.7
  TOP w0.203: PR620.2 72.6,54.72 v2(72.19,54.3) 71.62,53.74 71.13,53.74 70.56,53.18 PU602.1
N46815164: length 0.9
  TOP w0.254: PC621.2 70.46,55.22 PR623.1
N46815166: length 4.5
  TOP w0.203: PR623.2 69.53,54.93 68.96,54.37 v2(68.96,53.99) PU602.5
  TOP w0.254: PR621.2 69.56,56.06 PR622.2 69.53,56.05 PR623.2
N46815186: length 3.8
  TOP w0.203: PU602.4 69.36,53.91 v1(69.5,54.04)
  BOTTOM w0.102: v2(69.02,54.15) 69.4,54.15 v1(69.5,54.04)
  BOTTOM w0.254: v1(69.5,54.04) 69.17,53.71 PR617.2 PC616.2
N46815188: length 2
  BOTTOM w0.102: v2(66.49,53.96) 67.17,53.28 PC614.2
  BOTTOM w0.254: PC614.2 67.39,53.28 PR617.1
N46815204: length 4.1
  TOP w0.203: PU602.3 69.76,53.65 70.38,54.26 v2(70.88,54.26) 71.24,54.26 PR610.2
N46815214: length 3.8
  TOP w0.203: v1(70.57,53.82) 70.47,53.82 70.16,53.5 PU602.2
  BOTTOM w0.102: v1(70.57,53.82) v2(70.97,54.22)
  BOTTOM w0.254: PC613.2 v1(70.57,53.82) 71,53.82 71.25,53.56 PR613.2
N46816449: length 1.8
  TOP w0.102: v2(61.88,55.4) PC647.2
  TOP w0.203: PR650.2 61.88,54.51 PC647.2
N46816463: length 1.9
  BOTTOM w0.102: v2(63.17,46.07) 63.45,46.35 PC629.2
  BOTTOM w0.203: PC629.2 64.14,46.38 PR639.1
N46816511: length 22.6
  TOP w0.102: v1(56.09,57.17) v2(56.09,56.46)
  IN2 w0.254: v1(56.09,57.17) 57.46,58.54 59.72,58.54 60,58.26 60,57.27 63.91,53.36 65.35,53.36 65.85,52.85 65.85,47.71 v1(65.73,47.58)
  BOTTOM w0.254: PR647.2 65.59,49.11 PR635.1 65.59,48.61 65.73,48.47 v1(65.73,47.58) ; PH603.2 v1(56.09,57.17)
N46816791: length 5.2
  TOP w0.203: PC630.1 62.8,46.13 PR640.1 64.47,47 v2(64.91,47.44) 64.91,47.85 65.45,48.38 PU602.20
N46816817: length 2.9
  TOP w0.102: PC630.2 61.88,46.12 62.36,45.64 63.63,45.64 v2(63.68,45.69)
  TOP w0.203: PR644.1 61.07,46.12 PC630.2
N46816821: length 16.3
  TOP w0.102: v1(58.21,49.1) 58.01,49.3 v2(58.01,49.61)
  TOP w0.203: PR657.2 v1(58.21,49.1)
  IN3 w0.254: v1(65.85,58.12) 64.46,56.72 61.35,56.72 58.21,53.59 v1(58.21,49.1)
  BOTTOM w0.254: PH605.1 65.98,58.25 v1(65.85,58.12)
N46816907: length 1.8
  TOP w0.203: v2(60.01,53.49) PR645.1
  TOP w0.254: PR645.1 PC639.2
N46907385: length 2.4
  TOP w0.102: RT380.2 18.04,93.5 v1(18.29,93.76) 18.69,93.76 v2(18.86,93.93)
  BOTTOM w0.102: v1(18.29,93.76) UT9.32
N46924944: length 6.1
  TOP w0.102: PR920.2 13.21,16.94 12.94,17.21 11.45,17.21 v2(10.86,17.8)
  TOP w0.203: 14.78,16.76 PU901.21
  TOP w0.254: PR920.2 13.23,16.76 14.78,16.76
N46924987: length 3.4
  TOP w0.203: PU901.22 14.91,16.36
  TOP w0.254: 14.91,16.36 14.46,16.36 14.36,16.26 v2(14.09,16.26) 13.62,16.26 PR922.2
N47045001: length 0.9
  TOP w0.102: RZ63.1 CZ56.1
N47046031: length 4
  TOP w0.102: v1(300.92,48.3) 300.33,48.89 299.93,48.89 RZ132.2 v2(298.49,49.28)
  BOTTOM w0.102: JNGFF2.58 301.05,48.43 v1(300.92,48.3)
N47324022:
  vias: v2(183.22,91.74)
N48068474: length 2
  BOTTOM w0.102: v2(186.21,95.01) 186.21,94.29 PC307.2
  BOTTOM w0.254: PR308.1 185.07,94.01 PC307.2
N48704005: length 2.5
  TOP w0.102: v1(78.81,86.31) v2(78.81,86.97)
  TOP w0.254: PR624.1 v1(78.81,86.31)
  BOTTOM w0.254: PL614.3 v1(78.81,86.31)
N49117945: length 3.7
  TOP w0.203: PU901.27 17.85,14.16 v1(17.52,13.83)
  BOTTOM w0.102: v2(19.12,14.88) PR932.1
  BOTTOM w0.254: v1(17.52,13.83) 17.73,14.05 PR932.1
N49618756: length 2.1
  TOP w0.102: RC433.2 178.03,34.28 QC6.1
N49618758: length 9.1
  TOP w0.102: v2(180.31,28.42) QC7.2 179.47,30.1 179.27,30.31 179.27,32.7 179.7,33.13 RC432.2 RC433.1 178.49,33.09 177.65,33.09 CC340.1
N49742107: length 2.3
  TOP w0.102: v2(286.26,72.03) 286.52,71.77 RE94.1 287.2,72.93 QE12.1
N49990748: length 3.4
  TOP w0.254: v1(56.57,68.78) 56.98,69.18 PR687.2
  BOTTOM w0.102: v2(57.16,67.38) 57.35,67.57 PU610.1
  BOTTOM w0.254: v1(56.57,68.78) 56.83,69.03 PU610.1
N49990845: length 13.1
  TOP w0.102: v2(62.67,73.6) 63.04,73.23 v1(63.04,73.07)
  TOP w0.254: PR659.2 v1(63.04,73.07)
  IN1 w0.254: v1(63.04,73.07) 62.16,72.19 62.16,68.73 61.85,68.42 58.07,68.42 57.05,69.44 v1(56.57,69.44)
  BOTTOM w0.254: PU610.2 56.67,69.53 v1(56.57,69.44)
N49990847: length 3.9
  BOTTOM w0.102: PC655.2 54.49,72.75 v2(54.49,73.47)
  BOTTOM w0.254: PU610.7 55.21,72.03 PC655.2
N49990849: length 2.6
  BOTTOM w0.254: PR660.2 55.31,71.37 56.6,71.37 56.93,71.03 PU610.5
N49990851: length 1.2
  BOTTOM w0.508: PC655.1 PR660.1
N49990930: length 2.4
  TOP w0.102: v2(57.16,67.33) 57.41,67.58 v1(58,67.58)
  TOP w0.254: PR686.2 57.94,67.64 v1(58,67.58)
  BOTTOM w0.254: v1(58,67.58) 58.05,67.63 PU610.17
N49991792: length 1.5
  BOTTOM w0.305: PR692.2 63.3,75.56 PU613.1
N49991813: length 1.5
  BOTTOM w0.305: PU613.2 63.21,76.06 PR671.2
N49991827: length 1.8
  TOP w0.254: v1(63.73,77.87) 63.99,77.62 PR672.2
  BOTTOM w0.254: PU613.5 64.04,77.56 v1(63.73,77.87)
N49991829: length 2.8
  TOP w0.254: PC671.2 v1(63.73,78.86)
  BOTTOM w0.102: v2(62.72,79.24) 63.1,78.86 v1(63.73,78.86)
  BOTTOM w0.254: v1(63.73,78.86) 64.03,78.56 PU613.7
N49991831: length 3.5
  TOP w0.102: v2(61.98,75.84) 61.98,76.45 63.06,77.53 PR672.1
  TOP w0.508: PR672.1 PC671.1
N49991845: length 2.9
  TOP w0.102: v1(65.26,74.03) 65.26,73.98 65.67,73.58 v2(65.77,73.58)
  TOP w0.254: PR689.2 64.42,74.87 v1(65.26,74.03)
  BOTTOM w0.254: PU613.17 v1(65.26,74.03)
N49992706: length 3
  TOP w0.102: v2(58,57.45) 57.92,57.53 v1(57.92,58.06)
  TOP w0.254: PR681.2 56.82,58.44 57.21,58.06 v1(57.92,58.06)
  BOTTOM w0.254: PU612.17 v1(57.92,58.06)
N49992725: length 38.9
  TOP w0.102: v2(57.79,46.78) 58.21,47.2 v1(58.7,47.2)
  TOP w0.203: PR661.1 v1(58.7,47.2)
  IN2 w0.254: v1(58.7,47.2) 59.21,47.71 60.46,47.71 63.44,44.72 70.11,44.72 71.51,46.12 71.51,46.88 71.09,47.3 71.09,55.41 71.89,56.22 71.89,57.61 71.32,58.18 71.32,59.01 71,59.33 68.01,59.33 v1(67.38,59.96)
  BOTTOM w0.254: v1(67.38,59.96) 67.38,62.18 67.06,62.5 PL612.3
N49992760: length 5
  BOTTOM w0.102: PC663.2 55.16,63.54 53.75,63.54 v2(52.94,62.73)
  BOTTOM w0.254: PC663.2 56.15,62.56 PU612.7
N49992762: length 1.5
  BOTTOM w0.254: PR665.2 55.88,61.56 PU612.5
N49992764: length 2.8
  BOTTOM w0.102: v2(52.94,61.36) 53.24,61.66 PR665.1
  BOTTOM w0.508: PC663.1 PR665.1
N49992770: length 3.3
  BOTTOM w0.254: PR664.2 55.38,57.88 v2(56.2,57.88) 56.7,58.37 56.7,59.25 57.01,59.56 PU612.1
N49992776: length 4.1
  BOTTOM w0.102: v2(54.21,59.94) 54.41,59.94 55.22,59.12 PR662.2
  BOTTOM w0.254: PR662.2 55.68,58.9 56.84,60.06 PU612.2
N50204886: length 1.3
  TOP w0.102: PR914.2 v2(19.56,24.63)
N50205391: length 1.8
  TOP w0.102: v2(16.37,9.68) PC944.1
  TOP w0.203: PR934.2 16.4,10.66 PC944.1
N50261217: length 2.7
  TOP w0.102: RV97.1 107.28,92.45 105.72,92.45 105.6,92.58 UV7.20
N50261242: length 3.9
  TOP w0.102: UV7.17 104.4,92.33 105.76,90.96 CV96.1 106.35,91.27 v2(106.35,91.89)
N50318439: length 2.8
  TOP w0.102: v2(165.75,32.28) RZ62.1 166.32,33.93 UZ12.27
N50405068: length 2.3
  TOP w0.102: RV620.2 276.74,51.15 276.74,52.07 277.09,52.42 UV6.11
N50430953: length 75.9
  TOP w0.102: v1(151.26,55.64) 151.45,55.83 RV324.2 152.53,56.42 152.53,56.61 RV326.2 RV323.2 152.71,58.08 153.01,58.39 v2(154.61,58.39)
  IN2 w0.122: v1(152.28,82.8) 149.71,85.36 142.35,85.36 139.83,82.85 139.83,80.28 138.97,79.42 136.72,79.42 136.34,79.8 136.34,80.92 135.39,81.87 134.5,81.87 134.17,81.54 131.91,81.54 131.76,81.69 129.54,81.69 129.39,81.54 128.49,81.54 127.61,80.65 122.06,80.65 v1(121.8,80.92)
  IN4 w0.089: v1(152.28,82.8) 153.37,82.8 154.46,81.7 154.46,80.71 153.65,79.9 153.65,77.97 150.63,74.95 150.63,73.07 150.63,68.78 149.99,68.14 149.99,64.9 149.42,64.33 149.42,60.63 150.07,59.99 150.07,56.84 v1(151.26,55.64)
  BOTTOM w0.102: v1(121.8,80.92) 121.56,81.16 QV7.2
N50578362: length 3.4
  TOP w0.254: v1(100.31,66.1) 100.82,66.6 v2(100.82,66.95) 100.82,67.91 RC436.2
  BOTTOM w0.254: UC1.G65 100.65,65.75 v1(100.31,66.1) 100.62,66.4 UC1.F65
N50694114: length 74.6
  TOP w0.102: v1(286.21,76.65) 286.44,76.88 CE64.1 286.92,77.62 RE565.1 ; QE15.2 318.95,60.83 DE2.1 316.88,60.83 RE543.2 RE541.2 314.28,61.03 313.89,61.42 v2(313.89,62.78) 313.89,66.12 v1(313.57,66.44)
  IN3 w0.122: v1(286.21,76.65) 286.21,79.04 288.45,81.27 292.58,81.27 294.44,83.14 294.44,84.47 292.94,85.97 292.94,88.94 294.87,90.87 297.82,90.87 298.99,89.71 309.05,89.71 310.9,87.85 310.9,84.4 312.91,82.38 312.91,74.76 314.08,73.6 314.08,66.95 v1(313.57,66.44)
N50694120: length 3.6
  TOP w0.102: v2(319.26,66.36) 319.4,66.22 RE546.2 317.88,65.23 QE17.1
N51151144: length 1.4
  TOP w0.102: UV6.12 277.49,51.95 RV622.2
N52178133: length 4.6
  BOTTOM w0.102: QZ1.2 113.67,84.7 RZ380.2 114.66,85.69 CZ200.1
N119328643: length 6.3
  TOP w0.203: PC938.1 v2(14.41,13.3) 15.16,14.06 16.19,14.06 PU901.25
  TOP w0.254: PR931.2 13.55,10.71 PR930.1 PC938.1
N132000604: length 1.4
  TOP w0.102: PR921.2 v3(25.63,17.93)
N132005053: length 9.2
  TOP w0.254: PR917.3 29.74,9.15 29.57,9.31 27.49,9.31 26.62,10.18 v2(26.62,10.38) 26.62,12.32 26.09,12.86 26.09,13.4 25.71,13.78 25.32,13.78 PR938.2
N5026098529: length 2.3
  TOP w0.102: UV7.4 99.2,90.78 T204.1
N5026098531: length 1.3
  TOP w0.102: UV7.2 98.4,92.01 T223.1
N5026098558: length 1.4
  TOP w0.102: UV7.14 103.2,92.13 T224.1

## Copper pours and planes (outline as drawn)
2.5VSP on TOP (solid shape): 192.16,8.83 192.16,8.31 192.19,8.28 192.59,8.28 192.63,8.32 192.63,8.8 192.67,8.84 192.97,8.84 193.09,8.72 193.09,7.78 193.06,7.75 193.06,7.72 192.55,7.21 192.55,5.36 192.84,5.07 193.62,5.07 193.73,4.97 193.73,4.71 193.59,4.57 192.38,4.57 191.63,5.32 191.63,8.68 191.79,8.85 192.14,8.85
3V_SN on BOTTOM (solid shape): 160.28,109.06 160.99,109.06 161.04,109.01 161.04,108.32 160.91,108.2 158.45,108.2 158.37,108.27 158.37,109.87 158.42,109.92 159.42,109.92
3V_VIN on TOP (solid shape): 158.02,118.86 158.02,117.01 158.81,116.22 158.81,115.54 159.12,115.22 159.76,115.22 159.81,115.18 159.81,114.83 159.78,114.8 159.25,114.8 159.25,114.25 159.8,114.24 159.81,114.23 159.81,114.02 159.8,114.01 159.26,114.01 159.26,114 159.26,113.45 159.79,113.45 159.81,113.42 159.81,112.92 159.28,112.39 158.2,112.39 157.38,111.57 156.6,111.57 156.55,111.63 156.55,113.12 156.62,113.2 157.03,113.2 157.24,113.42 157.24,114.38 156.75,114.88 156.75,116.32 156.9,116.48 156.9,117.82 157.23,118.15 157.23,118.9 157.33,119 157.88,119
3V_VIN on BOTTOM (solid shape): 157.52,117.32 157.52,117.32 157.52,116.95 158.44,116.03 158.44,115.65 158.82,115.27 158.82,113.77 158.65,113.61 157.51,113.61 157.28,113.84 157.28,114.29 156.8,114.78 156.8,116.35 156.94,116.49 156.94,117.87 157.52,117.87
5V_SN on BOTTOM (solid shape): 163.07,108.54 163.07,106.57 162.95,106.44 161.98,106.44 161.3,107.13 161.3,108.48 161.42,108.6 163.01,108.6
5V_VIN on TOP (solid shape): 164.97,118.76 164.97,116.34 164.66,116.03 163.75,116.03 162.86,116.92 162.86,117.84 162.95,117.92 163.61,117.92 163.92,118.23 163.92,118.75 164.05,118.89 164.84,118.89
5V_VIN on BOTTOM (solid shape): 164.98,118.76 164.98,116.78 166.1,115.66 166.5,115.66 166.59,115.57 166.59,114.11 166.5,114.01 164.69,114.01 164.61,114.09 162.44,114.09 162.37,114.02 162.3,114.03 162.24,114.02 161.85,114.02 160.94,114.93 160.94,115.76 160.95,115.77 161.47,115.77 161.49,115.79 161.49,116.28 161.46,116.3 160.95,116.3 160.93,116.32 160.93,116.57 160.94,116.57 161.45,116.57 161.49,116.61 161.49,117.06 161.45,117.1 160.96,117.1 160.93,117.13 160.93,117.76 161.17,118 163.68,118 163.91,118.23 163.91,118.76 164.04,118.89 164.85,118.89
+0.6V_DDR_VTT on TOP (solid shape): 190.72,7.49 190.72,5.86 190.55,5.69 186.97,5.69 186.68,5.98 186.68,7.26 187.07,7.65 190.56,7.65
+0.6V_DDR_VTT on TOP (solid shape): 50.12,52.96 50.12,51.62 49.97,51.47 48.94,51.47 48.89,51.52 48.89,51.95 48.87,51.97 48.35,51.97 48.32,52 48.32,52.12 48.38,52.18 48.87,52.18 48.87,52.69 48.86,52.69 48.86,52.93 49.03,53.11 49.97,53.11
+0.6V_DDR_VTT on TOP (solid shape): 107.73,7.58 107.73,7.14 107.91,6.97 107.91,4.19 107.2,3.47 106.33,3.47 106.22,3.58 106.22,5.71 106.25,5.72 106.51,6.07 106.24,6.41 106.21,6.42 106.21,6.71 106.49,6.99 106.57,6.99 106.57,7.07 107.23,7.73 107.59,7.73
+0.6V_DDR_VTT on IN4 (solid shape): outline of 2383 points within 48.65,1.22 190.97,53.4
+0.6VSP on TOP (solid shape): 48.74,52.59 48.74,52.31 48.2,52.31 48.2,52.31 48.2,51.82 48.73,51.82 48.73,51.82 48.73,51.26 47.99,50.51 45.39,50.51 45.19,50.72 45.19,51.28 45.42,51.5 46.12,51.5 46.33,51.71 46.33,52.41 46.52,52.61 48.72,52.61
+0.6VSP on BOTTOM (solid shape): 47.73,52.06 47.73,50.96 47.24,50.47 47.24,49.5 47.12,49.38 46.59,49.38 46.51,49.46 46.51,50.62 46.6,50.7 46.6,52.03 46.7,52.13 47.66,52.13
+0.9V_LAN on TOP (solid shape): 285.18,87.75 285.18,87.75 285.3,87.72 285.41,87.73 285.44,87.74 285.66,87.51 287.27,87.51 287.37,87.46 287.47,87.44 287.49,87.44 287.56,87.38 287.56,86.73 287.15,86.33 285.73,86.33 285.7,86.3 285.65,86.3 285.65,86.25 285.6,86.2 285.6,85.74 285.42,85.56 284.57,85.56 284.36,85.77 284.36,87.44 284.52,87.61 284.54,87.61 284.66,87.66 284.78,87.74 284.79,87.75
+0.9V_LAN on TOP (solid shape): 280.2,83.14 280.2,82.14 280.34,82 280.4,82 280.46,81.99 280.56,82.01 280.63,82.06 280.67,82.14 280.8,82.14 281.07,82.14 281.24,81.96 281.24,81.49 280.91,81.15 280.58,81.15 280.47,81.26 280.47,81.53 280.3,81.71 280.29,81.71 280.25,81.75 280.02,81.75 279.94,81.83 279.93,81.9 279.91,81.93 279.8,82.05 279.66,82.12 279.61,82.12 279.61,82.64 279.58,82.79 279.49,82.91 279.49,83.16 279.55,83.22 280.12,83.22
+0.9V_LAN on BOTTOM (solid shape): 281.26,82.62 281.26,81.76 280.73,81.22 280.57,81.22 280.5,81.26 280.47,81.34 280.36,81.65 280.04,81.74 279.96,81.75 279.92,81.82 279.67,82.11 279.31,82.01 279.15,82.01 279,82.16 279,83.03 279.13,83.15 280.73,83.15
+0.9V_LAN on IN2 (solid shape): outline of 917 points within 272.47,79.86 286.14,90.41
+1.0V_AMPHYPLL on TOP (solid shape): 147.16,71.02 147.53,71.02 147.65,70.9 147.7,70.85 147.75,70.81 147.83,70.72 147.83,69.87 148.09,69.61 148.09,68.67 148.08,68.67 147.02,68.67 146.86,68.83 146.86,69.8 146.41,70.25 144.38,70.25 144.25,70.38 144.25,70.82 144.38,70.95 145.31,70.95 145.4,71.04 146.33,71.04 146.34,71.04 147.14,71.04
+1.0V_AMPHYPLL on IN3 (solid shape): outline of 1046 points within 129.38,63.4 138.74,70.32
+1.0V_APLL on TOP (solid shape): outline of 152 points within 129.52,59.46 134.9,61.09
+1.0V_APLLEBB on TOP (solid shape): 145.04,74.2 145.04,72.73 144.02,72.73 143.9,72.6 143.58,72.6 143.39,72.79 143.39,74.06 143.58,74.25 144.99,74.25
+1.0V_APLLEBB on IN3 (solid shape): outline of 332 points within 126.61,61.97 144.15,73.93
+1.0V_CLK2 on TOP (solid shape): 127.6,80.41 127.6,79.54 127.5,79.44 125.45,79.44 125.12,79.77 125.12,80.51 125.14,80.52 125.71,80.52 125.76,80.58 127.44,80.58
+1.0V_CLK2 on TOP (solid shape): outline of 89 points within 126.47,63.64 128.17,67.76
+1.0V_CLK3 on IN3 (solid shape): outline of 244 points within 125.44,63.53 130.67,74.35
+1.0V_CLK4 on BOTTOM (solid shape): 125.72,81.06 125.72,80.07 125.86,79.93 125.86,78.02 125.66,77.82 125.66,77.09 125.39,76.82 123.56,76.82 123.32,77.06 123.32,78.68 123.98,79.34 123.98,81.16 124.23,81.41 125.37,81.41
+1.0V_CLK5 on TOP (solid shape): 136.18,84.92 136.89,84.92 137.04,84.77 137.04,84.04 136.81,83.71 137.04,83.38 137.04,83.2 136.82,82.99 135.13,82.99 134.88,83.24 134.88,83.77 134.63,84.03 134.37,84.03 134.31,84.09 134.31,84.92 134.37,84.98 136.12,84.98
+1.0V_CLK5 on IN3 (solid shape): 128.82,69.16 128.82,69.03 128.37,68.58 128.34,68.58 127.69,67.93 127.69,66.23 127.59,66.04 127.64,65.82 127.66,65.78 127.69,65.74 127.69,65.52 127.62,65.35 127.65,65.17 127.67,65.13 127.69,65.1 127.69,64.72 127.15,64.18 127.12,64.18 126.87,64.13 126.74,63.91 126.74,63.77 126.81,63.64 126.81,63.22 126.77,63.15 126.75,63.08 126.74,63 126.55,62.81 126.32,62.81 126.15,62.98 126.15,63.84 126.4,64.1 126.4,64.31 127.08,64.98 127.1,64.99 127.35,65.22 127.25,65.56 127.23,65.6 127.22,65.65 127.22,66.25 127.23,66.29 127.23,66.87 127.23,66.93 127.25,66.97 127.35,67.12 127.35,67.3 127.27,67.45 127.12,67.53 127.1,67.54 127.1,67.78 127.1,67.83 127.12,67.87 127.16,67.88 127.48,68.06 127.44,68.42 127.4,68.46 128.37,69.42 128.56,69.42
+1.0V_MPHYAON on TOP (solid shape): outline of 575 points within 127.46,63.62 138.5,78.63
+1.0V_MPHYAON on BOTTOM (solid shape): 135.9,80.79 135.9,79.2 135.35,78.66 135.35,77.2 135.13,76.98 133.48,76.98 132.97,77.49 132.97,78.61 133.63,79.27 133.99,79.27 134.12,79.39 134.12,79.9 133.99,80.03 133.36,80.03 133.23,80.16 133.23,80.92 133.29,80.98 134.88,80.98 134.94,81.04 135.64,81.04
+1.0V_MPHYGT on TOP (solid shape): 120.59,80.47 120.59,80.16 120.74,80 121.19,80 121.42,79.77 121.42,78.43 121.25,78.26 120.01,78.26 119.69,78.58 119.69,79.24 119.77,79.32 119.77,80.54 120.53,80.54
+1.0V_MPHYGT on TOP (solid shape): 156.41,69.15 156.41,64.39 156.1,64.08 154.84,64.08 154.69,64.23 154.69,67.71 154.72,67.74 154.7,67.75 154.7,68.31 151.44,71.57 146.64,71.57 146.49,71.57 146.39,71.67 146.32,71.67 146.32,71.71 145.43,71.71 145.43,71.61 145.15,71.33 144.15,71.33 144.15,71.98 144.18,72 145.04,72 145.17,72.13 145.17,72.99 145.41,73.23 152.32,73.23
+1.0V_MPHYGT on TOP (solid shape): 129.33,63.07 129.33,62.38 129.28,62.23 129.3,62.07 129.18,61.95 128.08,61.95 128.08,62.05 128.03,62.09 128.04,62.12 127.95,62.41 127.65,62.51 127.62,62.5 127.43,62.69 127.43,63.12 127.51,63.2 127.71,63.2 128.23,62.68 128.54,62.68 128.74,62.88 128.74,63.16 128.85,63.28 129.12,63.28
+1.0V_MPHYGT on BOTTOM (solid shape): 141.11,90.73 141.11,88.74 141.04,88.66 140.59,88.66 140.59,89.24 138.56,89.24 138.56,88.66 136.15,88.66 135.89,88.92 135.89,90.8 136.25,91.16 140.68,91.16
+1.0V_MPHYGT on IN1 (solid shape): outline of 827 points within 119.41,77.86 138.08,90.3
+1.0V_MPHYGT on IN2 (solid shape): outline of 1276 points within 128.02,60.98 157.36,66.5
+1.0V_MPHYGT on IN4 (solid shape): outline of 1853 points within 118.69,61.27 130.31,80.16
+1.0V_PRIM on TOP (solid shape): 128.65,61.71 128.65,60.9 128.57,60.81 127.78,60.81 127.44,61.15 127.44,61.49 127.72,61.78 128.59,61.78
+1.0V_PRIM on TOP (solid shape): 144.68,66.79 144.68,66.42 144.7,66.41 144.7,66.22 144.94,65.98 144.94,65.94 144.93,65.93 144.91,65.8 144.93,65.68 144.94,65.67 144.94,65.05 144.93,65.04 144.91,64.92 144.93,64.79 144.94,64.78 144.94,64.66 144.9,64.61 144.86,64.56 144.85,64.53 143.2,64.53 143.07,64.66 143.07,64.98 143.62,65.52 143.62,66.52 143.95,66.85 144.63,66.85
+1.0V_PRIM on BOTTOM (solid shape): 141.23,88.35 141.23,86.39 140.76,85.91 137.6,85.91 137.56,85.95 137.56,88.28 137.76,88.47 141.11,88.47
+1.0V_PRIM on BOTTOM (solid shape): 177.93,85.74 177.93,82.25 177.42,82.25 177.42,81.55 177.93,81.55 177.93,81.05 177.42,81.05 177.42,80.35 177.93,80.35 177.93,78.74 176.88,77.69 165.15,77.69 162.06,80.79 162.06,85.24 164.22,87.39 176.28,87.39
+1.0V_PRIM on BOTTOM (solid shape): 126.7,84.47 126.77,84.44 126.8,84.36 127.15,83.98 127.51,84.36 127.54,84.44 127.61,84.47 128.91,84.47 129.8,83.58 132.47,83.58 133.02,83.03 134.17,83.03 134.24,82.96 134.24,81.79 134.19,81.74 133.29,81.74 133.14,81.59 133.14,81.28 132.72,80.85 131.77,80.85 131.51,81.11 131.11,81.11 131.01,81.21 131.01,81.74 130.88,81.87 129.76,81.87 128.86,82.76 128.2,82.76 128.02,82.58 128.02,79.9 127.64,79.52 126.37,79.52 126.11,79.78 126.11,81.3 126.17,81.35 126.17,84.37 126.27,84.47
+1.0V_PRIM on IN2 (solid shape): outline of 577 points within 122.64,48.56 125.4,55.49
+1.0V_PRIM on IN3 (solid shape): outline of 1209 points within 123.46,53.69 144.02,67.46
+1.0V_PRIM on VCC: 127.77,53.61 127.76,53.62 124.21,53.62 124.08,53.75 124.08,55.58 124.72,56.22 124.72,84.41 125.95,84.41 128.83,87.29 162.95,87.29 164.7,85.54 164.7,75.82 162.97,74.09 149.51,74.09 144.6,69.18 144.6,62.82 141.33,59.54 141.33,53.86 141.07,53.61 139.81,53.61 139.8,53.61 138.28,53.61 138.27,53.61 134.08,53.61
+1.0V_PRIM_CORE on TOP (solid shape): 134.05,103.26 134.05,102.72 134.6,102.72 134.61,102.73 134.61,103.26 135.64,103.26 136.26,102.64 136.26,102.03 135.64,101.4 133.06,101.4 132.6,101.86 132.6,102.96 132.9,103.26 133.24,103.26 133.25,103.25 133.25,102.72 133.26,102.71 133.8,102.71 133.8,102.72 133.8,103.26 134.04,103.26
+1.0V_PRIM_CORE on IN1 (solid shape): outline of 1371 points within 124.57,52.76 152.15,61.4
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 1233 points within 124.57,50.97 152.15,60.72
+1.0V_PRIM_CORE on IN4 (solid shape): outline of 1273 points within 133.08,52.56 151.82,103.35
+1.0V_PRIM_COREP on TOP (solid shape): 133.2,109.38 133.2,108.5 133.73,107.97 133.73,106.52 133.58,106.37 133.58,106.37 133.33,106.11 133.33,105.75 133.32,105.74 133.25,105.4 133.32,105.06 133.33,105.05 133.33,104.95 133.75,104.53 134.75,104.53 134.96,104.33 134.96,103.44 134.93,103.42 134.41,103.42 134.4,103.41 134.4,102.87 134.18,102.87 134.18,103.39 134.16,103.39 134.16,103.41 132.45,103.41 132.06,103.8 132.06,105.07 131.39,105.75 131.29,105.75 131.29,105.75 130.99,105.75 130.97,105.76 129.69,105.76 129.57,105.89 129.57,106.72 130.84,107.99 130.84,109.2 131.25,109.6 132.98,109.6
+1.0V_PRIM_XDP on IN3 (solid shape): outline of 980 points within 59.56,27.53 76.41,42.51
+1.0V_SRAM on TOP (solid shape): 125.98,58.2 125.98,56.99 125.88,56.89 125.6,56.89 125.26,57.24 125.26,58.44 125.28,58.46 125.72,58.46
+1.0V_SRAM on TOP (solid shape): 119,79.01 121.73,76.28 121.73,72.87 121.83,72.77 121.83,72.75 121.93,72.57 122.11,72.48 122.12,72.47 122.21,72.39 122.21,71.9 122.13,71.81 122.03,71.81 122.01,71.82 121.79,71.9 121.56,71.81 121.02,71.81 120.25,72.58 120.25,75.94 117.51,78.67 117.51,80.32 117.73,80.54 119,80.54
+1.0V_SRAM on IN4 (solid shape): outline of 1017 points within 120.34,56.2 126.89,73.31
+1.0V_VCCST on BOTTOM (solid shape): 123.4,83.96 124.05,83.32 124.05,83.01 124.04,83 123.49,83 123.47,82.98 123.47,82.54 123.5,82.52 124.03,82.52 124.05,82.5 124.05,82.2 123.94,82.1 123.13,82.1 123.05,82.13 123.03,82.22 122.87,82.59 122.46,82.57 122.05,82.98 122.05,83.71 122.31,83.97 122.53,83.97
+1.0V_VCCST on IN1 (solid shape): 98.3,80.79 99.64,80.79 101.86,78.57 101.86,77.11 101.73,76.98 101.02,76.98 100.94,77.02 100.92,77.12 100.59,77.59 100.25,77.12 100.24,77.02 100.16,76.98 97.86,76.98 97.29,77.55 97.29,80.66 97.54,80.92 98.18,80.92
+1.0V_VCCST on IN2 (solid shape): outline of 377 points within 123.35,63.49 127.26,70.43
+1.0V_VCCST on IN3 (solid shape): 272.98,49.05 273.05,48.95 273.15,48.87 273.2,48.82 273.2,48.75 273.34,48.34 273.77,48.36 273.83,48.38 273.89,48.36 274.42,48.44 274.28,48.95 274.25,48.99 274.26,49.03 274.29,49.09 275.03,49.09 275.15,48.96 275.15,48.05 274.95,47.85 272.54,47.85 272.42,47.97 272.42,48.82 272.69,49.09 272.97,49.09
+1.0V_VCCST on IN3 (solid shape): outline of 371 points within 97.07,79.51 123.32,83.91
+1.0V_VCCST on IN3 (solid shape): outline of 448 points within 277.51,55.6 282.05,74.99
+1.0V_VCCST_C on BOTTOM (solid shape): 126.02,84.44 126.02,84.41 126.01,84.33 126.03,84.23 126.03,82.4 125.86,82.23 125.11,82.23 124.84,82.36 124.57,82.23 124.21,82.23 124.19,82.26 124.19,82.62 124.15,82.65 123.64,82.65 123.61,82.69 123.61,82.83 123.64,82.86 124.15,82.86 124.17,82.89 124.17,82.95 124.18,82.95 124.18,83.37 124.17,83.38 124.08,83.47 124.08,84.47 124.34,84.73 125.74,84.73
+1.0V_VCCSTG on TOP (solid shape): 144.73,89.35 144.73,88.61 144.48,88.36 142.83,88.36 142.47,88.71 142.47,89.5 142.65,89.68 144.4,89.68
+1.0V_VCCSTG on TOP (solid shape): 114.25,80.74 114.81,80.18 114.81,79.65 114.46,79.29 112.86,79.29 112.6,79.55 112.6,80.61 113.52,81.53 114.23,81.53 114.25,81.55
+1.0V_VCCSTG on TOP (solid shape): 124.95,70.34 124.95,69.3 124.83,69.17 121.57,69.17 121.32,69.41 121.32,70.23 121.53,70.44 123.62,70.44 123.63,70.41 123.94,70.22 124.23,70.42 124.25,70.45 124.84,70.45
+1.0V_VCCSTG on BOTTOM (solid shape): 144.3,90.29 144.3,89.58 144.96,88.92 144.96,87.98 144.86,87.88 144.56,87.88 144.51,87.93 144.51,88.38 144.5,88.4 144.5,88.42 144.47,88.42 144.45,88.44 144.12,88.44 144.11,88.42 144.06,88.42 144.06,87.89 144.05,87.88 143.21,87.88 142.73,88.36 142.73,90.24 143.01,90.52 144.07,90.52
+1.0V_VCCSTG on IN3 (solid shape): outline of 205 points within 101.73,79.52 114.33,80.85
+1.0V_VCCSTG on TOP: 120.96,64.73 121.91,64.73 121.95,64.69 122.67,64.69 122.74,64.77 122.74,65.49 122.62,65.61 121.98,65.61 121.98,65.61 121.41,65.61 121.34,65.68 120.96,65.68 120.95,65.67 120.95,64.74
+1.0V_VCCSTG_C on BOTTOM (solid shape): 144.38,88.28 144.38,87.87 144.38,87.78 144.4,87.75 144.66,87.75 144.81,87.6 144.81,87.32 144.81,87.32 144.78,87.19 144.81,87.07 144.81,87.06 144.81,86.53 144.73,86.45 143.44,86.45 143.31,86.58 143.31,87.55 143.51,87.75 144.1,87.75 144.11,87.76 144.16,87.76 144.16,87.81 144.2,87.85 144.2,88.31 144.35,88.31
+1.0V_VCCSTG_R on TOP (solid shape): outline of 303 points within 123.23,64.53 126.34,67.92
+1.0VS_VCCIO on TOP (solid shape): outline of 138 points within 118.03,52.79 122.15,56.08
+1.0VS_VCCIO on TOP (solid shape): outline of 1011 points within 141.97,12.8 204.03,102.72
+1.0VS_VCCIO on BOTTOM (solid shape): 121.25,54.77 121.24,54.74 121.22,54.59 121.26,54.45 121.26,54.44 121.26,53.31 121,53.04 120.99,53.04 120.91,52.98 120.85,52.9 120.85,52.89 120.78,52.82 120.48,52.82 120.42,52.88 120.41,52.89 120.16,53.06 119.93,52.86 119.92,52.82 119.64,52.82 119.49,52.98 119.49,53.23 119.99,53.74 119.99,54.44 120.04,54.58 120.03,54.72 120.02,54.75 120.15,54.88 121.14,54.88
+1.0VS_VCCIO on IN3 (solid shape): outline of 134 points within 279.33,55.74 282.02,58.04
+1.0VS_VCCIO on IN3 (solid shape): outline of 1324 points within 168.6,8.52 203.92,20.91
+1.0VS_VCCIO on IN3 (solid shape): outline of 6528 points within 106.43,30.31 124.33,54.92
+1.2V_DDR_B+ on TOP (solid shape): 42.01,48.06 44.24,48.06 44.83,47.47 44.83,45.91 43.01,44.09 41.38,44.09 41.38,44.09 40.77,44.09 40.77,44.4 41.34,44.4 41.34,45.8 40.77,45.8 40.77,47.96 40.96,48.15 41.91,48.15
+1.2V_DDR_B+ on BOTTOM (solid shape): 41.72,48.09 46.28,48.09 46.36,48.02 46.36,47.58 46.32,47.54 44.67,47.54 44.52,47.39 44.52,46.75 44.33,46.56 41.34,46.56 40.96,46.94 40.96,48.09 41.03,48.15 41.66,48.15
+1.2V_DDRP on TOP (solid shape): 57.18,44.85 57.18,41 56.66,40.48 53.22,40.48 51.93,39.2 46.87,39.2 46.87,39.2 46.61,39.2 46.04,39.77 46.04,41.74 46.65,42.35 48.8,42.35 51.45,45 57.03,45
+1.2V_DDRP on BOTTOM (solid shape): 49,51.59 49,50.31 48.1,49.41 47.46,49.41 47.4,49.47 47.4,50.21 47.91,50.71 47.91,51.68 48.81,51.79
+1.2V_DDRP on BOTTOM (solid shape): 57.18,45.33 57.18,41.15 56.95,40.93 48.56,40.93 48.27,41.22 48.27,42.12 48.39,42.25 49.54,42.25 50.21,42.92 50.21,44.97 50.68,45.44 57.08,45.44
+1.2V_LDO on TOP (solid shape): 25.74,54.93 25.43,54.63 25.43,53.99 24.97,53.54 24.97,52.98 25.3,52.65 25.3,51.71 25.25,51.66 25.13,51.66 25.07,51.71 25.07,52.49 24.54,53.03 24.54,53.87 24.74,54.07 24.74,55.67 24.85,55.77 25.74,55.77
+1.2V_LDO on TOP (solid shape): 29.01,54.15 29.01,53.66 28.4,53.05 27.46,53.05 27.39,52.98 27.38,52.98 26.95,52.55 26.95,52.54 26.9,52.49 26.9,52.47 26.9,51.7 26.85,51.65 26.75,51.65 26.68,51.72 26.68,52.61 27.56,53.5 27.96,53.5 28.43,53.97 28.43,54.15 28.5,54.22 28.93,54.22
+1.2V_MEM on TOP (solid shape): outline of 25213 points within 41.08,2.36 185.19,52.02
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 309.95,75.2 312.62,75.2 312.81,75.01 312.81,74.19 309.5,74.19 309.5,74.82 308.68,75.65 308.17,75.65 307.79,75.27 307.41,75.27 307.41,75.52 308.04,76.15 309,76.15
+1.8V_PRIM on TOP (solid shape): 309.76,73.42 310.27,73.42 310.27,74 310.96,74 311.16,73.81 311.16,72.98 310.71,72.54 310.71,72.09 310.14,72.09 309.5,72.73 309.5,74 309.76,74
+1.8V_PRIM on TOP (solid shape): 120.52,101.71 120.52,101.15 120.91,101.15 120.91,101.15 121.52,101.15 121.63,101.04 122.85,101.04 123,100.89 123,100.33 122.84,100.17 120.05,100.17 119.89,100.32 119.89,100.72 119.89,100.72 119.89,101.09 119.96,101.16 120.34,101.16 120.34,101.71 120.34,101.71 120.51,101.71
+1.8V_PRIM on TOP (solid shape): 272.98,52.7 272.98,52.33 272.82,52.06 272.94,51.77 272.98,51.7 272.95,51.62 272.78,51.45 271.15,51.45 270.99,51.61 270.99,52.69 271.15,52.85 272.83,52.85
+1.8V_PRIM on BOTTOM (solid shape): 263.76,27.02 263.76,26.36 263.17,25.77 262.84,25.77 262.51,26.1 262.51,27.35 263.43,27.35
+1.8V_PRIM on BOTTOM (solid shape): 164.61,54.22 164.61,53.45 164.24,53.08 162.74,53.08 162.48,53.34 162.48,54.02 162.83,54.37 164.45,54.37
+1.8V_PRIM on BOTTOM (solid shape): 176.48,55.67 176.48,54.68 176.2,54.4 174.98,54.4 174.67,54.71 174.67,55.9 174.8,56.03 176.12,56.03
+1.8V_PRIM on BOTTOM (solid shape): 255.68,39.49 255.68,37.74 254.74,37.74 254.4,38.07 254.4,38.3 254.6,38.62 254.4,38.93 254.4,39.15 254.94,39.68 255.49,39.68
+1.8V_PRIM on IN2 (solid shape): 176.98,55.97 176.98,54.57 176.78,54.37 175.46,54.37 175.06,54.76 175.06,55.94 175.33,56.21 176.75,56.21
+1.8V_PRIM on IN3 (solid shape): 180.35,31.78 180.35,31.79 180.35,31.82 180.37,31.85 180.39,31.86 180.42,31.88 180.45,31.88 180.48,31.87 180.51,31.86 180.52,31.85 182.5,29.86 185.17,29.86 185.81,29.23 185.81,28.59 184.92,27.7 182.19,27.7 180.88,29.01 183.11,29.01 183.11,28.96 183.12,28.9 183.13,28.85 183.16,28.81 183.19,28.76 183.22,28.72 183.27,28.69 183.31,28.66 183.36,28.64 183.41,28.63 183.47,28.63 183.52,28.63 183.57,28.64 183.62,28.66 183.67,28.69 183.71,28.72 183.75,28.76 183.78,28.81 183.8,28.85 183.81,28.9 183.82,28.96 183.82,29.01 183.81,29.06 183.8,29.11 183.78,29.16 183.75,29.21 183.71,29.25 183.67,29.28 183.62,29.31 183.57,29.32 183.52,29.34 183.47,29.34 183.41,29.34 183.36,29.32 183.31,29.31 183.27,29.28 183.22,29.25 183.19,29.21 183.16,29.16 183.13,29.11 183.12,29.06 183.11,29.01 180.88,29.01 180.35,29.55
+1.8V_PRIM on IN3 (solid shape): outline of 175 points within 161.37,49.81 165.28,54.24
+1.8V_PRIM on IN3 (solid shape): outline of 341 points within 138.65,54.55 158.45,60.62
+1.8V_PRIM on IN3 (solid shape): outline of 454 points within 253.06,38.41 273.15,52.23
+1.8V_PRIM on IN3 (solid shape): outline of 629 points within 213.26,11.07 228.48,14.3
+1.8V_PRIM on IN3 (solid shape): outline of 1617 points within 261.42,25.37 314.68,73.99
+1.8V_PRIM on TOP: 147.58,60.96 148.54,60.96 148.6,60.9 148.6,59.67 148.27,59.35 147.92,59.35 147.79,59.48 147.79,60.15 147.52,60.42 147.52,60.9
+1.8V_RUN on TOP (solid shape): 303.34,44.56 303.34,43.84 303.08,43.57 302.21,43.57 302.17,43.61 302.17,44.34 302.07,44.44 302.07,44.68 302.21,44.82 303.08,44.82
+1.8V_RUN on TOP (solid shape): outline of 305 points within 271.94,41.32 285.71,48.41
+1.8V_RUN on IN4 (solid shape): outline of 341 points within 284.34,41.33 303.98,46.69
+1.8V_RUN_AUDIO on TOP (solid shape): 303.09,38.38 303.09,37.48 303.03,37.42 302.26,37.42 302.03,37.65 302.03,38.26 302.14,38.37 302.58,38.37 302.69,38.49 302.99,38.49
+1.8V_RUN_AUDIO on TOP (solid shape): 303.09,43.26 303.09,42.18 303.03,42.18 303.03,42.18 302.2,42.18 301.88,41.86 301.88,41.09 301.77,40.98 301.72,40.83 301.72,40.81 301.63,40.72 301.63,39.83 301.25,39.45 301.22,39.41 301.19,39.36 300.79,38.96 300.79,38.93 300.74,38.88 300.74,38.87 300.71,38.84 300.71,37.97 300.66,37.93 300.55,37.93 300.49,37.99 300.49,38.82 300.55,38.88 300.55,39.17 301.12,39.74 301.12,42.55 301.96,43.39 302.96,43.39
+1.8V_RUN_AUDIO on IN1 (solid shape): outline of 135 points within 301.53,37.48 303.41,43.47
+1.8V_RUN_AUDIO on BOTTOM: 302.02,36.98 301.93,37.07 301.93,38.1 302.25,38.42 302.36,38.41 302.46,38.44 302.88,38.44 303.03,38.29 303.03,37.93 302.65,37.55 302.65,37.04 302.58,36.98
+1.8V_RUN_CARD on TOP (solid shape): 25.63,53.46 25.63,52.72 25.68,52.67 25.68,51.71 25.63,51.66 25.53,51.66 25.48,51.71 25.48,52.57 25.43,52.62 25.43,52.72 25.15,53 25.15,53.46 25.23,53.54 25.56,53.54
+1.8V_RUN_CARD on TOP (solid shape): 6.55,62.25 6.55,61.68 6.74,61.49 8.45,61.49 8.9,61.93 10.36,61.93 10.42,61.87 10.42,60.41 10.23,60.22 5.97,60.22 5.72,60.47 5.72,62.25 5.91,62.44 6.36,62.44
+1.8V_RUN_CARD on BOTTOM (solid shape): 6.48,62.22 6.48,60.41 5.72,60.41 5.72,62.25 5.87,62.4 6.3,62.4
+1.8V_RUN_CARD on IN4 (solid shape): 10.86,61.8 10.55,61.8 10.17,61.42 9.34,61.42 9.15,61.61 9.15,62.25 9.47,62.57 10.86,62.57
+1.8V_RUN_CARD on IN4 (solid shape): 25.66,54.3 25.66,53.05 25.56,52.95 25.25,52.95 25.15,53.05 25.15,53.43 24.82,53.76 24.82,54.42 24.97,54.58 25.38,54.58
+1.8V_RUN_UZ8 on TOP (solid shape): 272.21,49.63 272.75,49.63 272.75,48.88 272.39,48.52 272.39,48.43 272.37,48.41 272.37,47.89 272.35,47.87 271.91,47.87 271.9,47.86 271.84,47.86 271.84,47.82 271.83,47.79 271.81,47.77 271.81,47.51 271.83,47.49 271.84,47.46 271.84,47.43 271.9,47.43 271.91,47.41 272.35,47.41 272.39,47.37 272.39,46.87 272.18,46.65 271.45,46.65 270.95,47.16 270.95,50.18 270.99,50.22 271.62,50.22
+1.8VALWP on TOP (solid shape): 121.49,103.56 121.49,102.96 121.77,102.68 124.28,102.68 124.46,102.5 124.46,102.18 124.46,102.17 124.46,101.21 124.42,101.17 121.83,101.17 121.68,101.32 120.72,101.32 120.7,101.31 120.68,101.33 120.68,101.88 120.2,101.88 120.16,101.85 120.16,101.33 120.15,101.33 119.37,101.33 119.23,101.47 119.23,103.59 119.25,103.61 121.44,103.61
+1VALWP on TOP (solid shape): 183.77,83.58 183.77,80.66 183.58,80.47 181.78,80.47 181.67,80.59 181.67,83.41 182.1,83.84 183.52,83.84
+1VALWP on BOTTOM (solid shape): 184,86.28 184,78.38 183.82,78.2 178.36,78.2 178.1,78.46 178.1,80.47 178.06,80.47 177.55,80.47 177.55,80.92 178.06,80.92 178.06,80.93 178.09,80.93 178.09,81.7 177.55,81.7 177.55,82.12 178.1,82.12 178.1,86.25 178.97,87.11 183.16,87.11
+1VALWP_B+ on TOP (solid shape): 179.53,98.93 179.53,97.02 179.28,96.77 178.31,96.77 178.24,96.84 178.24,98.42 178.77,98.95 179.51,98.95
+1VALWP_B+ on BOTTOM (solid shape): 179.52,100.87 179.52,97.05 179.33,96.86 179.33,96.03 179.99,95.37 179.99,93.9 179.9,93.81 178.45,93.81 176.99,95.27 176.13,95.27 175.77,95.62 175.77,98.32 176.09,98.32 176.09,97.74 177.49,97.74 177.49,98.32 177.93,98.32 178.27,98.66 178.27,100.84 178.36,100.93 179.46,100.93
+1VS_VCCIOP on TOP (solid shape): 144.15,106.83 144.15,105.11 144.34,104.92 144.85,104.92 144.85,104.79 144.53,104.48 144.53,102.99 144.4,102.86 140.81,102.86 140.66,103.02 140.66,104.03 140.78,104.16 141.19,104.16 141.5,104.46 141.5,106.98 141.54,107.02 143.96,107.02
+2.5V_MEM on TOP (solid shape): 107.55,11.06 109.39,11.06 109.62,11.3 110.04,11.3 110.14,11.19 110.14,9.77 109.8,9.43 107.94,9.43 107.76,9.62 107.41,9.62 107.05,9.7 106.69,9.62 105.33,9.62 105.23,9.72 105.23,10.94 105.23,10.94 105.23,11.28 105.5,11.55 107.07,11.55
+2.5V_MEM on TOP (solid shape): 193.38,10.08 193.38,9.29 193.06,8.96 192.57,8.96 192.56,8.95 192.51,8.95 192.51,8.85 192.51,8.85 192.51,8.43 192.49,8.41 192.33,8.41 192.29,8.44 192.29,8.94 192.26,8.98 192.2,8.98 192.2,8.97 191.43,8.97 191.21,9.19 191.21,10.21 190.83,10.59 188.7,10.59 187.99,9.88 186.95,9.88 186.64,10.19 186.28,10.19 186.11,10.36 186.11,11.12 186.5,11.51 188.33,11.51 188.73,11.91 188.73,12.34 188.87,12.48 190.98,12.48
+2.5V_MEM on BOTTOM (solid shape): 107.19,12.66 107.19,9.84 107.07,9.71 105.58,9.71 105.38,9.9 105.38,11.38 105.39,11.38 105.39,11.93 105.14,12.18 105.14,13.76 105.21,13.84 106.02,13.84
+2.5V_MEM on BOTTOM (solid shape): 186.57,13.86 186.62,13.86 187.53,13.86 187.83,13.55 187.83,11.98 188.12,11.69 188.12,10.02 187.94,9.84 186.87,9.84 186.86,9.88 186.77,10.07 186.61,10.19 186.6,10.2 186.12,10.67 186.12,13.8 186.19,13.86
+2.5V_MEM on IN3 (solid shape): outline of 4431 points within 109.35,9.04 188.7,13.71
+2.5V_VIN on TOP (solid shape): 198.05,6.99 198.05,6.34 198.08,6.31 198.61,6.31 198.62,6.3 198.62,6.13 198.6,6.11 198.08,6.11 198.05,6.09 198.05,5.49 197.13,4.56 195.93,4.56 195.79,4.7 195.79,5.27 196.24,5.72 196.24,7.22 196.31,7.29 197.75,7.29
+3.3V_1.8V_ESPI on TOP (solid shape): 159.87,55.75 159.87,53.28 159.72,53.13 157.74,53.13 157.54,53.33 157.54,54.19 157.54,54.55 157.54,54.64 157.52,54.65 156.99,54.65 156.98,54.66 156.98,54.84 156.98,54.85 157.51,54.85 157.53,54.86 157.53,55.76 157.56,55.8 159.82,55.8
+3.3V_1.8V_PGPPA on TOP (solid shape): 157.38,55.39 157.38,55.01 157.36,54.98 156.88,54.98 156.86,54.97 156.85,54.97 156.85,54.54 156.86,54.54 156.88,54.53 157.38,54.53 157.41,54.5 157.41,54.25 155.88,52.72 153.95,52.72 153.75,52.93 153.75,53.74 154.31,54.3 154.31,55.31 154.41,55.41 155.91,55.41 156.01,55.52 157.26,55.52
+3.3V_1.8V_PGPPA on IN1 (solid shape): outline of 829 points within 129.49,48.57 142.4,54.5
+3.3V_1.8V_PGPPA on IN2 (solid shape): 154.87,53.3 154.87,52.9 154.02,52.04 154.02,51.47 146.08,51.47 143.5,48.89 141.61,48.89 141.36,49.14 141.36,50.21 141.66,50.5 141.74,50.5 142.15,50.5 144.44,52.79 144.53,52.79 144.75,52.82 144.95,52.92 148.63,52.92 148.88,52.82 149.13,52.91 149.14,52.92 149.25,52.92 149.26,52.91 149.51,52.8 149.77,52.91 149.78,52.92 149.89,52.92 150.15,52.8 150.41,52.91 150.43,52.92 150.49,52.92 150.5,52.91 150.75,52.81 151,52.91 151.01,52.92 151.07,52.92 151.09,52.91 151.35,52.8 151.6,52.92 151.72,52.92 152.1,52.54 153.3,52.54 154.17,53.42 154.76,53.42
+3.3V_1.8V_PGPPG on BOTTOM (solid shape): 150.74,58.06 150.74,56.51 150.52,56.29 150.26,56.29 150.04,56.07 149.51,56.07 149.4,56.18 149.4,56.48 150.11,57.19 150.11,57.96 150.27,58.11 150.7,58.11
+3.3V_1.8V_PGPPG on IN3 (solid shape): outline of 216 points within 129.34,55.2 136.87,57.38
+3.3V_ALW on TOP (solid shape): 145.75,113.02 146.21,113.02 146.33,112.9 146.33,112.21 146.16,112.03 144.94,112.03 144.94,113.45 145.32,113.45
+3.3V_ALW on TOP (solid shape): 178.59,35.84 178.59,35.63 177.76,34.8 177.63,34.8 177.55,34.88 177.55,35.97 177.64,36.06 178.36,36.06
+3.3V_ALW on TOP (solid shape): 203.41,10.5 203.41,9.17 203.29,9.05 202.32,9.05 202.15,8.87 202.15,8.38 202.05,8.28 201,8.28 200.75,8.54 200.75,10.55 200.98,10.79 203.12,10.79
