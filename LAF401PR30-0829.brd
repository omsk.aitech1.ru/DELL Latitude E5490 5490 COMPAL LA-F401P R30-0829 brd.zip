# Allegro board LAF401PR30-0829.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW on TOP (solid shape): 191.28,15.81 191.28,15.2 191.33,15.16 191.49,15.16 191.93,14.72 191.93,14.11 191.53,13.71 191.31,13.71 190.96,14.06 190,14.06 190,14.06 189.38,14.06 189.22,14.22 189.22,15.53 189.45,15.76 190.27,15.76 190.38,15.87 191.22,15.87
+3.3V_ALW on TOP (solid shape): 202.15,6.87 202.15,5.97 201.91,5.73 201.63,5.73 200.34,4.44 198.51,4.44 198.19,4.76 198.19,5.98 198.2,5.99 198.65,5.99 198.66,5.99 198.75,5.99 198.75,6.47 198.18,6.47 198.18,6.69 198.24,6.75 201.15,6.75 201.32,6.93 202.09,6.93
+3.3V_ALW on TOP (solid shape): 311.66,81.04 311.66,80.41 311.85,80.22 313.38,80.22 313.44,80.16 313.44,79.52 313.57,79.39 314.27,79.39 314.39,79.27 314.39,78.95 314.27,78.82 313,78.82 312.49,79.33 311.16,79.33 311.03,79.46 311.03,81.04 311.16,81.17 311.54,81.17
+3.3V_ALW on TOP (solid shape): 182.35,33.95 182.35,31.29 182.91,30.73 182.91,30.12 182.37,29.58 181.82,29.58 181.76,29.64 181.76,30.35 180.61,31.49 179.79,31.49 179.53,31.74 179.53,32.3 180.35,33.11 180.35,33.8 180.85,33.8 180.85,33.83 181.46,33.83 181.63,33.99 182.31,33.99
+3.3V_ALW on TOP (solid shape): 312.04,73.42 312.55,73.42 312.55,74 312.81,74 312.81,72.6 313,72.41 313.57,72.41 313.7,72.54 315.16,72.54 315.6,72.09 315.6,71.01 315.41,70.82 312.36,70.82 311.66,71.52 311.66,73.93 311.73,74 312.04,74
+3.3V_ALW on TOP (solid shape): 223.52,14.7 223.52,13.6 223.4,13.48 222.54,13.48 222.36,13.3 222.36,13.18 221.39,12.21 220,12.21 219.86,12.35 219.86,13.82 219.92,13.88 220.46,13.88 220.54,13.8 220.54,13.48 220.66,13.36 221.47,13.36 222.05,13.94 222.05,14.6 222.26,14.8 223.42,14.8
+3.3V_ALW on TOP (solid shape): 125.29,112.1 125.91,112.1 126.46,111.54 127.26,111.54 127.39,111.41 127.39,110.69 127.31,110.61 126.6,110.61 126.37,110.38 125.23,110.38 125.23,110.95 124.72,110.95 124.72,110.38 124.72,110.38 124.47,110.38 124.47,110.64 123.58,111.52 122.56,111.52 122.24,111.21 121.73,111.21 121.73,112.29 121.99,112.54 124.85,112.54
+3.3V_ALW on TOP (solid shape): 298.33,66.82 298.33,66.25 298.46,66.12 299.79,66.12 299.92,65.99 299.92,65.68 300.11,65.49 300.44,65.49 300.44,64.99 300.46,64.97 300.94,64.97 300.94,65.52 301.42,65.52 301.71,65.81 302.87,65.81 303.07,65.74 303.28,65.79 303.53,65.79 304.09,65.23 306.76,65.23 306.87,65.33 307.68,65.33 307.79,65.45 308.41,65.45 308.68,65.18 308.68,64.76 307.97,64.05 306.25,64.05 305.96,64.2 305.67,64.05 305.15,64.05 305,64.2 303.68,64.2 303.48,64.4 303.48,64.99 303.27,65.2 302.06,65.2 301.43,64.57 301.38,64.55 301.33,64.53 300.81,64.53 300.61,64.59 300.42,64.53 299.91,64.53 299.42,65.02 298.81,65.02 297.72,66.11 297.72,66.85 297.76,66.88 298.26,66.88
+3.3V_ALW on BOTTOM (solid shape): 273.38,50.06 273.82,49.63 273.91,49.63 273.93,49.62 274.18,49.62 274.25,49.55 275.05,49.55 275.28,49.32 275.28,48.81 275.28,48.81 275.28,48.64 275.06,48.42 274,48.42 274,48.42 273.66,48.42 273.65,48.44 273.1,48.44 272.78,48.76 272.78,49.87 273.02,50.11 273.38,50.11
+3.3V_ALW on BOTTOM (solid shape): 148.58,103.73 148.58,103.08 148.53,103.04 148.07,103.04 148.04,103.02 148.04,102.31 148.07,102.28 148.58,102.28 148.6,102.26 148.6,101.88 148.57,101.84 148.07,101.84 148.05,101.82 148.05,101.1 148.06,101.09 148.15,101.09 148.16,101.09 148.55,101.09 148.58,101.06 148.59,100.61 148.59,100.28 148.4,100.09 145.6,100.09 144.99,99.48 144.51,99.48 144.51,103.98 144.94,104.41 147.9,104.41
+3.3V_ALW on BOTTOM (solid shape): 274.43,52.96 274.54,52.91 274.67,52.9 274.69,52.9 274.88,52.71 274.89,52.71 275.06,52.55 275.06,51.99 275.21,51.83 275.21,50.95 275.09,50.82 274.45,50.82 273.6,51.67 273.58,51.67 273.5,51.75 273.5,51.88 273.5,51.89 273.53,51.98 273.53,52.07 273.53,52.1 273.75,52.32 273.89,52.32 273.95,52.37 273.95,52.61 274.3,52.97 274.41,52.97
+3.3V_ALW on BOTTOM (solid shape): outline of 109 points within 270.62,79.11 273.51,82.52
+3.3V_ALW on BOTTOM (solid shape): outline of 656 points within 189.3,3.35 200.54,15.61
+3.3V_ALW on BOTTOM (solid shape): outline of 1119 points within 216.71,7.95 225.18,29.95
+3.3V_ALW on IN1 (solid shape): outline of 676 points within 298.84,82.92 309.45,91.01
+3.3V_ALW on IN2 (solid shape): outline of 1156 points within 144.61,95.94 184.17,115.98
+3.3V_ALW on IN3 (solid shape): outline of 5046 points within 19.82,27.58 148.52,104.16
+3.3V_ALW on IN4 (solid shape): outline of 682 points within 181.87,13.61 192.41,31.26
+3.3V_ALW on IN4 (solid shape): outline of 703 points within 307.58,63.42 318.58,71.84
+3.3V_ALW on IN4 (solid shape): outline of 1262 points within 197.79,2.25 222.38,13.42
+3.3V_ALW on VCC: outline of 86 points within 123.37,26.31 320.62,119.53
+3.3V_ALW2 on IN4 (solid shape): 276.2,46.15 276.2,45.95 275.21,44.95 274.78,44.95 274.76,44.94 274.11,44.29 273.75,44.29 273.59,44.46 273.59,44.87 274.25,45.53 274.25,45.66 274.36,45.78 274.63,45.78 274.63,45.72 274.64,45.67 274.65,45.62 274.68,45.57 274.71,45.53 274.74,45.49 274.78,45.45 274.83,45.43 274.88,45.41 274.93,45.4 274.99,45.39 275.04,45.4 275.09,45.41 275.14,45.43 275.19,45.45 275.23,45.49 275.26,45.53 275.29,45.57 275.32,45.62 275.33,45.67 275.34,45.72 275.34,45.78 275.33,45.83 275.32,45.88 275.29,45.93 275.26,45.97 275.23,46.01 275.19,46.04 275.14,46.07 275.09,46.09 275.04,46.1 274.99,46.11 274.93,46.1 274.88,46.09 274.83,46.07 274.78,46.04 274.74,46.01 274.71,45.97 274.68,45.93 274.65,45.88 274.64,45.83 274.63,45.78 274.36,45.78 274.58,45.99 274.58,46.21 274.92,46.55 275.16,46.55 275.32,46.71 275.64,46.71
+3.3V_ALW_DSW on TOP (solid shape): outline of 555 points within 127.09,42.56 136.47,54.84
+3.3V_ALW_DSW on IN4 (solid shape): 128.05,57.31 128.05,57.23 128.23,56.86 128.63,56.94 128.7,56.97 128.78,56.94 128.82,56.89 128.87,56.86 128.9,56.85 128.9,55.78 128.87,55.77 128.82,55.73 128.78,55.69 128.7,55.66 128.63,55.69 128.05,55.48 128.63,55.26 128.7,55.29 128.78,55.26 128.82,55.22 128.87,55.18 128.9,55.17 128.9,55.06 128.23,54.39 127.56,54.39 127.43,54.51 127.43,57.15 127.72,57.44 127.93,57.44
+3.3V_ALW_PCH on TOP (solid shape): 207.4,9.85 207.4,8.88 207.29,8.78 206.35,8.78 206.31,8.83 206.31,9.3 206.3,9.3 206.3,9.92 206.38,10 207.24,10
+3.3V_ALW_PCH on TOP (solid shape): outline of 500 points within 127.72,53.48 147.6,57.83
+3.3V_ALW_PCH on BOTTOM (solid shape): 137.93,78.38 137.93,77.3 137.8,77.17 136.28,77.17 136.15,77.3 136.15,78.38 136.21,78.44 137.86,78.44
+3.3V_ALW_PCH on IN1 (solid shape): outline of 866 points within 146.82,51.78 156.72,64.57
+3.3V_ALW_PCH on IN2 (solid shape): 303.09,65.73 303.16,65.74 303.86,65.74 304.6,65 304.6,63.55 304.36,63.3 304.32,63.33 303.91,63.33 303.77,62.93 303.8,62.87 303.81,62.83 303.81,62.79 303.8,62.76 303.78,62.75 303.62,62.44 303.79,62.14 303.8,62.14 303.84,62.1 303.75,62.01 303.13,62.01 302.97,62.17 302.97,63.44 303.44,63.92 303.44,64.3 303.48,64.34 303.48,65.04 303.36,65.17 303.06,65.17 302.64,65.17 302.63,65.18 302.39,65.18 302.35,65.18 302.31,65.17 302.11,65.17 302.1,65.16 301.94,64.98 301.93,64.73 301.93,64.72 301.93,64.06 301.85,63.98 300.41,63.98 300.32,64.07 300.32,65.41 300.65,65.74 303.03,65.74
+3.3V_ALW_PCH on IN3 (solid shape): outline of 210 points within 196.89,8.72 207.31,16.13
+3.3V_ALW_PCH on IN3 (solid shape): outline of 448 points within 272.64,49.72 277.1,60.2
+3.3V_ALW_PCH on IN3 (solid shape): outline of 532 points within 136.25,63.95 154.82,78.15
+3.3V_ALW_PCH on IN3 (solid shape): outline of 2046 points within 124.75,31.57 154.62,55.95
+3.3V_ALW_PCH on IN4 (solid shape): outline of 260 points within 124.7,54.41 127.86,59.85
+3.3V_ALW_PCH on IN4 (solid shape): outline of 303 points within 299.04,49.29 306.9,54.4
+3.3V_ALW_PCH on TOP: 126.11,33.14 127,33.14 127.06,33.09 128.06,33.09 128.1,33.13 128.1,33.64 127.97,33.76 126.09,33.76 126.06,33.74 126.06,33.19
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 206.25,10.18 206.15,10.08 206.15,9.7 205.57,9.7 205.57,9.14 206.15,9.14 206.15,8.73 206.37,8.51 206.37,7.5 206.28,7.41 205.75,7.41 205.5,7.66 205.35,7.66 204.8,8.21 204.56,8.21 204.4,8.37 203.61,8.37 203.61,8.37 203.47,8.37 203.36,8.48 203.36,8.9 203.79,9.33 204.12,9.33 204.2,9.4 204.2,9.48 204.2,9.48 204.2,9.91 204.21,9.92 204.42,10.01 204.52,10.21 204.53,10.25 206.03,10.25 206.03,10.25 206.25,10.25
+3.3V_ALW_UE1 on TOP (solid shape): 290.52,76.54 290.76,76.45 291,76.54 291.35,76.54 291.51,76.37 291.51,75.73 291.29,75.51 290.23,75.51 290.17,75.57 290.17,76.5 290.21,76.54
+3.3V_ALW_UE1 on TOP (solid shape): 301.21,67.8 301.21,67.6 301.08,67.29 301.21,66.99 301.39,66.81 301.39,65.8 301.29,65.7 300.21,65.7 300.21,66.13 300.57,66.5 300.57,67.87 300.63,67.93 301.08,67.93
+3.3V_ALW_UE1 on VCC: 307.89,74.92 291.51,74.95 291.51,79.54 293.74,81.77 306.3,81.77 307.89,80.18 ; 1 cut-out
+3.3V_ALW_UZ12 on TOP (solid shape): 177.37,35.96 177.37,35.61 176.84,35.61 176.84,35.17 177.37,35.17 177.37,35.04 177.35,35.02 177.35,34.61 177.13,34.39 175.74,34.39 175.29,34.84 175.29,35.65 175.85,36.21 177.12,36.21
+3.3V_ALW_UZ12 on TOP (solid shape): 171.2,35.57 171.2,33.01 170.49,32.3 169.88,32.3 169.87,32.31 169.87,33.36 169.93,33.42 169.93,35.39 169.8,35.51 169.26,35.51 169.17,35.6 169.17,35.71 169.27,35.81 170.97,35.81
+3.3V_ALW_UZ12 on IN2 (solid shape): 176.57,35.18 176.57,34.33 176.27,34.03 172.34,34.03 171.58,33.27 170.77,33.27 170.39,33.65 170.39,35.12 171.05,35.78 175.98,35.78
+3.3V_ALWP on TOP (solid shape): 150.25,107.08 150.25,105.17 150.37,105.05 154.59,105.05 154.74,104.89 154.74,103.85 154.54,103.65 149.74,103.65 147.63,105.76 147.63,107.18 147.78,107.33 149.99,107.33
+3.3V_ALWP on BOTTOM (solid shape): outline of 82 points within 148.18,98.77 159.97,107.33
+3.3V_CPS on IN4 (solid shape): outline of 374 points within 18.6,90.25 24.33,98.95
+3.3V_EC_PLL on TOP (solid shape): 299.75,72.03 299.75,71.24 299.47,70.96 299.47,70.15 299.78,69.84 299.78,69.1 300.05,68.83 300.05,68.52 300.23,68.34 300.23,67.33 300.17,67.26 299.53,67.26 299.34,67.46 299.34,67.84 299.04,68.14 299.04,69.16 299.06,69.18 299.06,70.02 299.06,71.16 299.39,71.49 299.39,72 299.5,72.1 299.67,72.1
+3.3V_HDD on BOTTOM (solid shape): 274.08,40.08 274.08,39.62 274.09,39.61 274.09,39.57 274.6,39.57 274.6,40.1 274.61,40.11 275.46,40.11 275.63,39.95 275.63,38.62 275.74,38.51 275.7,38.47 275.62,38.08 275.95,37.86 276.02,37.83 276.05,37.76 276.05,37.23 276.18,37.1 276.74,37.1 276.84,37 276.84,36.44 276.69,36.29 276.69,36.25 276.66,36.23 276.66,35.49 276.64,35.46 276.64,34.01 276.4,33.77 275.99,33.77 275.67,34.09 275.67,35.56 275.53,35.7 275.5,35.77 275.53,35.85 275.54,36.36 275.03,36.35 274.99,36.34 274.95,36.36 274.92,36.39 274.92,37.65 274.82,37.76 274.82,37.89 274.69,37.89 274.2,38.37 273.84,38.37 273.59,38.63 273.59,38.75 273.07,39.27 272.95,39.27 272.82,39.4 272.82,40.05 272.87,40.11 273.28,40.11 273.29,40.1 273.29,39.56 273.3,39.56 273.79,39.56 273.82,39.58 273.82,40.09 273.85,40.12 274.04,40.12
+3.3V_HDD on VCC: 273.52,38.14 273.33,38.32 273.33,43.62 276.91,47.19 276.91,50.01 276.86,50.06 276.86,54.7 278.14,55.98 278.14,61.64 275.47,64.32 275.47,64.99 279.92,69.43 282.8,69.43 282.8,54.35 280.37,51.91 280.37,46.3 278.48,44.41 278.05,44.41 276.34,42.71 276.34,38.5 275.99,38.14
+3.3V_HDD_M2 on TOP (solid shape): 294.33,28.02 294.33,25.47 294.15,25.29 293.5,25.29 293.49,25.3 292.93,25.3 292.72,25.51 292.72,26.09 293.16,26.54 293.38,26.54 293.69,26.85 293.69,28.02 293.82,28.15 294.2,28.15
+3.3V_HDD_M2 on TOP (solid shape): 291.79,30.24 291.79,27.79 291.79,27.58 291.49,27.25 291.47,27.19 291.46,27.15 291.45,27.07 290.21,27.07 289.88,27.4 289.88,28.76 290.72,29.6 290.72,30.5 291.53,30.5
+3.3V_HDD_M2 on TOP (solid shape): 306.46,28.02 306.46,27.33 306.46,27.01 306.68,26.78 306.68,26.76 306.96,26.48 306.96,24.02 306.58,23.64 303.84,23.64 303.54,23.94 303.54,25.22 305.75,25.22 305.75,25.17 305.76,25.12 305.77,25.07 305.8,25.02 305.83,24.97 305.86,24.93 305.91,24.9 305.95,24.87 306,24.86 306.05,24.84 306.11,24.84 306.16,24.84 306.21,24.86 306.26,24.87 306.31,24.9 306.35,24.93 306.39,24.97 306.42,25.02 306.44,25.07 306.45,25.12 306.46,25.17 306.46,25.22 306.45,25.28 306.44,25.33 306.42,25.37 306.39,25.42 306.35,25.46 306.31,25.49 306.26,25.52 306.21,25.54 306.16,25.55 306.11,25.55 306.05,25.55 306,25.54 305.95,25.52 305.91,25.49 305.86,25.46 305.83,25.42 305.8,25.37 305.77,25.33 305.76,25.28 305.75,25.22 303.54,25.22 303.54,26.31 304.3,27.07 304.3,27.77 304.36,27.83 304.74,27.83 304.74,27.46 304.74,27.46 304.74,27.26 304.81,27.2 305.69,27.2 305.76,27.26 305.76,28.02 305.82,28.09 306.39,28.09
+3.3V_HDD_M2 on BOTTOM (solid shape): 266.83,22.88 266.83,19.5 266.78,19.45 263.15,19.45 262.82,19.78 262.82,20.3 263.31,20.3 263.31,21 262.82,21 262.82,21.5 263.31,21.5 263.31,22.2 262.82,22.2 262.82,22.81 263.14,23.13 266.58,23.13
+3.3V_HDD_M2 on BOTTOM (solid shape): 291.85,28.91 291.85,27.7 291.65,27.5 291.23,27.5 291.05,27.32 291.03,27.32 290.84,27.13 290.84,27.11 290.77,27.04 290.77,26.37 290.79,26.25 290.84,26.14 290.84,25.67 290.64,25.48 289.63,25.48 289.37,25.74 289.37,27.7 289.76,28.09 289.76,29.16 289.95,29.36 291.41,29.36
+3.3V_HDD_M2 on BOTTOM (solid shape): 305.38,27.07 305.38,25.42 305.5,25.29 305.65,25.29 305.72,25.26 305.75,25.19 306.11,24.84 306.46,25.19 306.49,25.26 306.56,25.29 306.9,25.29 307.03,25.42 307.03,27.06 307.12,27.15 307.93,27.15 308.3,26.79 308.3,23.77 308.11,23.58 303.66,23.58 303.54,23.7 303.54,27.07 303.66,27.2 305.25,27.2
+3.3V_HDD_M2 on IN2 (solid shape): 292.48,29.01 292.48,25.26 293.08,24.66 299.15,24.66 300.11,25.61 305.5,25.61 305.76,25.35 305.75,25.23 305.75,25.16 305.76,25.13 305.76,23.89 305.44,23.58 291.2,23.58 290.13,24.64 290.13,27.1 291.53,27.1 291.53,27.04 291.54,26.99 291.55,26.94 291.58,26.89 291.61,26.85 291.64,26.81 291.68,26.77 291.73,26.75 291.78,26.73 291.83,26.72 291.89,26.71 291.94,26.72 291.99,26.73 292.04,26.75 292.09,26.77 292.13,26.81 292.16,26.85 292.19,26.89 292.22,26.94 292.23,26.99 292.24,27.04 292.24,27.1 292.23,27.15 292.22,27.2 292.19,27.25 292.16,27.29 292.13,27.33 292.09,27.36 292.04,27.39 291.99,27.41 291.94,27.42 291.89,27.43 291.83,27.42 291.78,27.41 291.73,27.39 291.68,27.36 291.64,27.33 291.61,27.29 291.58,27.25 291.55,27.2 291.54,27.15 291.53,27.1 290.13,27.1 290.13,28.59 290.37,28.83 290.85,28.83 291.21,29.18 292.24,29.18 292.27,29.22
+3.3V_HDD_M2 on IN4 (solid shape): outline of 340 points within 264.4,19.53 305.64,29.38
+3.3V_LAN on TOP (solid shape): 286.32,82.18 286.32,81.5 286.21,81.4 285.4,81.4 285.2,81.2 284.66,81.2 284.57,81.29 284.57,82.29 284.75,82.47 286.02,82.47
+3.3V_LAN on TOP (solid shape): 305.31,97.74 305.76,97.74 305.95,97.55 305.95,96.85 305.6,96.5 304.51,96.5 304.42,96.59 304.42,97.11 304.17,97.36 304.17,97.87 305.19,97.87
+3.3V_LAN on TOP (solid shape): 285.12,105.36 285.12,105.11 284.49,104.48 279.72,104.48 278.52,103.27 278.52,101.94 278.01,101.94 278.01,103.02 277.25,103.78 277.25,104.35 277.31,104.41 278.33,104.41 279.34,105.43 285.06,105.43
+3.3V_LAN on BOTTOM (solid shape): 280.27,53.42 280.27,52.96 280.26,52.89 280.27,52.83 280.27,52.11 280.12,51.96 279.84,51.96 279.84,51.98 279.61,52.19 279.31,52.15 279.25,52.15 279.07,52.32 279.07,52.91 278.52,52.91 278.52,53.09 279.07,53.09 279.07,53.5 279.1,53.52 280.17,53.52
+3.3V_LAN on IN1 (solid shape): outline of 85 points within 280.46,78.2 286.52,82.41
+3.3V_LAN on IN1 (solid shape): outline of 1680 points within 266.71,52.1 306.16,105.05
+3.3V_LAN on IN3 (solid shape): outline of 605 points within 276.12,81.32 286.83,104.41
+3.3V_LAN_OUT on TOP (solid shape): 282.35,85.16 282.43,85.14 282.51,85.14 283.25,84.4 283.98,84.4 284.42,83.96 284.42,82.64 283.89,82.11 283.89,81.26 283.86,81.23 283.18,81.23 283.15,81.26 283.15,81.96 282.94,82.17 282.94,83.63 282.64,83.93 282.65,83.96 282.55,84.29 282.22,84.39 282.19,84.38 282.1,84.47 280.7,84.47 280.62,84.55 280.62,85.03 280.75,85.16 282.34,85.16
+3.3V_LAN_OUT on IN1 (solid shape): outline of 367 points within 273.47,82.96 284.33,90.51
+3.3V_LAN_UZ2 on BOTTOM (solid shape): 278.92,53.49 278.92,53.26 278.36,53.26 278.36,52.75 278.92,52.75 278.92,52.21 277.96,51.25 277.53,50.83 276.59,50.83 276.42,50.99 276.42,51.56 276.41,51.56 276.41,52.87 276.41,52.87 276.41,53.25 276.71,53.55 278.86,53.55
+3.3V_MMI_AUX on TOP (solid shape): 26.32,45.84 26.32,45.76 26.45,45.76 26.57,45.64 28.22,45.64 28.4,45.46 28.4,44.77 28.28,44.65 26.42,44.65 25.38,45.69 21.41,45.69 21.41,45.8 20.52,45.8 20.52,45.8 20.48,45.75 20.43,45.76 20.2,45.99 20.2,46.37 20.45,46.63 22.89,46.63 23.11,46.53 23.34,46.59 23.38,46.6 23.41,46.58 23.8,46.33 24.24,46.47 24.63,46.47 25,46.84 25.32,46.84
+3.3V_MMI_IN on TOP (solid shape): 21.57,45 21.57,44.19 22.26,43.5 22.26,42.79 22.09,42.63 18.42,42.63 18.36,42.69 18.36,43.01 18.93,43.01 18.93,44.4 18.36,44.4 18.36,44.98 18.48,45.1 21.47,45.1
+3.3V_MMI_IN on TOP (solid shape): 28.17,55.03 28.17,54.73 28.07,54.63 27.87,54.63 27.83,54.59 27.79,54.59 27.79,54.55 27.74,54.5 27.74,53.8 27.56,53.63 27.51,53.63 26.55,52.67 26.55,52.61 26.49,52.55 26.49,51.71 26.42,51.64 26.36,51.64 26.28,51.72 26.28,52.72 26.41,52.85 26.41,53.76 26.28,53.89 26.28,54.45 26.55,54.72 26.96,54.72 27.11,54.87 27.11,55.06 27.21,55.16 28.05,55.16
+3.3V_MMI_IN on IN3 (solid shape): outline of 94 points within 20.33,43.56 28.33,55.95
+3.3V_PGPPB on TOP (solid shape): 129.03,56.82 129.13,56.84 129.56,56.84 129.57,56.83 129.67,56.82 129.76,56.83 129.77,56.84 130.07,56.84 130.26,56.65 130.26,56.18 130.36,56.18 130.51,56.03 130.51,55.38 130.11,55.38 130.04,55.41 130.01,55.48 129.66,55.81 129.35,55.45 129.35,55.43 129.13,55.21 128.94,55.21 128.72,55.44 128.72,55.46 128.71,55.55 128.69,55.62 128.69,56.8 128.72,56.84 128.92,56.84
+3.3V_PGPPC on TOP (solid shape): 128.63,58.94 128.63,58.74 128.87,58.5 128.87,57.56 128.85,57.54 128.46,57.54 128.41,57.59 128.41,58.48 128.17,58.72 128.17,58.92 128.31,59.06 128.52,59.06
+3.3V_PGPPC on IN3 (solid shape): outline of 99 points within 128,57.04 138.32,59.15
+3.3V_PGPPD on IN3 (solid shape): 137.8,59.2 137.8,58.54 137.29,58.04 135.45,58.04 135.37,58.07 135.34,58.14 135.13,58.44 134.77,58.36 134.7,58.33 134.63,58.36 134.33,58.47 134.08,58.28 134.07,58.28 134.03,58.23 133.86,58.38 133.72,58.41 133.59,58.38 133.48,58.3 133.4,58.27 133.33,58.3 133.09,58.41 132.84,58.3 132.77,58.27 132.7,58.3 132.45,58.41 132.21,58.3 132.13,58.27 132.06,58.3 131.82,58.41 131.57,58.3 131.5,58.27 131.43,58.3 131.18,58.41 130.94,58.3 130.68,58.04 130.1,58.04 129.42,58.72 129.42,58.96 129.52,59.06 130.22,59.06 130.24,59.03 130.26,58.98 130.28,58.94 130.52,58.74 130.83,58.83 130.89,58.86 130.96,58.83 131.2,58.75 131.42,58.86 131.5,58.9 131.58,58.87 131.87,58.77 132.12,58.95 132.15,58.95 132.18,58.94 132.44,58.8 132.71,58.93 132.77,58.95 132.83,58.93 133.09,58.78 133.36,58.9 133.4,58.92 133.43,58.91 133.46,58.89 133.49,58.87 133.77,58.78 134.01,58.95 134.06,58.95 134.11,58.92 134.3,58.82 134.5,58.85 134.56,58.87 134.65,58.93 134.69,58.95 134.73,58.92 134.99,58.75 135.27,58.88 135.59,58.88 136.15,59.44 137.56,59.44
+3.3V_PGPPE on TOP (solid shape): 134.68,59.47 134.78,59.41 134.76,59.3 135.01,58.75 135.27,59.3 135.25,59.41 135.34,59.47 137.12,59.47 137.17,59.41 137.17,59.08 136.49,58.4 136.47,58.4 136.12,58.05 135.45,58.05 135.38,58.07 135.34,58.14 135.13,58.44 134.77,58.36 134.7,58.33 134.63,58.36 134.53,58.44 134.42,58.47 134.4,58.47 134.1,58.78 134.1,59.21 134.35,59.47
+3.3V_PGPPE on IN3 (solid shape): 128.74,60.53 128.74,60.51 128.89,60.21 129.22,60.2 129.23,60.2 129.53,60.2 129.54,60.16 129.86,59.91 130.18,60.16 130.19,60.2 130.66,60.2 130.74,60.17 130.76,60.08 130.95,59.73 131.35,59.82 131.43,59.86 131.5,59.82 131.89,59.73 132.08,60.08 132.11,60.17 132.18,60.2 133.34,60.2 133.42,60.16 133.44,60.07 133.76,59.66 134.08,60.07 134.1,60.16 134.18,60.2 134.45,60.2 134.58,60.07 134.58,59.11 134.45,58.98 134.28,58.98 134.1,59.16 134.05,59.16 134.04,59.2 133.8,59.43 133.48,59.34 133.41,59.31 133.34,59.34 133.1,59.44 132.86,59.33 132.78,59.3 132.71,59.34 132.45,59.47 132.19,59.34 132.12,59.31 132.04,59.33 131.8,59.42 131.57,59.31 131.5,59.28 131.42,59.31 131.18,59.41 130.94,59.32 130.88,59.29 130.81,59.31 130.53,59.39 130.3,59.22 130.28,59.19 129.85,59.19 129.84,59.19 129.71,59.22 129.58,59.19 129.57,59.19 129.43,59.19 129.38,59.18 129.33,59.16 128.89,59.16 128.16,59.9 128.16,60.61 128.26,60.71 128.56,60.71
+3.3V_PGPPE on TOP: 127.25,58.35 127.63,58.35 127.66,58.37 127.66,58.59 128.55,59.48 128.55,60.28 128.63,60.36 128.63,60.6 128.52,60.7 128.3,60.7 128.06,60.47 128.06,59.57 127.81,59.32 127.25,59.32 127.23,59.29 127.23,58.38
+3.3V_RUN on TOP (solid shape): 18.17,44.85 18.17,42.69 18.1,42.63 16.77,42.63 16.58,42.82 16.58,44.79 16.77,44.98 18.04,44.98
+3.3V_RUN on TOP (solid shape): 108.03,93.44 107.88,93.29 107.16,93.29 106.88,93.01 106.03,93.01 105.87,93.16 105.87,93.52 105.77,93.62 105.77,93.69 105.85,93.77 106.79,93.77 106.96,93.59 107.42,93.59 107.68,93.85 108.03,93.85
+3.3V_RUN on TOP (solid shape): 107.07,99.4 107.44,99.4 107.57,99.26 107.57,99.23 107.58,99.19 107.58,98.92 108.02,98.48 108.02,97.93 107.89,97.8 107.43,97.8 106.78,97.15 105.81,97.15 105.74,97.21 105.74,97.34 106.19,97.79 106.19,99.58 106.26,99.65 106.81,99.65
+3.3V_RUN on TOP (solid shape): 294.54,58.69 294.54,58.34 294.87,58.01 295.48,58.01 295.81,58.34 296.12,58.34 296.22,58.23 296.22,57.93 296.12,57.83 295.86,57.83 295.41,57.37 295.41,56.96 294.92,56.96 294.92,57.4 294.62,57.7 294.24,57.7 294.01,57.93 294.01,58.72 294.52,58.72
+3.3V_RUN on TOP (solid shape): 273.82,77.51 273.87,77.46 274.27,77.46 274.3,77.49 274.3,78 274.35,78.05 274.55,78.05 274.6,78 274.6,76.98 274.33,76.7 274.33,75.13 274.25,75.05 273.83,75.05 273.79,75.01 273.59,75.01 273.59,74.81 273.48,74.69 272.55,74.69 272.53,74.68 272.4,74.82 272.39,74.83 272.34,74.92 272.27,74.99 272.27,75.64 272.27,75.65 272.29,75.77 272.27,75.9 272.27,75.9 272.27,77.31 273,78.05 273.82,78.05
+3.3V_RUN on TOP (solid shape): 201.6,3.99 201.6,3.57 201.62,3.55 201.62,3.46 201.68,3.46 201.7,3.45 201.72,3.45 202.24,3.45 202.3,3.45 202.31,3.46 202.33,3.48 202.33,3.54 202.33,3.54 202.33,3.99 202.35,4 202.78,4 202.81,3.97 202.81,3.47 202.84,3.44 202.92,3.44 203.43,3.44 203.5,3.44 203.54,3.48 203.54,3.55 203.54,3.55 203.54,3.97 203.56,3.98 204.08,3.98 204.37,3.69 204.37,1.62 204.23,1.48 200.91,1.48 200.75,1.64 200.75,3.35 200.79,3.39 200.82,3.44 200.86,3.63 200.8,3.81 200.77,3.85 200.93,4.01 201.58,4.01
+3.3V_RUN on TOP (solid shape): 218.49,17.55 219.29,17.55 220.06,16.78 221.39,16.78 221.49,16.68 221.49,16.12 221.36,15.99 220.63,15.99 220.49,15.84 220.49,15.58 220.42,15.51 219.98,15.51 219.97,15.51 219.86,15.62 219.86,16.1 219.67,16.29 218.99,16.29 218.98,16.28 218.88,16.28 218.67,16.07 218.67,14.18 218.26,13.77 218.26,12.84 218.09,12.67 217.04,12.67 217.03,12.67 216.9,12.67 216.72,12.85 216.72,12.92 216.75,12.99 216.82,13.02 217.18,13.38 216.82,13.73 216.75,13.76 216.72,13.84 216.72,15.74 216.98,16.01 216.98,17.15 216.77,17.37 216.77,17.92 216.86,18.01 217.18,18.01 217.19,17.99 217.19,17.47 217.22,17.44 217.64,17.44 217.66,17.47 217.66,18.01 217.68,18.03 218.01,18.03
+3.3V_RUN on BOTTOM (solid shape): 17.29,89.72 17.29,88.78 17.11,88.6 16.03,88.6 15.77,88.86 15.77,89.77 15.94,89.95 17.06,89.95
+3.3V_RUN on BOTTOM (solid shape): 148.85,71.14 148.85,69.51 148.63,69.28 146.94,69.28 146.79,69.44 146.79,70.99 146.88,71.07 147.57,71.07 147.86,71.37 148.62,71.37
+3.3V_RUN on BOTTOM (solid shape): 271.12,70.16 271.12,69.64 270.9,69.41 270.49,69.41 270.24,69.66 269.32,69.66 269.25,69.69 269.22,69.76 269.2,69.87 269.14,69.96 269.14,70.45 269.33,70.64 270.65,70.64
+3.3V_RUN on BOTTOM (solid shape): 262.66,22.93 262.66,22.1 262.69,22.1 262.69,22.08 263.17,22.08 263.17,21.63 262.69,21.63 262.69,21.6 262.66,21.6 262.66,20.9 262.69,20.9 262.69,20.88 263.17,20.88 263.17,20.43 262.69,20.43 262.69,20.4 262.66,20.4 262.66,19.82 262.6,19.77 262.6,19.56 262.49,19.45 259.97,19.45 259.44,19.98 259.44,22.88 259.69,23.13 262.46,23.13
+3.3V_RUN on BOTTOM (solid shape): 274.73,46.58 274.73,46.22 274.55,46.04 274.55,45.59 274.65,45.48 274.68,45.44 274.78,45.34 274.78,45.23 274.8,45.13 274.83,45.03 274.85,44.99 274.78,44.93 274.17,44.93 274.09,45.01 274.1,45.04 274.14,45.13 274.15,45.23 274.15,45.51 274.07,45.59 274.07,46.25 273.92,46.4 273.77,46.4 273.77,46.88 274.43,46.88
+3.3V_RUN on BOTTOM (solid shape): 274.39,43.88 274.39,42.76 274.68,42.46 274.68,42 274.68,41.97 275.95,40.7 275.95,40.67 275.98,40.67 276.07,40.58 276.49,40.58 276.66,40.41 276.66,39.87 276.76,39.77 276.76,39.26 276.59,39.08 276.13,39.08 275.88,39.33 275.88,39.88 275.51,40.25 274.51,40.25 274.48,40.22 274.48,40.16 274.46,40.14 274.46,39.7 274.22,39.7 274.21,39.7 274.21,40.13 274.2,40.14 274.2,40.22 274.19,40.24 274.11,40.24 274.1,40.25 273.8,40.25 273.78,40.24 273.71,40.24 273.68,40.21 273.68,39.69 273.67,39.68 273.43,39.68 273.42,39.7 273.42,40.15 273.41,40.16 273.41,40.23 273.4,40.24 272.83,40.24 272.55,40.53 272.55,40.53 271.85,41.23 270.13,41.23 270.13,41.74 272.1,41.74 272.36,41.74 272.55,41.93 272.55,42.75 272.72,42.93 272.73,42.93 273.64,43.83 273.98,43.83 274.12,43.97 274.3,43.97
+3.3V_RUN on BOTTOM (solid shape): outline of 1346 points within 275.04,52.27 299.93,61.05
+3.3V_RUN on IN1 (solid shape): outline of 134 points within 264.17,39.77 273.61,44.88
+3.3V_RUN on IN1 (solid shape): outline of 1014 points within 270.01,57.35 278.95,77.62
+3.3V_RUN on IN3 (solid shape): outline of 238 points within 169.8,33.86 226.6,63.9
+3.3V_RUN on IN3 (solid shape): outline of 1335 points within 135.64,25.86 175.2,41.63
+3.3V_RUN on IN4 (solid shape): 33.55,61.33 33.55,60.13 33.16,59.75 32.33,59.75 32.09,59.99 32.09,61.51 32.26,61.69 33.19,61.69
+3.3V_RUN on IN4 (solid shape): 16.29,89.81 16.29,87.78 16.16,87.65 15.07,87.65 14.95,87.76 14.95,89.65 15.3,90 16.1,90
+3.3V_RUN on VCC: 211.16,32.86 208.66,35.37 208.66,41.15 216.23,38.67 224.15,37.83 229.15,37.83 238.16,38.92 246.65,42.13 248.09,42.13 248.7,42.21 249.27,42.46 252.2,44.43 254.94,46.65 255.5,47.42 255.7,48.34 255.7,48.73 258.71,52.09 261.3,55.77 267.77,55.77 269.54,54 269.54,45.51 262.78,38.75 261.57,38.75 261.52,38.79 258.48,38.79 256.6,36.91 241.97,36.91 237.92,32.86
+3.3V_RUN on VCC: outline of 160 points within 16.58,1.27 302.01,102.21 ; 1 cut-out
+3.3V_RUN_AUDIO on TOP (solid shape): 295.43,41.15 295.43,40.59 295.33,40.49 294.26,40.49 294.06,40.7 294.06,41.19 294.1,41.23 295.36,41.23
+3.3V_RUN_AUDIO on TOP (solid shape): outline of 217 points within 270.26,70.12 274.63,78.89
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 293.69,41.18 293.69,40.77 294.28,40.19 294.28,39.69 294.28,39.68 294.28,39.05 294.41,38.78 294.71,38.7 294.77,38.7 294.83,38.72 294.88,38.68 294.9,38.63 294.96,38.56 295.66,38.56 296.42,37.8 296.93,37.8 296.99,37.74 296.99,37.47 296.93,37.41 296.17,37.41 295.52,38.05 294.92,38.05 294.84,38.14 294.47,38.14 293.78,38.83 293.78,38.99 293.76,39.01 293.76,39.19 293.65,39.29 293.57,39.31 293.48,39.31 293.45,39.31 293.25,39.52 293.25,39.9 293.28,39.93 293.28,40.56 293.13,40.71 293.13,40.74 293.12,40.87 293.06,40.98 293.06,41.22 293.65,41.22
+3.3V_RUN_AUDIO_IO on TOP (solid shape): 295.76,34.42 296.13,34.42 296.15,34.44 296.95,34.44 297,34.39 297,34.28 296.93,34.21 295.83,34.21 295.48,33.86 295.48,33.56 295.47,33.55 294.96,33.55 294.84,33.42 294.84,33.23 294.77,33.17 294.77,32.53 294.71,32.47 294.26,32.47 294.14,32.59 294.14,34.24 294.26,34.37 294.92,34.37 295.11,34.56 295.61,34.56
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 274.3,73.75 274.3,71.9 274.13,71.73 274.13,70.25 274.01,70.12 273.18,70.12 273.18,70.88 272.61,70.88 272.61,73.06 272.69,73.13 272.75,73.23 272.78,73.25 272.78,73.74 273.19,73.74 273.28,73.83 274.22,73.83
+3.3V_RUN_CARD on TOP (solid shape): 26.27,53.69 26.27,52.9 26.09,52.72 26.09,51.71 26.04,51.66 25.94,51.66 25.89,51.71 25.89,52.67 25.76,52.8 25.76,53.71 25.84,53.79 26.17,53.79
+3.3V_RUN_CARD on TOP (solid shape): 32.34,46.42 32.34,44.01 32.21,43.88 30.56,43.88 30.41,44.04 30.41,45.79 31.2,46.58 32.19,46.58
+3.3V_RUN_CARD on BOTTOM (solid shape): 33.2,44.98 33.2,44.42 33.08,44.29 31.76,44.29 31.35,43.88 30.59,43.88 30.46,44.01 30.46,44.87 30.69,45.1 33.08,45.1
+3.3V_RUN_CARD on IN1 (solid shape): 27.46,53.15 27.46,52.57 27.41,52.52 26.68,52.52 26.47,52.72 25.91,52.72 25.79,52.85 25.79,53.64 25.94,53.79 26.83,53.79
+3.3V_RUN_CARD on IN1 (solid shape): 33.13,46.86 32.29,46.02 31.2,46.02 31.06,46.16 31.06,46.46 31.76,47.16 31.76,47.36 32.11,47.72 32.11,47.92 33.13,47.92
+3.3V_RUN_DIMM2 on TOP (solid shape): 188.3,12.41 188.3,11.86 188.1,11.67 186.46,11.67 186.1,11.31 185.57,11.31 185.45,11.44 185.45,12.39 185.53,12.47 188.23,12.47
+3.3V_RUN_UT9 on BOTTOM (solid shape): 17.34,92.01 17.34,90.28 17.24,90.18 16.17,90.18 16.04,90.3 16.04,90.99 15.7,91.33 15.7,92.3 15.87,92.46 16.89,92.46
+3.3V_RUN_UT9 on BOTTOM (solid shape): 26.08,101.27 26.08,100.42 26.22,100.27 26.62,100.27 26.85,100.04 26.85,99.78 26.34,99.27 25.66,99.27 25.28,99.65 25.28,101.25 25.35,101.33 26.02,101.33
+3.3V_RUN_UT9 on IN4 (solid shape): outline of 322 points within 25.63,93.13 28.51,101.32
+3.3V_RUN_UZ3 on TOP (solid shape): 204.35,6.77 204.35,6.49 204.43,6.41 204.43,6.4 204.53,6.3 204.53,5.69 204.84,5.38 205.5,5.38 205.51,5.33 205.93,4.65 206.7,4.46 206.79,4.43 206.82,4.36 206.82,2.97 206.71,2.86 204.81,2.86 204.53,3.14 204.53,3.73 204.15,4.11 203.45,4.11 203.42,4.11 203.42,4.08 203.41,4.07 203.41,3.61 203.38,3.57 202.97,3.57 202.94,3.61 202.94,4.1 202.89,4.14 202.24,4.14 202.21,4.11 202.21,3.6 202.18,3.57 201.77,3.57 201.73,3.62 201.73,4.1 201.72,4.11 201.69,4.14 201.05,4.14 201.05,4.89 201.71,5.55 202.11,5.55 202.63,6.07 203.16,6.07 203.35,6.27 203.35,6.88 203.44,6.96 204.16,6.96
+3.3V_TBTA_FLASH on BOTTOM (solid shape): 33.47,100.33 33.47,99.55 33.59,99.44 34.71,99.44 34.97,99.18 34.97,96.1 34.73,95.87 33.67,95.87 32.14,97.4 32.14,100.42 32.26,100.54 33.27,100.54
+3.3V_TBTA_FLASH on IN4 (solid shape): outline of 445 points within 26.95,83.52 37.66,97.57
+3.3V_TP on TOP (solid shape): 215.65,19.69 215.65,19.19 215.8,19.05 215.88,19.05 215.88,19.04 216.01,19.04 216.06,18.99 216.59,18.99 216.64,19.04 216.64,19.09 216.67,19.12 217.78,19.12 217.96,18.93 217.96,18.18 217.94,18.15 217.56,18.15 217.53,18.13 217.53,17.6 217.52,17.59 217.34,17.59 217.33,17.6 217.33,18.14 217.32,18.15 215.45,18.15 215.45,18.15 215.22,18.15 215.17,18.2 213.97,18.2 213.69,18.48 212.7,18.48 212.63,18.56 212.63,18.74 212.71,18.82 213.68,18.82 213.87,19 214.43,19 214.7,19.27 214.7,19.5 214.89,19.7 215.64,19.7
+3.3V_TP on BOTTOM (solid shape): outline of 128 points within 214.12,18.49 218.23,23.92
+3.3V_VCCHDA on TOP (solid shape): 125.96,33 126.92,33 127.02,32.9 127.02,31.36 126.57,30.91 125.25,30.91 124.86,31.29 124.86,31.62 124.85,31.64 124.85,32.78 125.1,33.04 125.92,33.04
+3.3V_VCCHDA on IN3 (solid shape): outline of 969 points within 123.74,30.93 126.75,54.84
+3.3V_VDD_DCIN on BOTTOM (solid shape): 73.62,104.85 73.62,103.95 73.39,103.72 71.83,103.72 71.52,104.03 71.52,104.6 72.14,105.23 73.25,105.23
+3.3V_VDD_DCIN on IN4 (solid shape): outline of 483 points within 55.74,98.38 74.53,112.59
+3.3V_VDD_PIC on TOP (solid shape): 28.81,101.61 28.81,100.91 28.45,100.55 27.06,100.55 26.85,100.75 26.85,101.81 26.99,101.95 28.47,101.95
+3.3V_VDD_PIC on TOP (solid shape): 43.45,100.59 43.45,99.62 43.31,99.48 42.31,99.48 42.04,99.75 42.04,100.72 42.18,100.86 43.19,100.86
+3.3V_VDD_PIC on TOP (solid shape): 32.77,89.05 32.77,87.9 32.64,87.78 32.2,87.78 32.2,88.35 31.69,88.35 31.69,87.78 31.31,87.78 31.25,87.84 31.25,89.05 31.37,89.17 32.64,89.17
+3.3V_VDD_PIC on BOTTOM (solid shape): 28.12,101.66 28.12,100.54 28,100.41 26.79,100.41 26.77,100.43 26.77,101.74 26.97,101.94 27.84,101.94
+3.3V_VDD_PIC on BOTTOM (solid shape): 43.92,99.86 43.92,99.85 44.24,99.53 45.25,99.53 45.37,99.4 45.37,98.93 45.74,98.57 45.74,97.42 44.88,96.56 42.97,96.56 42.8,96.73 42.8,97.57 41.88,98.49 41.88,99.79 42.14,100.05 43.73,100.05
+3.3V_VDD_PIC on IN1 (solid shape): outline of 302 points within 40.92,87.17 44.79,100.58
+3.3V_VDD_PIC on IN3 (solid shape): 41.47,88.16 41.47,87.33 41.15,87.01 41.15,82.12 39.18,80.16 38.68,80.16 38.55,80.03 38.55,79.94 38.54,79.93 38.54,79.84 37.79,79.84 37.79,80.85 38.23,81.3 38.87,81.3 40.17,82.6 40.17,87.68 40.77,88.28 41.34,88.28
+3.3V_VDD_PIC on IN4 (solid shape): outline of 122 points within 31.56,80.16 41.92,90.76
+3.3V_VDD_PIC on IN4 (solid shape): outline of 304 points within 10.29,30.24 23.5,39.9
+3.3V_VDD_PIC on IN4 (solid shape): outline of 300 points within 42.1,99.54 68.26,106.38
+3.3V_VDD_PIC_PDA on TOP (solid shape): 32.58,87.52 32.58,86.95 32.39,86.76 31.56,86.76 31.18,86.38 31.18,85.36 31.12,85.3 30.68,85.3 30.68,87.01 31.25,87.58 32.52,87.58
+3.3V_WLAN on TOP (solid shape): 215.08,8.48 215.08,7.12 215.5,6.7 215.5,6 215.73,5.77 216.12,5.77 216.24,5.64 216.24,5.14 215.97,4.87 213.93,4.87 212.92,5.87 212.92,7.98 212.92,7.98 212.92,8.21 213.23,8.52 215.04,8.52
+3.3V_WLAN on TOP (solid shape): 195.35,12.29 195.35,11.18 195.25,11.11 195.19,11 195.18,10.99 194.93,10.73 194.93,9.62 194.67,9.37 194.19,9.37 193.82,9.74 193.82,9.85 192.16,11.51 192.16,12.29 192.38,12.51 192.74,12.51 192.77,12.49 192.77,12.06 192.77,11.96 192.87,11.96 193.2,11.96 193.25,11.96 193.26,11.97 193.28,11.97 193.28,12.03 193.3,12.06 193.3,12.51 193.53,12.51 193.55,12.49 193.55,12.08 193.55,12.01 193.57,11.99 193.57,11.97 193.59,11.97 193.6,11.96 193.99,11.96 194.04,11.96 194.05,11.97 194.08,11.97 194.08,12 194.09,12.01 194.09,12.49 194.11,12.51 194.9,12.51 195.13,12.51
+3.3V_WLAN on BOTTOM (solid shape): outline of 762 points within 205.11,5.32 216.08,31.39
+3.3V_WLAN on VCC: 211.6,5.76 208.55,8.8 194.52,8.8 193.48,9.85 193.48,11.74 197.25,15.51 197.65,15.51 198.58,14.58 215.46,14.58 215.68,14.36 215.68,11.81 217.05,10.44 217.05,6.96 215.85,5.76
+3.3V_WLAN_UZ4 on TOP (solid shape): 193.77,15.64 194.16,15.64 194.99,14.81 195.03,14.6 195.2,14.48 195.2,13 194.85,12.64 194.01,12.64 193.99,12.62 193.97,12.62 193.97,12.61 193.96,12.59 193.96,12.11 193.93,12.08 193.73,12.08 193.68,12.13 193.68,12.59 193.68,12.62 193.65,12.62 193.63,12.64 193.2,12.64 193.17,12.62 193.17,12.11 193.15,12.08 192.92,12.08 192.89,12.11 192.89,12.62 192.87,12.64 192.38,12.64 192.36,12.67 192.36,13.34 192.66,13.64 192.66,14.19 192.69,14.19 192.69,14.8 192.66,14.8 192.66,14.95 192.49,15.13 192.49,15.72 192.64,15.87 193.54,15.87
+3.3V_WWAN on TOP (solid shape): 305.39,48.96 305.39,47.97 305.17,47.73 305.03,47.43 304.93,47.33 304.93,46.75 304.87,46.69 303.41,46.69 303.34,46.75 303.34,47.82 303.36,47.89 303.36,47.94 303.36,47.99 303.34,48.01 303.28,48.11 303.18,48.17 303.17,48.18 302.81,48.53 302.81,49.12 302.9,49.21 305.15,49.21
+3.3V_WWAN on BOTTOM (solid shape): outline of 130 points within 303.89,45.81 310.84,50.21
+3.3V_WWAN on BOTTOM (solid shape): outline of 272 points within 279.79,44.73 287.74,50.6
+3.3V_WWAN on IN4 (solid shape): outline of 1144 points within 281.69,58.72 294.16,66.56
+3.3V_WWAN on VCC: 291.51,74.02 291.51,74.69 307.89,74.67 307.89,70.18 311.1,66.97 311.1,59.92 307.98,56.81 307.98,49.39 305.91,47.32 303.18,47.32 302.42,48.08 302.42,48.67 302.55,48.8 302.55,58.76 306.56,58.76 307.38,59.58 307.38,67.25 305.44,69.18 293.94,69.18 288.11,63.36 288.11,60.2 287.02,59.1 287.02,56.58 287.04,56.55 287.04,55.41 286.17,54.54 286.17,52.76 284.2,50.78 284.2,50.07 284.32,49.94 284.32,49.59 283.09,48.36 280.88,48.36 280.88,51.7 283.31,54.14 283.31,69.43 286.92,69.43 ; 2 cut-outs
+3.3V_WWAN_UZ2 on BOTTOM (solid shape): outline of 137 points within 276.47,44.72 280.19,49.55
+5V_ALW on TOP (solid shape): 306.3,60.87 306.6,60.57 306.6,60.31 306.74,60.18 307.49,60.18 307.65,60.02 307.65,59.06 307.13,58.54 307.02,58.54 306.91,58.42 305.18,58.42 305.12,58.48 305.12,60.67 305.34,60.88 306.3,60.88
+5V_ALW on TOP (solid shape): 128.58,29.36 128.58,29.1 128.45,28.98 128.45,28.96 128.39,28.9 128.39,28.62 128.17,28.4 127.99,28.4 127.45,28.94 127.09,28.94 126.93,29.1 126.93,29.38 127.04,29.49 127.53,29.49 127.7,29.66 128.27,29.66
+5V_ALW on TOP (solid shape): 311.43,63.42 311.43,62.49 311.27,62.33 311.27,61.67 310.88,61.28 309.53,61.28 309.38,61.44 309.38,62.3 309.24,62.44 309.24,63.54 309.27,63.58 309.79,63.58 309.81,63.58 309.81,63.59 310.08,63.86 310.99,63.86
+5V_ALW on TOP (solid shape): 25.48,76.78 25.48,76.22 25.76,75.94 25.76,75.1 25.96,74.9 25.96,74.01 25.79,73.83 24.41,73.83 24.26,73.98 24.26,74.38 23.03,75.61 23.03,76.35 23.53,76.85 25.41,76.85
+5V_ALW on TOP (solid shape): 137.61,117.94 137.61,117.05 137.55,116.99 136.66,116.99 136.47,116.79 136.47,115.18 136.82,114.83 136.82,114.34 136.29,114.34 136.29,113.9 136.83,113.9 136.83,113.56 136.75,113.48 135.59,113.48 135.41,113.66 134.58,113.66 134.07,114.18 134.07,114.68 134.07,114.69 134.07,114.95 134.07,114.95 134.07,115.59 134.6,115.59 134.6,116.03 134.07,116.03 134.07,116.3 134.13,116.36 134.44,116.36 135.01,116.93 135.01,117.94 135.07,118 137.55,118
+5V_ALW on TOP (solid shape): 188.91,24.26 189.15,24.09 189.44,24.17 189.51,24.2 189.57,24.17 189.85,24.1 190.09,24.26 191.91,24.26 192.14,24.03 192.57,23.61 192.57,22.53 191.3,21.26 191.3,17.8 191.29,17.8 191.29,17.21 191.27,17.19 190.3,17.19 189.97,17.52 189.55,17.52 189.36,17.33 189.36,16.72 189.06,16.41 185.2,16.41 185.01,16.61 185.01,21.11 187.24,23.34 187.27,23.34 187.6,23.43 187.69,23.76 187.69,23.79 188.16,24.26
+5V_ALW on TOP (solid shape): 40.86,99.33 40.86,95.63 40.25,95.63 40.2,95.58 40.16,95.58 40.16,95.07 40.13,95.05 39.69,95.05 39.66,95.07 39.66,95.55 39.66,95.58 39.63,95.58 39.61,95.6 39.01,95.6 38.99,95.58 38.96,95.58 38.96,95.05 38.95,95.04 38.49,95.04 38.48,95.05 38.48,95.55 38.46,95.56 38.46,95.58 37.68,95.58 37.68,95.57 35.92,95.57 35.2,96.29 35.2,99.22 39.56,99.22 39.56,99.17 39.57,99.11 39.59,99.06 39.61,99.01 39.64,98.97 39.68,98.93 39.72,98.9 39.77,98.87 39.82,98.85 39.87,98.84 39.92,98.84 39.97,98.84 40.03,98.85 40.08,98.87 40.12,98.9 40.16,98.93 40.2,98.97 40.23,99.01 40.25,99.06 40.27,99.11 40.28,99.17 40.28,99.22 40.27,99.27 40.25,99.32 40.23,99.37 40.2,99.42 40.16,99.45 40.12,99.49 40.08,99.51 40.03,99.53 39.97,99.55 39.92,99.55 39.87,99.55 39.82,99.53 39.77,99.51 39.72,99.49 39.68,99.45 39.64,99.42 39.61,99.37 39.59,99.32 39.57,99.27 39.56,99.22 35.2,99.22 35.2,99.5 35.72,100.02 40.18,100.02
+5V_ALW on BOTTOM (solid shape): 37.48,99.62 37.48,97.72 37.27,97.52 35.47,97.52 35.31,97.68 35.31,99.38 35.68,99.75 37.34,99.75
+5V_ALW on BOTTOM (solid shape): 165.93,100.15 166.63,100.15 166.63,100.67 167.13,100.67 167.13,100.15 167.83,100.15 167.83,100.67 168.92,100.67 169.36,100.22 169.36,97.68 169.04,97.36 165.11,97.36 164.6,97.87 164.6,100.41 164.85,100.67 165.93,100.67
+5V_ALW on BOTTOM (solid shape): 83.89,102.76 83.89,102.31 84.03,102.18 84.03,102.18 84.07,102.14 84.65,102.14 84.89,101.9 84.89,100.4 84.58,100.09 83.29,100.09 82.28,99.08 80.9,99.08 80.78,99.21 80.78,100.73 82.86,102.81 83.84,102.81
+5V_ALW on BOTTOM (solid shape): 277.36,41.54 277.45,41.47 277.45,41.46 278.12,41.46 278.2,41.39 278.2,40.63 278.16,40.6 277.97,40.6 277.45,40.07 277.13,40.07 276.97,40.23 276.97,40.58 276.78,40.78 276.78,41.46 276.9,41.58 276.9,41.58 276.94,41.61 277.3,41.61
+5V_ALW on BOTTOM (solid shape): outline of 193 points within 305.06,58.54 311.56,63.16
+5V_ALW on IN2 (solid shape): outline of 297 points within 127.16,15.03 187.39,29.66
+5V_ALW on VCC: outline of 171 points within 1.72,15.09 306.87,119.53 ; 1 cut-out
+5V_ALW_PDA on TOP (solid shape): 35.57,78.03 35.57,77.01 35.22,76.66 34.39,76.66 34.05,77 34.05,77.09 34.04,77.16 34.16,77.28 34.16,77.82 34.04,77.94 34.04,78.19 34.06,78.21 35.39,78.21
+5V_ALW_PDA on TOP (solid shape): 42.19,94.18 46.08,94.18 46.75,93.5 46.75,92.5 46.65,92.25 46.75,92 46.75,91.65 46.46,91.36 39.16,91.36 38.12,92.4 38.06,92.47 37.99,92.53 37.05,93.46 37.05,94.78 37.71,95.44 38.33,95.44 38.35,95.43 38.35,94.95 38.38,94.92 38.43,94.92 38.44,94.91 39,94.91 39.04,94.92 39.05,94.93 39.06,94.94 39.08,94.96 39.08,94.99 39.09,95 39.09,95.47 39.53,95.47 39.54,95.47 39.54,95.02 39.56,95 39.56,94.94 39.56,94.93 39.57,94.93 39.58,94.92 39.63,94.92 40.19,94.92 40.25,94.92 40.28,94.94 40.28,95.01 40.3,95.03 40.3,95.48 40.88,95.48
+5V_ALW_PDA on BOTTOM (solid shape): 46.66,93.02 46.66,92.35 46.65,92.25 46.66,92.15 46.66,91.84 46.36,91.53 45.06,91.53 44.91,91.69 44.91,92.63 45.43,93.14 46.54,93.14
+5V_ALW_PDA on IN3 (solid shape): outline of 1386 points within 29.98,76.41 42.23,93.05
+5V_ALWP on TOP (solid shape): 171.61,105.24 171.61,100.42 171.3,100.11 169.55,100.11 169.09,100.57 169.09,104.84 169.75,105.5 171.35,105.5
+5V_ALWP on BOTTOM (solid shape): 171.84,105.56 171.84,99.43 171.71,99.31 170.65,99.31 169.11,100.86 167.71,100.86 167.71,100.29 167.27,100.29 167.27,100.85 166.47,100.85 166.47,100.29 166.07,100.29 166.07,100.86 165.3,100.86 164.79,101.36 164.79,105.87 165.49,106.57 170.82,106.57
+5V_HDD on BOTTOM (solid shape): 280.51,38.56 280.51,38.02 280.54,37.99 280.93,37.99 280.99,37.93 280.99,37.61 280.74,37.36 280.74,36.52 280.17,35.96 280.17,35.77 280.04,35.64 280.04,34.18 279.91,34.05 278.83,34.05 278.71,34.18 278.71,35.96 278.63,36.04 278.63,36.2 278.45,36.38 278.45,36.98 278.41,37.01 278.41,37.03 278.4,37.03 278.39,37.04 277.71,37.04 277.7,37.04 277.63,37.07 277.55,37.08 277.53,37.08 277.37,37.23 277.37,38.43 277.52,38.58 277.89,38.58 277.9,38.56 277.9,38.04 277.92,38.02 278.35,38.02 278.38,38.04 278.38,38.58 278.38,38.58 278.47,38.58 278.77,38.58 278.77,38.59 279.12,38.59 279.72,37.99 280.29,37.99 280.32,38.02 280.32,38.58 280.34,38.6 280.48,38.6
+5V_HDD_UZ23 on BOTTOM (solid shape): 280.8,41.17 280.8,39.58 281.06,39.32 281.06,38.28 280.96,38.18 280.74,38.18 280.68,38.25 280.68,38.7 280.64,38.73 280.18,38.73 280.17,38.72 280.17,38.18 279.91,38.18 279.72,38.37 279.72,40.47 279.6,40.59 279.6,41.36 279.66,41.42 280.55,41.42
+5V_PD_VDD on BOTTOM (solid shape): 38.24,100.27 38.65,100.27 38.92,100 38.92,99.19 39.18,98.93 39.68,98.93 39.92,98.84 40.16,98.93 41.29,98.93 41.46,98.77 41.46,98.37 40.95,97.86 40.95,96.05 40.7,95.8 37.87,95.8 37.6,96.07 37.6,99.67 37.6,99.67 37.6,99.8 37.48,99.92 37.13,99.92 37.06,99.98 37.06,100.48 37.18,100.59 37.93,100.59
+5V_RUN on TOP (solid shape): 221.12,18.17 221.26,18.17 222.4,17.03 222.4,17.02 222.46,16.95 222.52,16.9 222.53,16.9 222.59,16.84 223.29,16.84 223.41,16.73 223.41,16.58 223.28,16.45 222.06,16.45 221.6,16.91 220.8,16.91 220.79,16.92 220.1,16.92 219.7,17.32 219.7,18.04 219.84,18.18 221.11,18.18
+5V_RUN on TOP (solid shape): 267.44,41.49 267.44,39.47 266.27,38.31 266.27,37.64 266.21,37.57 265.59,37.57 265.56,37.6 265.56,38.39 265.4,38.54 265.4,39.61 265.18,39.83 264.86,39.83 264.61,40.09 264.61,41.43 264.73,41.55 267.38,41.55
+5V_RUN on TOP (solid shape): 275.49,78.47 275.49,78.38 275.65,78.22 275.65,78.1 276.45,77.29 276.45,76.64 276.48,76.61 276.48,76.56 277.21,75.83 277.34,75.83 277.37,75.81 277.73,75.81 277.89,75.65 277.89,74.77 277.91,74.76 277.87,74.69 277.8,74.67 277.73,74.67 277.65,74.64 277.6,74.64 277.42,74.47 276.92,74.47 276.36,75.02 275.65,75.02 275.6,75.08 275.6,75.97 275.64,76.02 275.64,76.68 275.4,76.92 275.4,76.94 275.24,77.2 274.94,77.25 274.85,77.26 274.81,77.34 274.81,78.45 274.92,78.57 275.39,78.57
+5V_RUN on TOP (solid shape): 272.14,68.52 272.14,68 272.15,67.99 272.69,67.99 272.7,67.98 272.7,67.74 272.68,67.73 272.23,67.73 272.23,67.72 272.18,67.72 272.16,67.71 272.15,67.69 272.15,67.64 272.13,67.62 272.13,67.28 272.15,67.26 272.15,67.22 272.16,67.2 272.21,67.2 272.23,67.18 272.68,67.18 272.68,66.94 272.23,66.94 272.2,66.91 272.16,66.91 272.15,66.89 272.15,66.86 272.12,66.83 272.12,66.18 272.15,66.15 272.15,65.86 272.06,65.78 270.69,65.78 270.51,65.97 270.51,67.32 270.55,67.4 270.64,67.41 271.12,67.75 270.64,68.08 270.55,68.1 270.51,68.18 270.51,68.25 271.07,68.81 271.84,68.81
+5V_RUN on TOP (solid shape): outline of 873 points within 113.72,19.39 196.18,105.49
+5V_RUN on BOTTOM (solid shape): 129.48,98.25 129.48,96.67 128.47,96.67 128.47,97.55 128.28,97.74 128.28,98.32 128.4,98.44 129.29,98.44
+5V_RUN on BOTTOM (solid shape): 128.91,89.21 128.91,88.85 127.26,87.2 126.18,87.2 125.93,87.46 125.93,88.22 126.31,88.6 127.2,88.6 128.15,89.55 128.57,89.55
+5V_RUN on BOTTOM (solid shape): 278.97,40.11 278.97,38.96 278.71,38.71 278.52,38.71 278.26,38.71 278.23,38.68 278.23,38.17 278.21,38.15 278.05,38.15 278.03,38.16 278.03,38.69 278,38.72 277.45,38.72 277.41,38.76 277.41,39.84 278,40.42 278.66,40.42
+5V_RUN on BOTTOM (solid shape): 247.12,35.31 247.12,28.99 238.29,20.15 238.28,20.15 237.32,19.19 233.39,19.19 231.35,17.15 231.35,13.26 230.98,12.89 228.38,12.89 227.86,13.41 227.86,20.25 228.96,21.35 229.1,21.49 229.62,21.48 229.61,22 230.93,23.32 235.91,23.32 243.32,30.73 243.32,34.47 244.52,35.67 246.76,35.67
+5V_RUN on BOTTOM (solid shape): outline of 301 points within 259.57,39.92 266.57,49.13
+5V_RUN on IN1 (solid shape): outline of 329 points within 264.37,37.29 278.91,41.29
+5V_RUN on IN3 (solid shape): outline of 2162 points within 258.79,47.26 278.9,79.93
+5V_RUN on IN4 (solid shape): outline of 241 points within 243.16,32.73 261.63,49.4
+5V_RUN on IN4 (solid shape): outline of 1857 points within 191.39,12.15 231.31,22.38
+5V_RUN_AUDIO on TOP (solid shape): 301.12,47.01 301.12,45.17 300.93,44.98 299.69,44.98 299.28,45.38 299.28,47.01 299.57,47.3 299.65,47.3 299.72,47.33 300.8,47.33
+5V_RUN_AUDIO on TOP (solid shape): 310.46,28.4 310.46,26.89 310.25,26.68 307.29,26.68 306.58,27.39 306.58,27.83 306.65,27.89 307.15,27.89 307.28,28.02 308.11,28.02 308.3,27.83 309.31,27.83 309.95,28.47 310.39,28.47
+5V_RUN_AUDIO on TOP (solid shape): 277.37,70.83 277.37,70.25 277.88,70.25 277.88,70.83 278.14,70.83 278.16,70.81 278.16,69.6 277.11,68.55 277.11,68.03 277.06,67.98 275.5,67.98 275.2,67.68 275.2,66.62 274.54,65.96 272.51,65.96 272.25,66.23 272.25,66.33 272.26,66.33 272.26,66.79 272.27,66.8 272.81,66.8 272.81,67.31 272.28,67.31 272.26,67.33 272.26,67.57 272.29,67.6 272.79,67.6 272.81,67.6 272.81,67.62 272.82,67.63 272.82,68.09 272.81,68.1 272.8,68.11 272.79,68.12 272.33,68.12 272.28,68.17 272.28,68.89 272.82,69.42 276.26,69.42 276.84,70 276.84,70.73 276.94,70.84 277.37,70.84
+5V_RUN_AUDIO on VCC: outline of 106 points within 273.29,20.97 326.78,86.69 ; 1 cut-out
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): outline of 127 points within 275.6,70.99 278.14,73.81
+5V_RUN_PVDD_L on TOP (solid shape): outline of 128 points within 297.19,37.91 300.97,45.32
+5V_RUN_UZ4 on TOP (solid shape): 194.68,20.28 194.68,19.75 194.69,19.73 195.2,19.73 195.21,19.75 195.21,20.29 195.22,20.3 195.46,20.3 195.49,20.26 195.49,19.77 195.51,19.76 195.53,19.74 195.97,19.74 195.97,18.56 195.59,18.18 195.2,18.18 195.1,18.08 195.1,17.62 195.03,17.54 193.81,17.54 193.43,17.16 192.58,17.16 192.51,17.24 192.51,18.9 193.35,19.74 194.36,19.74 194.41,19.74 194.42,19.74 194.42,20.29 194.43,20.3 194.66,20.3
+5V_TBT_VBUS on BOTTOM (solid shape): 25.63,89.91 25.63,89.08 25.41,88.86 25.07,88.86 24.49,89.45 23.89,89.45 23.7,89.63 23.7,90.26 23.86,90.42 25.13,90.42
+5V_TBT_VBUS on BOTTOM (solid shape): 37.34,97.08 37.34,94.51 36.37,93.54 34.95,93.54 34.71,93.78 34.71,94.92 35.32,95.53 35.32,96.35 35.34,96.37 35.34,97.24 35.42,97.32 37.09,97.32
+5V_TBT_VBUS on IN4 (solid shape): outline of 251 points within 24.47,88.94 36.31,99.65
+5V_TBTA_VBUS_D on TOP (solid shape): 44.05,99.1 44.05,98.07 43.65,97.67 43.65,95.33 43.51,95.19 42.62,95.19 42.11,95.7 42.11,97.55 42.27,97.85 42.11,98.15 42.11,98.76 42.66,99.31 43.84,99.31
+5V_TBTA_VBUS_D on BOTTOM (solid shape): outline of 146 points within 35.29,90.9 44.21,96.37
+5V_TSP on BOTTOM (solid shape): outline of 99 points within 116.16,88.05 125.45,92.79
+5V_USB_CHG_PWR on TOP (solid shape): 313.71,46.59 313.71,45.45 311.85,43.59 311.85,43.58 310.08,41.8 310.08,40.91 309.69,40.53 307.54,40.53 307.41,40.66 307.41,41.61 307.6,41.8 308.62,41.8 309.06,42.25 309.06,43.26 308.88,43.44 308.88,44.4 309.19,44.4 309.69,44.91 309.69,46.37 309.82,46.5 311.22,46.5 311.66,46.94 313.35,46.94
+5V_USB_CHG_PWR on TOP (solid shape): 312.35,58.77 312.35,56.73 312.26,55.91 312.95,55.47 313.27,55.47 313.61,55.13 313.61,54.25 313.36,54 313.33,54.01 313.08,54.05 312.83,54 312.02,54 312.02,54 311.37,54 310.31,55.06 309.34,56.03 309.34,59.09 309.39,59.14 311.98,59.14
+5V_USB_CHG_PWR on BOTTOM (solid shape): 313.95,47.01 313.95,46.17 313.88,45.85 313.95,45.53 313.95,45.1 313.07,44.23 312.95,44.23 312.39,43.98 312.18,43.4 311.54,42.75 310.84,42.75 310.52,42.44 307.34,39.57 307.34,37.76 307.27,37.69 306.01,37.69 305.96,37.74 305.96,40.47 306.59,41.1 307.09,41.1 307.28,41.29 307.28,43.13 307.73,43.58 310.77,43.58 310.88,43.69 310.98,43.69 310.98,43.78 311.16,43.96 311.16,45.94 311.16,45.94 311.16,46.5 311.92,47.26 313.7,47.26
+5V_USB_CHG_PWR on IN3 (solid shape): outline of 359 points within 307.41,40.59 313.43,58.41
+DV33_18 on TOP (solid shape): 22.84,51.6 22.84,51.32 22.76,51.24 20.75,51.24 20.7,51.3 20.7,51.62 20.82,51.74 22.7,51.74
+GND_CHASSIS on BOTTOM (solid shape): 303.2,99.28 303.2,98.22 302.9,97.91 284.93,97.91 284.74,98.1 284.74,99.42 284.88,99.56 302.93,99.56
+VBUS_DC_SS on TOP (solid shape): 11.84,49.5 13.19,49.5 14.18,48.51 14.18,44.09 13.87,43.78 11.23,43.78 11.1,43.91 11.1,46.3 11.13,46.32 11.13,46.58 10.62,47.08 9.15,47.08 8.29,47.95 4.65,47.95 4.45,48.15 4.45,49.68 4.64,49.87 11.47,49.87
+VCC_1P8 on TOP (solid shape): 130.99,60.23 131.1,60.26 131.2,60.23 131.23,60.21 131.25,60.21 131.32,60.14 131.32,59.9 131.22,59.8 131.03,59.8 131.02,59.81 131.02,59.85 130.94,59.85 130.94,59.85 130.49,59.85 130.43,59.85 130.43,59.8 130.33,59.69 130.33,59.39 130.25,59.3 129.29,59.3 129.28,59.31 129.28,59.77 129.35,59.83 129.95,59.83 130.34,60.22 130.97,60.22
+VCC_1P8 on BOTTOM (solid shape): 131.67,60.75 131.67,60.36 131.64,60.34 131.45,60.17 131.45,59.91 131.45,59.87 131.42,59.85 131.38,59.83 130.94,59.83 130.57,60.2 130.57,60.76 130.64,60.84 131.58,60.84
+VCC_CORE on TOP (solid shape): 85.35,79.74 85.35,76.77 85.03,76.45 85.03,76.45 83.91,74.89 83.65,72.98 84.84,70.53 87.32,69.4 87.32,69.36 87.57,69.36 87.76,69.17 87.76,67.46 87.51,67.2 86.43,67.2 86.39,67.24 86.39,67.43 86.05,67.77 85.22,67.77 84.78,68.22 83.89,68.22 83.63,68.47 74.43,68.47 74.05,68.85 74.05,76.98 76.94,79.87 85.21,79.87
+VCC_CORE on TOP (solid shape): outline of 1604 points within 111.51,52.79 120.72,74.25
+VCC_CORE on BOTTOM (solid shape): outline of 140 points within 69.8,65.17 88.42,81.11
