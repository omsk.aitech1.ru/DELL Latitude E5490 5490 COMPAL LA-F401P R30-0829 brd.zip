# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UPD2_SMBDAT: length 19.6
  TOP w0.102: v1(298.36,76.33) UE1.E7 ; v1(309.29,82.41) 309.45,82.57 312.43,82.57 312.95,82.04 312.95,81.66 312.82,81.53 RPE12.4
  IN4 w0.089: v1(298.36,76.33) UE1.E7 301.19,76.73 301.64,77.17 304.3,77.17 306.82,79.69 306.82,80.22 308.77,82.16 308.77,82.44 308.92,82.6 309.11,82.6 v1(309.29,82.41)
UPD2_SMBINT#: length 20.5
  TOP w0.102: RE92.1 289.36,69.84 289.57,70.05 289.57,71.9 v2(289.1,72.37) v1(287.54,73.93) ; v1(299.16,74.73) UE1.F5
  BOTTOM w0.102: v1(287.54,73.93) 287.54,74.55 288.37,75.38 290.56,75.38 291.09,75.91 292.3,75.91 292.66,76.28 294.12,76.28 295.42,74.98 296.18,74.98 296.32,75.12 298.77,75.12 v1(299.16,74.73)
USB1_A_DE0: length 4.7
  TOP w0.102: RI53.1 302.13,62.18 302.13,61.02 RI54.1 v2(301.63,59.59) 301.63,59.51 301.38,59.26 UI5.16
USB1_A_DE1: length 5
  TOP w0.102: RI51.1 300.11,62.17 300.11,61.03 RI52.1 299.6,60.27 300.38,59.48 UI5.18
USB1_A_EQ0: length 4.8
  TOP w0.102: UI5.17 300.88,59.31 300.98,59.41 300.98,59.98 300.61,60.34 RI41.1 301.12,61.03 301.12,62.17 RI40.1
USB1_A_EQ1: length 6.1
  TOP w0.102: v2(303.6,63.01) 302.98,63.01 RI38.1 302.94,62.39 302.94,61.93 303.17,61.7 303.17,61.05 RI39.1 302.65,60.03 301.88,59.26 UI5.15
USB1_B_DE0: length 4.5
  TOP w0.102: RI58.1 301.6,50.61 301.6,52.2 RI57.1 301.38,52.93 UI5.3
USB1_B_DE1: length 6.2
  TOP w0.102: UI5.6 302.88,53.95 303.13,53.7 304.53,53.7 304.81,53.42 304.81,52.63 v2(305.27,52.17) 305.78,51.65 RI56.1 RI55.1
USB1_B_EQ0: length 4.8
  TOP w0.102: UI5.2 300.88,53.32 RI44.1 299.73,52.16 299.73,51.45 300.23,50.94 300.23,50.51 RI45.1
USB1_B_EQ1: length 4.4
  TOP w0.102: UI5.4 301.88,52.87 RI42.1 302.51,52.24 302.51,50.63 RI43.1
USB1_TEST: length 2.6
  TOP w0.102: RI34.2 303.66,60.1 v2(303.13,59.57) 302.38,58.82 UI5.14
USB2_ID: length 267.4
  TOP w0.102: RC337.1 v1(151.77,37.61)
  IN1 w0.089: v1(135.99,56.06) 135.99,56.04 136.89,55.14 142.25,55.14 145.12,52.26 145.12,47.86 144.28,47.02 v1(143.9,47.02)
  IN2 w0.122: v1(39.54,74.69) 38.36,73.51 v1(38.36,70.76) ; v1(151.77,37.61) 151.77,37.97 150.52,39.22 150.31,39.22 144.5,45.03 144.5,46.8 144.28,47.02 v1(143.9,47.02)
  IN4 w0.089: v1(180.65,20.69) 180.65,22.48 178.37,24.75 177.91,24.75 176.03,26.63 176.03,27.9 174.84,29.1 174.84,31.15 173.49,32.5 173.49,35.24 168.54,40.19 164.75,40.19 v1(164.43,39.86)
  BOTTOM w0.102: v1(38.36,70.76) v2(38.36,63.89) 38.36,55.92 37.85,55.42 37.85,41.5 43.1,36.25 58.47,36.25 60.03,34.69 69.13,34.69 70.85,32.97 82.28,32.97 85.45,29.8 123.34,29.8 132.4,20.73 177.43,20.73 177.73,20.44 180.39,20.44 v1(180.65,20.69) ; RT74.2 37.28,78.31 39.15,76.45 39.15,75.09 v1(39.54,74.69) ; v1(151.77,37.61) 152.07,37.61 153.42,36.26 160.1,36.26 163.25,39.41 163.98,39.41 v1(164.43,39.86) ; v1(135.99,56.06) 135.99,55.77 UC1.AG3
USB2_VBUSSENSE: length 28
  TOP w0.102: RC338.1 150.75,40.05 v1(150.07,40.73)
  IN1 w0.089: v1(143.88,47.6) 144.41,47.6 144.91,48.1 144.91,52.16 142.13,54.93 136.49,54.93 135.48,55.94 v1(135.12,55.94)
  IN2 w0.122: v1(150.07,40.73) 150.07,41.21 144.89,46.39 144.89,46.97 144.26,47.6 v1(143.88,47.6)
  BOTTOM w0.102: UC1.AG4 135.47,55.6 v1(135.12,55.94)
USB3_PD#: length 5.5
  TOP w0.102: v1(304.45,51.16) 303.62,51.16 RI37.2 RI81.2 303.01,53.32 302.38,53.95 UI5.5
  BOTTOM w0.102: v1(304.45,51.16) v2(304.45,52.08)
USB3_PRX_C_DTX_N1: length 2.8
  BOTTOM w0.094: CT112.2 21.85,99.51 21.85,99.41 21.77,99.33 21.42,99.33 21.14,99.05 21.14,98.34 21.01,98.21 UT9.4
USB3_PRX_C_DTX_P1: length 2.8
  BOTTOM w0.094: CT111.2 22.04,99.44 22.04,99.33 21.85,99.14 21.5,99.14 21.32,98.97 21.32,98.33 21.41,98.24 UT9.5
USB3_PRX_C_RD_DTX_N6: length 2.6
  TOP w0.094: UI5.23 299.11,55.66 298.97,55.8 298.68,55.8 298.58,55.7 298.58,55.27 298.38,55.06 298.21,55.06 CI42.2
USB3_PRX_C_RD_DTX_P6: length 2.6
  TOP w0.094: UI5.22 299.15,56.16 298.97,55.98 298.6,55.98 298.4,55.77 298.4,55.34 298.3,55.25 298.16,55.25 CI41.2
USB3_PRX_DTX_N1: length 201.4
  IN4 w0.089: v1(132.56,65.34) 132.42,65.48 132.16,65.48 131.99,65.64 131.99,68.63 130.13,70.49 130.13,72.23 130.62,72.73 130.62,75.45 129.34,76.74 129.34,77.31 129.85,77.82 129.85,79.64 129.42,80.07 129.42,80.72 128.17,81.96 128.17,84 125.57,86.61 122.14,86.61 116.29,92.46 116.29,95.74 113.85,98.18 113.85,100.06 108.87,105.03 93.79,105.03 92.02,103.26 87.99,103.26 84.55,99.82 80.76,99.82 76.71,95.78 76.71,95.78 76.52,95.58 74.32,95.58 72.82,94.09 68.36,94.09 67.32,93.05 65.73,93.05 62.35,89.67 62.35,86.43 55.06,79.14 51.96,79.14 50.45,77.63 45.93,77.63 44.38,76.08 44.38,72.23 39.78,67.63 23.01,67.63 21.99,68.65 21.99,69.29 21.66,69.61 19.99,69.61 19.07,70.54 19.07,77.48 16.97,79.57 16.97,84.34 16.69,84.63 16.69,94.02 16.31,94.41 16.31,97.98 19.08,100.75 21.6,100.75 21.9,101.06 21.9,101.49 v1(21.7,101.69)
  BOTTOM w0.094: v1(21.7,101.69) 21.88,101.5 21.88,101.22 CT112.1 ; UC1.H8 132.71,65.3 132.59,65.3 v1(132.56,65.34)
USB3_PRX_DTX_N2: length 204
  TOP w0.094: v1(290.81,46.8) 290.77,46.77 290.64,46.77 290.53,46.88 290.53,46.97 290.4,47.09 290.4,47.21 290.55,47.36 291.66,47.36 292.04,46.98 v4(292.04,46.68) 292.04,46.32 291.97,46.25 291.78,46.25 291.73,46.2 LI16.4 291.56,45.43 RI28.1
  IN2 w0.076: 135.79,64.51 135.77,64.49 135.73,64.49 135.39,64.15 134.13,64.15 133.87,64.42 133.87,64.67 133.76,64.78 v1(133.47,64.78)
  IN2 w0.122: 135.79,64.51 136.85,65.57 143.8,65.57 144.44,64.94 149.48,64.94 150.24,65.7 153.77,65.7 155.11,67.03 158.32,67.03 160.73,64.62 160.73,59.74 161.06,59.41 161.06,50.72 163.2,48.59 163.2,48.05 164.73,46.52 167.38,46.52 169.79,44.11 170.42,44.11 181.01,33.52 185.46,33.52 187,31.97 193.2,31.97 198.84,26.33 201.61,26.33 204.56,23.38 205.88,23.38 206.44,22.82 208,22.82 209.63,24.45 210.59,24.45 211.01,24.87 215.82,24.87 216.82,23.87 221.69,23.87 222.27,23.29 225.16,23.29 226.85,24.97 229,24.97 230.63,26.61 234.5,26.61 235.36,27.47 241.68,27.47 243.95,29.74 248.72,29.74 249.89,30.9 252.96,30.9 253.47,31.41 256.34,31.41 257.23,32.3 260.33,32.3 261.85,33.83 269.75,33.83 270.8,34.88 275.13,34.88 279.28,39.03 279.28,40.05 280.96,41.74 282.18,41.74 282.88,42.44 282.88,43.64 284.03,44.79 285.58,44.79 285.81,44.74 287.27,44.74 288.31,45.79 290.28,45.79 290.69,46.2 290.69,46.68 v1(290.81,46.8)
  BOTTOM w0.076: UC1.J6 133.86,64.39 v1(133.47,64.78)
USB3_PRX_DTX_N3: length 168.6
  TOP w0.094: JUSB2.5 14.16,71.21 14.25,71.31 14.66,71.31 15.2,71.84 16.44,71.84 17.12,71.15 17.12,71.11 17.66,70.57 18.87,70.57 DI1.9 DI1.1 20.33,70.38 20.38,70.43 20.38,70.49 20.45,70.57 20.76,70.57 21.16,70.17 21.16,69.5 v1(20.76,69.11)
  IN4 w0.089: v1(20.76,69.11) 20.96,68.9 20.96,67.96 22.02,66.9 39.96,66.9 44.96,71.9 44.96,75.65 46.3,76.98 50.61,76.98 52.16,78.53 55.26,78.53 62.99,86.26 62.99,89.48 65.94,92.43 67.59,92.43 68.34,93.18 81.3,93.18 84.65,96.54 84.93,96.54 89.81,101.41 92.79,101.41 94.16,102.78 108.44,102.78 111.79,99.44 111.79,97.8 113.24,96.34 113.24,92.99 118.34,87.89 118.34,86.96 119.51,85.79 119.51,85.42 120.86,84.07 123.73,84.07 126.11,81.68 126.11,80.61 127.56,79.17 127.56,77.84 128.12,77.29 128.12,76.33 129.01,75.44 129.01,69.57 130.16,68.43 130.16,65.52 130.49,65.19 130.7,65.19 131.1,64.8 131.41,64.8 v1(131.6,64.61)
  BOTTOM w0.076: v1(131.6,64.61) 131.82,64.39 UC1.J10
USB3_PRX_DTX_N4: length 96.6
  TOP w0.094: v1(80.39,95.25) 80.71,95.57 80.71,96.16 80.57,96.3 80.57,101.55 80.41,101.71 DI6.1 DI6.9 80.41,103.41 80.57,103.57 80.57,103.85 78.05,106.37 78.05,107.24 77.46,107.83 77.46,108.43 77.36,108.52 JUSB3.5
  IN4 w0.076: 131.25,67.5 131.25,67.08 131.35,66.98 131.53,66.98 131.62,67.07 v1(131.62,67.21)
  IN4 w0.089: 131.25,67.5 131.17,67.58 131.17,68.66 129.78,70.06 129.78,75.75 128.91,76.62 128.91,79.19 126.95,81.15 126.95,82.3 124.88,84.37 124.88,84.82 124.06,85.64 121.34,85.64 120.65,86.33 120.15,86.33 119.26,87.22 119.26,88.05 115.29,92.02 115.29,93.1 114.4,93.99 114.4,96.25 112.58,98.08 112.58,99.79 108.78,103.59 93.9,103.59 92.48,102.17 89.5,102.17 84.95,97.62 84.14,97.62 82.96,96.44 81.33,96.44 80.6,95.71 80.6,95.46 v1(80.39,95.25)
  BOTTOM w0.076: UC1.E10 131.83,66.99 131.62,67.2 v1(131.62,67.21)
USB3_PRX_DTX_N6: length 214.1
  TOP w0.094: v1(296.02,54.84) 296.22,55.05 296.51,55.05 296.85,54.7 CI42.1
  IN2 w0.076: 131.27,68.34 131.25,68.32 131.25,66.24 131.07,66.06 130.86,66.06 v1(130.71,65.91)
  IN2 w0.122: 131.27,68.34 131.87,68.94 134.95,68.94 137.58,66.31 144.13,66.31 144.61,65.83 146.59,65.83 147.7,66.94 150.68,66.94 150.76,67.03 154.12,67.03 155.43,68.34 158.15,68.34 161.93,64.56 161.93,59.84 164.51,57.26 164.51,49.77 165.19,49.09 167.98,49.09 177.19,39.87 177.19,38.28 181.29,34.18 185.86,34.18 187.38,32.65 193.45,32.65 199.04,27.07 202.27,27.07 204.94,24.4 208.2,24.4 209.02,25.21 210.26,25.21 210.7,25.65 217.58,25.65 218.34,24.89 225.59,24.89 227.07,26.37 229.25,26.37 231.24,28.36 241.43,28.36 243.51,30.44 248.44,30.44 249.56,31.56 252.68,31.56 253.19,32.07 255.98,32.07 256.87,32.96 260,32.96 261.57,34.54 268.29,34.54 269.43,35.68 271.3,35.68 272.39,36.77 276.08,36.77 277.68,38.37 277.68,39.8 277.99,40.11 277.99,40.31 278.54,40.86 278.96,40.86 278.96,40.86 279.15,40.86 283.74,45.44 285.65,45.44 285.88,45.4 286.89,45.4 290.64,49.15 291.52,49.15 294.28,51.91 294.28,54.25 295.22,55.2 295.53,55.2 295.6,55.13 295.6,54.88 295.72,54.76 295.93,54.76 v1(296.02,54.84)
  BOTTOM w0.094: UC1.G11 v1(130.71,65.91)
USB3_PRX_DTX_P1: length 201.3
  IN4 w0.089: v1(132.56,66) 132.56,65.77 132.5,65.71 132.4,65.71 132.35,65.66 132.23,65.66 132.17,65.72 132.17,68.7 130.31,70.57 130.31,72.15 130.8,72.65 130.8,75.53 129.52,76.81 129.52,77.23 130.03,77.74 130.03,79.72 129.6,80.15 129.6,80.79 128.35,82.04 128.35,84.08 125.64,86.79 122.22,86.79 116.47,92.54 116.47,95.81 114.03,98.25 114.03,100.13 108.95,105.21 93.71,105.21 91.94,103.44 87.91,103.44 84.48,100 80.68,100 76.64,95.96 76.64,95.96 76.44,95.76 74.24,95.76 72.75,94.27 68.29,94.27 67.25,93.23 65.65,93.23 62.17,89.74 62.17,86.51 54.98,79.32 51.89,79.32 50.37,77.81 45.85,77.81 44.2,76.15 44.2,72.31 39.7,67.81 23.08,67.81 22.17,68.73 22.17,69.36 21.73,69.79 20.07,69.79 19.25,70.62 19.25,77.55 17.15,79.64 17.15,84.42 16.87,84.7 16.87,94.1 16.49,94.48 16.49,97.91 19.16,100.57 21.67,100.57 22.08,100.98 22.08,101.48 v1(22.28,101.69)
  BOTTOM w0.076: v1(132.56,66) 132.87,65.69 UC1.G8
  BOTTOM w0.094: CT111.1 22.07,101.22 22.07,101.47 v1(22.28,101.69)
USB3_PRX_DTX_P2: length 204
  TOP w0.094: v1(290.13,46.8) 290.21,46.88 290.21,47.29 290.47,47.55 291.73,47.55 292.23,47.05 292.23,46.96 292.24,46.95 292.24,46.38 292.23,46.37 LI16.1 292.4,45.43 RI27.1
  IN2 w0.076: v1(133.48,65.37) 133.48,65.29 134.03,64.73 134.03,64.49 134.2,64.32 135.32,64.32 135.62,64.62 135.62,64.67
  IN2 w0.122: 135.62,64.67 136.76,65.8 143.9,65.8 144.53,65.17 149.38,65.17 150.14,65.93 153.68,65.93 155.01,67.26 158.41,67.26 160.96,64.71 160.96,59.83 161.3,59.5 161.3,50.81 163.43,48.68 163.43,48.15 164.82,46.75 167.47,46.75 169.88,44.34 170.51,44.34 181.11,33.75 185.55,33.75 187.1,32.2 193.3,32.2 198.94,26.56 201.71,26.56 204.65,23.61 205.98,23.61 206.54,23.06 207.91,23.06 209.53,24.68 210.49,24.68 210.91,25.1 215.92,25.1 216.92,24.1 221.78,24.1 222.37,23.52 225.07,23.52 226.75,25.2 228.9,25.2 230.54,26.84 234.4,26.84 235.26,27.7 241.59,27.7 243.85,29.97 248.63,29.97 249.79,31.13 252.87,31.13 253.37,31.64 256.24,31.64 257.13,32.53 260.23,32.53 261.76,34.06 269.65,34.06 270.71,35.12 275.04,35.12 279.05,39.13 279.05,40.15 280.87,41.97 282.09,41.97 282.65,42.53 282.65,43.73 283.93,45.02 285.61,45.02 285.84,44.97 287.17,44.97 288.22,46.02 290.18,46.02 290.45,46.29 290.45,46.48 290.13,46.8 v1(290.13,46.8)
  BOTTOM w0.076: UC1.H6 133.81,65.04 v1(133.48,65.37)
USB3_PRX_DTX_P3: length 168.6
  TOP w0.094: v1(21.34,69.11) 21.34,69.11 21.34,70.25 20.84,70.75 20.52,70.75 20.51,70.76 20.33,70.76 20.21,70.88 DI1.2 DI1.8 18.95,70.76 17.79,70.76 v4(17.54,71) 16.52,72.03 15.12,72.03 14.58,71.49 14.25,71.49 14.16,71.59 JUSB2.6
  IN4 w0.089: v1(131.6,65.36) 131.6,65.13 131.45,64.98 131.17,64.98 130.78,65.37 130.56,65.37 130.34,65.59 130.34,68.5 129.19,69.65 129.19,75.52 128.3,76.41 128.3,77.36 127.74,77.92 127.74,79.24 126.29,80.69 126.29,81.76 123.8,84.25 120.94,84.25 119.69,85.49 119.69,85.87 118.52,87.04 118.52,87.97 113.43,93.06 113.43,96.42 111.97,97.87 111.97,99.51 108.51,102.96 94.09,102.96 92.72,101.6 89.74,101.6 84.86,96.72 84.57,96.72 81.22,93.36 68.27,93.36 67.52,92.61 65.87,92.61 62.81,89.55 62.81,86.33 55.18,78.71 52.09,78.71 50.54,77.16 46.22,77.16 44.78,75.72 44.78,71.97 39.89,67.08 22.1,67.08 21.14,68.04 21.14,68.9 v1(21.34,69.11)
  BOTTOM w0.076: v1(131.6,65.36) 131.91,65.04 UC1.H10
USB3_PRX_DTX_P4: length 96.6
  TOP w0.094: v1(81.24,95.26) 80.9,95.61 80.9,96.23 80.75,96.37 80.75,101.55 80.91,101.71 DI6.2 DI6.8 80.91,103.42 80.75,103.58 80.75,103.93 78.24,106.45 78.24,107.32 77.64,107.91 77.64,108.43 77.74,108.52 JUSB3.6
  IN4 w0.076: 131.08,67.42 131.08,67.41 131.08,67.01 131.28,66.81 131.38,66.81 v1(131.62,66.58)
  IN4 w0.089: 131.08,67.42 130.99,67.51 130.99,68.59 129.6,69.98 129.6,75.67 128.73,76.54 128.73,79.12 126.77,81.07 126.77,82.23 124.7,84.3 124.7,84.74 123.99,85.46 121.27,85.46 120.58,86.15 120.07,86.15 119.08,87.15 119.08,87.98 115.11,91.94 115.11,93.02 114.22,93.92 114.22,96.18 112.4,98 112.4,99.72 108.7,103.41 93.97,103.41 92.55,101.99 89.57,101.99 85.02,97.44 84.22,97.44 83.04,96.26 81.4,96.26 80.78,95.64 80.78,95.34 80.97,95.14 81.12,95.14 v1(81.24,95.26)
  BOTTOM w0.076: UC1.F10 131.86,66.34 v1(131.62,66.58)
USB3_PRX_DTX_P6: length 214.1
  TOP w0.094: CI41.1 296.44,55.23 296.21,55.23 v1(296.02,55.43)
  IN2 w0.076: 131.11,68.5 131.09,68.49 131.1,68.49 131.1,68.43 131.08,68.42 131.08,68.38 131.08,68.38 131.08,66.31 131.01,66.23 130.92,66.23 130.87,66.28 130.82,66.28 130.65,66.45 130.65,66.56 v1(130.71,66.63)
  IN2 w0.122: v1(296.02,55.43) 295.13,55.43 294.05,54.35 294.05,52.01 291.42,49.38 290.55,49.38 286.79,45.63 285.9,45.63 285.67,45.68 283.64,45.68 279.06,41.09 278.44,41.09 277.76,40.41 277.76,40.2 277.45,39.89 277.45,38.46 275.99,37 272.29,37 271.2,35.91 269.34,35.91 268.2,34.77 261.48,34.77 259.9,33.19 256.77,33.19 255.88,32.3 253.09,32.3 252.58,31.79 249.46,31.79 248.34,30.68 243.41,30.68 241.33,28.59 231.15,28.59 229.15,26.6 226.98,26.6 225.5,25.12 218.44,25.12 217.68,25.88 210.6,25.88 210.17,25.44 208.92,25.44 208.11,24.63 205.03,24.63 202.37,27.3 199.14,27.3 193.55,32.89 187.48,32.89 185.96,34.41 181.39,34.41 177.42,38.37 177.42,39.97 168.07,49.32 165.28,49.32 164.74,49.86 164.74,57.35 162.16,59.93 162.16,64.66 158.24,68.57 155.33,68.57 154.02,67.26 150.67,67.26 150.58,67.18 147.61,67.18 146.49,66.06 144.71,66.06 144.22,66.54 137.67,66.54 135.04,69.17 131.78,69.17 131.11,68.5
  BOTTOM w0.094: UC1.F11 v1(130.71,66.63)
USB3_PRX_L_DTX_N2: length 5.6
  TOP w0.094: v1(293.41,43.4) 293.61,43.6 293.61,43.73 293.51,43.83 293.12,43.83 292.54,43.25 292.12,43.25 291.88,43.49 291.88,43.74 291.73,43.89 LI16.3 291.56,44.52 RI28.2
  BOTTOM w0.094: JNGFF2.29 293.8,42.45 293.97,42.62 293.97,42.73 293.64,43.05 293.64,43.16 v1(293.41,43.4)
USB3_PRX_L_DTX_P2: length 5.6
  TOP w0.094: RI27.2 292.4,44.52 LI16.2 292.23,43.87 292.07,43.71 292.07,43.56 292.19,43.44 292.46,43.44 293.04,44.01 293.59,44.01 293.79,43.81 293.79,43.6 v1(293.99,43.4)
  BOTTOM w0.094: v1(293.99,43.4) 293.83,43.24 293.83,43.13 294.15,42.81 294.15,42.63 294.3,42.48 JNGFF2.31
USB3_PRX_RD_DTX_N6: length 16
  TOP w0.094: UI5.8 304.06,55.66 304.38,55.97 304.6,55.97 304.66,56.03 304.79,56.03 304.8,56.02 305.44,56.02 305.45,56.03 305.45,56.03 305.65,56.22 305.9,56.22 v1(306.19,55.93) ; v1(307.77,54.92) 308.05,54.64 308.29,54.64 308.52,54.87 DI4.1 DI4.9 309.74,54.87 309.9,54.71 310.16,54.71 312.43,52.45 313.47,52.45 313.96,52.94 314.33,52.94 314.6,53.22 JUSB1.5
  BOTTOM w0.094: v1(306.19,55.93) 306.59,56.33 307.32,56.33 308.43,55.21 308.43,54.8 308.26,54.63 308.06,54.63 v1(307.77,54.92)
USB3_PRX_RD_DTX_P6: length 16
  TOP w0.094: UI5.9 304.53,56.16 304.59,56.22 v4(305.12,56.22) 305.38,56.22 305.57,56.41 306.09,56.41 v1(306.19,56.51) ; JUSB1.6 314.6,52.49 314.34,52.76 314.04,52.76 313.54,52.26 312.35,52.26 310.09,54.52 309.89,54.52 309.73,54.37 DI4.8 DI4.2 308.49,54.37 308.4,54.46 307.89,54.46 v1(307.77,54.34)
  BOTTOM w0.094: v1(307.77,54.34) 307.87,54.44 308.34,54.44 308.62,54.72 308.62,55.29 307.39,56.51 v1(306.19,56.51)
USB3_PTX_C_DRX_N1: length 3.6
  BOTTOM w0.094: UT9.7 22.21,98.26 22.32,98.37 22.32,98.72 22.63,99.03 22.87,99.03 22.88,99.03 23.51,99.03 23.52,99.03 23.75,99.03 23.89,99.17 23.89,99.5 CT114.2
USB3_PTX_C_DRX_N2: length 1.8
  TOP w0.094: RI30.1 294.73,47.4 LI17.4 294.9,47.82 295.06,47.98 295.06,48.55 CI29.1
USB3_PTX_C_DRX_N3: length 11.6
  TOP w0.094: CI5.1 20.86,72 20.07,72 DI1.4 DI1.7 18.58,71.88 18.42,72.03 18.15,72.03 v4(17.46,72.73) 17.08,73.11 17.08,74.15 17.05,74.19 17.05,74.77 17.08,74.8 17.08,75.26 15.93,76.41 15.56,76.41 14.66,77.31 14.25,77.31 14.16,77.21 JUSB2.8
USB3_PTX_C_DRX_N4: length 9.7
  TOP w0.094: JUSB3.8 83.25,108.52 83.47,108.3 83.47,108.12 82.88,107.53 82.88,106.14 v4(82.55,105.81) 82.07,105.33 82.07,104.62 82.04,104.58 82.04,104 82.07,103.97 82.07,103.6 81.91,103.44 DI6.7 DI6.4 81.91,101.87 82.08,101.7 82.08,100.97 CI27.1
USB3_PTX_C_DRX_N6: length 12.9
  TOP w0.094: CI13.1 307.68,53.3 307.77,53.21 308.3,53.21 308.46,53.37 DI4.4 DI4.7 310.05,53.37 310.21,53.2 310.38,53.2 310.82,52.76 310.87,52.76 311.28,52.35 311.28,52.3 311.54,52.05 v4(311.54,49.76) 311.54,48.59 312.43,47.69 313.36,47.69 314.11,46.94 314.51,46.94 314.6,47.04 JUSB1.8
USB3_PTX_C_DRX_P1: length 3.6
  BOTTOM w0.094: UT9.8 22.61,98.27 22.51,98.38 22.51,98.64 22.71,98.84 v4(23.2,98.84) 23.82,98.84 24.08,99.1 24.08,99.45 CT113.2
USB3_PTX_C_DRX_P2: length 1.8
  TOP w0.094: CI30.1 295.25,48.55 295.25,47.98 295.4,47.82 LI17.1 295.57,47.4 RI29.1
USB3_PTX_C_DRX_P3: length 11.7
  TOP w0.094: JUSB2.9 14.16,77.59 14.25,77.49 14.74,77.49 15.63,76.6 16.01,76.6 17.26,75.34 v4(17.26,74.48) 17.26,73.18 17.36,73.09 17.37,73.09 17.82,72.64 17.82,72.63 18.23,72.22 18.42,72.22 18.58,72.38 DI1.6 DI1.5 20.14,72.18 20.86,72.18 CI4.1
USB3_PTX_C_DRX_P4: length 9.6
  TOP w0.094: CI28.1 82.27,100.97 82.27,101.71 82.41,101.85 DI6.5 DI6.6 82.41,103.44 82.25,103.6 v4(82.25,104.29) 82.25,105.25 82.45,105.45 82.5,105.45 82.91,105.86 82.91,105.91 83.06,106.06 83.06,107.45 83.65,108.04 83.65,108.3 83.87,108.52 JUSB3.9
USB3_PTX_C_DRX_P6: length 12.9
  TOP w0.094: CI16.1 307.68,52.92 307.78,53.02 308.3,53.02 308.46,52.87 DI4.5 DI4.6 310.05,52.87 310.2,53.02 310.3,53.02 v4(310.92,52.4) 311.35,51.97 311.35,50.09 311.32,50.06 311.32,49.47 311.35,49.44 311.35,48.51 312.36,47.5 313.29,47.5 314.03,46.76 314.51,46.76 314.6,46.66 JUSB1.9
USB3_PTX_C_RD_DRX_N6: length 2.1
  TOP w0.094: UI5.20 299.22,57.16 299.07,57.31 298.85,57.31 298.63,57.08 298.2,57.08 298.14,57.03 298.14,57.03 CI40.1
USB3_PTX_C_RD_DRX_P6: length 2.1
  TOP w0.094: CI39.1 298.17,57.27 298.55,57.27 298.78,57.5 299.07,57.5 299.22,57.66 UI5.19
USB3_PTX_DRX_N1: length 200.7
  IN4 w0.089: v1(23.71,101.5) 23.71,100.43 23.37,100.09 19.36,100.09 16.92,97.65 16.92,94.76 17.27,94.41 17.27,85.06 17.62,84.72 17.62,80.07 19.83,77.86 19.83,70.97 20.55,70.25 25.66,70.25 26.9,69.01 39.53,69.01 43.19,72.66 43.19,76.54 45.61,78.96 49.99,78.96 51.79,80.76 54.29,80.76 61.03,87.5 61.03,90.06 66.2,95.23 72.34,95.23 74.41,97.3 76.6,97.3 81.91,102.61 84.95,102.61 85.88,103.55 86.32,103.55 87.65,104.88 91.38,104.88 92.68,106.18 110,106.18 119.27,96.91 119.27,91.16 122.67,87.75 126.67,87.75 128.38,86.05 130,86.05 130.56,85.49 130.56,80.55 131.01,80.11 131.01,78.37 131.83,77.55 131.83,76.59 131.45,76.21 131.45,72.59 130.56,71.7 130.56,70.95 v1(130.98,70.53)
  BOTTOM w0.076: v1(130.98,70.53) 130.77,70.74 130.6,70.74 130.07,70.21 130.07,69.61 130.13,69.49 130.13,69.34 130.07,69.15 130.07,68.98 130.11,68.85 130.22,68.75 130.41,68.75 130.43,68.73 130.47,68.73 130.65,68.55 130.65,68.51 130.71,68.45 130.71,68.32 130.6,68.21 130.54,68.21 UC1.C13
  BOTTOM w0.094: CT114.1 23.91,101.21 23.91,101.31 v1(23.71,101.5)
USB3_PTX_DRX_N2: length 204.2
  TOP w0.094: CI29.2 295.07,50.18 295.07,50.33 294.9,50.49 294.15,50.49 293.21,51.43 v4(290.9,51.43) 289.57,51.43 289.53,51.4 288.92,51.4 288.88,51.43 288.51,51.43 287.56,50.49 287.56,49.95 287.39,49.78 287.39,49.1 286.51,48.22 v1(286.51,48.08)
  IN2 w0.122: v1(131.93,70.55) 132.09,70.71 133.13,70.71 133.37,70.95 141.03,70.95 142.19,69.79 151.18,69.79 152.17,70.78 158.18,70.78 164.94,64.02 164.94,60.14 167.52,57.56 167.52,51.7 171.93,47.28 172.65,47.28 179.35,40.58 183.35,40.58 184.55,39.38 188.69,39.38 199.51,28.55 203.35,28.55 204.48,27.42 206.37,27.42 207.23,28.28 209.99,28.28 210.33,27.93 212.71,27.93 213.32,27.32 220.38,27.32 220.88,26.82 224.51,26.82 225.5,27.82 228.39,27.82 230.3,29.73 240.08,29.73 242.12,31.77 247.17,31.77 248.79,33.39 255.42,33.39 256.34,34.31 259.41,34.31 261.02,35.91 267.59,35.91 269.98,38.29 272.85,38.29 277.13,42.58 277.13,42.91 277.42,43.2 278.65,43.2 280.85,45.39 281.64,45.39 283.16,46.9 284.54,46.9 285.97,48.33 286.25,48.33 v1(286.51,48.08)
  BOTTOM w0.076: v1(131.93,70.55) 131.71,70.76 131.61,70.76 131.53,70.68 131.53,70.21 131.19,69.87 131.19,69.63 130.84,69.29 130.41,69.29 130.34,69.21 UC1.B13
USB3_PTX_DRX_N3: length 161.1
  TOP w0.094: v1(22.78,69.08) 22.79,69.08 23.12,69.41 23.12,69.85 22.81,70.17 22.81,71.91 22.64,72.07 22.42,72.07 22.13,71.78 CI5.2
  IN4 w0.089: v1(22.78,69.08) 22.89,68.97 22.89,68.61 23.07,68.43 39.77,68.43 43.77,72.43 43.77,76.3 45.79,78.31 50.32,78.31 51.76,79.75 54.65,79.75 57.61,82.71 57.61,83.27 61.65,87.31 61.65,89.86 66.45,94.66 72.58,94.66 74.08,96.16 76.28,96.16 82.03,101.91 85.06,101.91 86.11,102.96 86.6,102.96 87.93,104.29 91.94,104.29 93.25,105.6 109.72,105.6 117.99,97.33 117.99,91.6 122.41,87.18 126.2,87.18 127.92,85.46 129.09,85.46 129.99,84.56 129.99,80.31 130.43,79.87 130.43,78.07 131.21,77.3 131.21,77.05 130.96,76.81 130.8,76.81 v1(130.56,77.04)
  BOTTOM w0.076: 130.02,73.76 130.02,73.74 130.03,73.73 130.03,73.26 129.35,72.59 129.35,71.44 128.68,70.76 128.68,69.68 UC1.B15
  BOTTOM w0.094: v1(130.56,77.04) 130.02,76.5 130.02,73.76
USB3_PTX_DRX_N4: length 83
  TOP w0.094: v1(81.88,97.17) 81.99,97.28 81.99,97.82 82.08,97.91 82.08,99.22 CI27.2
  IN4 w0.089: v1(128.95,80.56) 128.91,80.51 128.43,80.51 127.59,81.35 127.59,82.49 125.57,84.51 125.57,85.07 124.43,86.21 121.8,86.21 121.02,86.99 120.34,86.99 119.84,87.48 119.84,88.28 115.87,92.26 115.87,95.6 113.23,98.24 113.23,99.98 108.57,104.64 94.07,104.64 92.29,102.85 88.3,102.85 83.69,98.24 82.4,98.24 81.93,97.77 81.93,97.22 v1(81.88,97.17)
  BOTTOM w0.076: UC1.C15 128.95,68.38 128.95,68.24 129.03,68.16 129.19,68.16 129.29,68.26 129.29,68.31 129.31,68.37 129.31,68.66 129.34,68.69 129.42,68.97 129.42,69.18 129.36,69.34 129.36,69.41 129.43,69.61 129.43,70.67 130.03,71.27 130.03,72.32 131.3,73.59 131.31,73.59 131.32,73.6
  BOTTOM w0.094: v1(128.95,80.56) 129.11,80.39 129.43,80.39 131.83,77.99 131.83,74.11 131.32,73.6
USB3_PTX_DRX_N6: length 213.1
  TOP w0.094: v1(296.01,56.87) 296.2,57.07 296.45,57.07 CI40.2
  IN2 w0.122: v1(296.01,56.87) 295.81,57.07 295.53,57.07 293.62,55.15 293.62,53.13 291.55,51.06 291.55,51.06 286.55,46.06 285.94,46.06 285.73,46.1 285.72,46.1 283.31,46.1 280.79,43.58 280.16,43.58 277.3,40.71 276.79,40.71 276.02,39.94 276.02,38.94 274.61,37.53 272.06,37.53 270.92,36.39 269.12,36.39 267.98,35.25 261.32,35.25 259.69,33.62 256.59,33.62 255.7,32.73 252.91,32.73 252.45,32.28 248.77,32.28 247.6,31.11 242.44,31.11 240.36,29.02 230.68,29.02 228.75,27.09 225.92,27.09 224.94,26.11 219.98,26.11 219.43,26.66 204.15,26.66 202.96,27.85 199.25,27.85 192.24,34.86 187.82,34.86 187.19,35.5 186.27,35.5 185.3,36.46 182.5,36.46 172.5,46.46 171.65,46.46 166.78,51.33 166.78,56.92 162.69,61.01 162.69,65.12 158.52,69.3 152.01,69.3 151.46,68.75 142.32,68.75 141.86,68.29 136.79,68.29 135.62,69.46 130.26,69.46 129.53,70.19 129.53,71.39 129.22,71.7 128.81,71.7 v1(128.63,71.52)
  BOTTOM w0.076: UC1.D16 128.13,68.64 128.13,69.01 128.34,69.41 128.34,71.39 128.47,71.52 v1(128.63,71.52)
USB3_PTX_DRX_P1: length 200.8
  IN4 w0.089: v1(130.98,71.12) 130.86,71.12 130.74,71.23 130.74,71.62 131.63,72.51 131.63,76.14 132.01,76.52 132.01,77.63 131.19,78.45 131.19,80.18 130.74,80.63 130.74,85.56 130.08,86.23 128.45,86.23 126.74,87.93 122.75,87.93 119.45,91.23 119.45,96.98 110.07,106.36 92.6,106.36 91.3,105.06 87.58,105.06 86.25,103.73 85.81,103.73 84.88,102.8 81.83,102.8 76.52,97.48 74.33,97.48 72.27,95.41 66.13,95.41 60.85,90.13 60.85,87.57 54.22,80.94 51.72,80.94 49.92,79.14 45.53,79.14 43.01,76.61 43.01,72.74 39.46,69.19 26.98,69.19 25.74,70.43 20.63,70.43 20.01,71.05 20.01,77.93 17.8,80.14 17.8,84.79 17.45,85.13 17.45,94.48 17.1,94.84 17.1,97.58 19.44,99.91 23.45,99.91 23.89,100.36 23.89,100.99 23.94,101.05 24.39,101.05 24.49,101.15 24.49,101.3 v1(24.29,101.5)
  BOTTOM w0.076: v1(130.98,71.12) 130.77,70.91 130.53,70.91 129.9,70.28 129.9,69.58 129.94,69.48 129.94,69.29 129.9,69.2 129.9,68.95 130.04,68.47 130.04,68.36 130.12,68.09 UC1.D13
  BOTTOM w0.094: v1(24.29,101.5) 24.09,101.3 24.09,101.21 24.49,100.81 CT113.1
USB3_PTX_DRX_P2: length 204.2
  TOP w0.094: CI30.2 295.25,50.16 295.25,50.4 294.98,50.68 294.23,50.68 293.29,51.61 291.22,51.61 291.22,51.62 290.58,51.62 290.57,51.61 v4(289.21,51.61) 288.43,51.61 287.38,50.56 287.38,50.03 287.2,49.85 287.2,49.18 286.79,48.76 v1(286.48,48.76)
  IN2 w0.122: v1(286.48,48.76) 286.28,48.56 285.87,48.56 284.44,47.13 283.06,47.13 281.55,45.62 280.75,45.62 278.56,43.43 277.32,43.43 276.9,43.01 276.9,42.67 272.75,38.52 269.88,38.52 267.5,36.14 260.92,36.14 259.32,34.54 256.24,34.54 255.33,33.62 248.7,33.62 247.07,32 242.02,32 239.99,29.96 230.21,29.96 228.29,28.05 225.41,28.05 224.42,27.06 220.97,27.06 220.48,27.55 213.42,27.55 212.8,28.16 210.43,28.16 210.09,28.51 207.13,28.51 206.28,27.65 204.58,27.65 203.45,28.78 199.61,28.78 188.78,39.61 184.64,39.61 183.44,40.81 179.45,40.81 172.75,47.52 172.03,47.52 167.75,51.79 167.75,57.66 165.17,60.23 165.17,64.11 158.27,71.01 152.07,71.01 151.08,70.02 142.28,70.02 141.12,71.18 133.28,71.18 133.04,70.94 132.09,70.94 v1(131.9,71.13)
  BOTTOM w0.076: UC1.A13 130.34,69.56 130.44,69.45 130.78,69.45 131.03,69.7 131.03,69.94 131.36,70.28 131.36,70.74 131.54,70.93 131.7,70.93 v1(131.9,71.13)
USB3_PTX_DRX_P3: length 161.1
  TOP w0.094: v1(23.36,69.08) 23.31,69.14 23.31,69.93 22.99,70.25 22.99,71.98 22.72,72.26 22.4,72.26 CI4.2
  IN4 w0.089: v1(131.07,76.41) 131.07,76.66 131.39,76.98 131.39,77.37 130.61,78.15 130.61,79.94 130.17,80.39 130.17,84.63 129.16,85.64 128,85.64 126.28,87.36 122.48,87.36 118.17,91.67 118.17,97.41 109.79,105.78 93.17,105.78 91.86,104.47 87.86,104.47 86.53,103.14 86.03,103.14 84.98,102.09 81.96,102.09 76.21,96.34 74,96.34 72.51,94.84 66.38,94.84 61.47,89.93 61.47,87.38 57.43,83.35 57.43,82.79 54.57,79.93 51.68,79.93 50.25,78.49 45.71,78.49 43.59,76.37 43.59,72.51 39.69,68.61 23.15,68.61 23.07,68.68 23.07,68.81 23.35,69.08 v1(23.36,69.08)
  BOTTOM w0.076: 130.2,73.76 130.2,73.74 130.19,73.73 130.19,73.19 129.52,72.52 129.52,71.37 128.84,70.69 128.84,70.12 128.9,70.06 129.03,70.06 129.1,69.99 129.1,69.79 129.02,69.71 UC1.A15
  BOTTOM w0.094: 130.2,73.76 130.2,76.42 130.42,76.64 130.73,76.64 130.84,76.75 130.98,76.75 131.07,76.66 v1(131.07,76.41)
USB3_PTX_DRX_P4: length 83
  TOP w0.094: v1(82.47,97.17) 82.18,97.46 82.18,97.74 82.27,97.83 82.27,99.22 CI28.2
  IN4 w0.089: v1(82.47,97.17) 82.11,97.53 82.11,97.7 82.47,98.06 83.77,98.06 88.38,102.67 92.36,102.67 94.14,104.45 108.5,104.45 113.05,99.91 113.05,98.16 115.69,95.52 115.69,92.18 119.66,88.21 119.66,87.41 120.26,86.81 120.95,86.81 121.73,86.03 124.35,86.03 125.39,85 125.39,84.44 127.41,82.42 127.41,81.27 128.35,80.33 128.59,80.33 v1(128.95,79.97)
  BOTTOM w0.076: 131.19,73.73 131.18,73.72 131.18,73.7 129.86,72.39 129.86,71.33 129.26,70.74 129.26,69.64 129.2,69.47 129.19,69.44 129.19,69.31 129.26,69.15 129.26,69 129.22,68.86 129.16,68.8 129,68.73 128.86,68.73 128.75,68.62 128.69,68.45 128.69,68.28 UC1.D15
  BOTTOM w0.094: 131.19,73.73 131.65,74.19 131.65,77.92 129.36,80.21 129.19,80.21 v1(128.95,79.97)
USB3_PTX_DRX_P6: length 213.1
  TOP w0.094: v1(296.01,57.45) 296.21,57.25 296.43,57.25 CI39.2
  IN2 w0.122: v1(296.01,57.45) 295.85,57.3 295.44,57.3 293.39,55.25 293.39,53.23 291.35,51.19 291.35,51.19 286.45,46.29 285.97,46.29 285.8,46.32 285.77,46.33 283.22,46.33 280.69,43.81 280.07,43.81 277.21,40.94 276.7,40.94 275.79,40.03 275.79,39.03 274.51,37.76 271.97,37.76 270.82,36.62 269.03,36.62 267.89,35.48 261.22,35.48 259.6,33.85 256.49,33.85 255.61,32.96 252.81,32.96 252.36,32.51 248.67,32.51 247.5,31.34 242.35,31.34 240.26,29.25 230.59,29.25 228.65,27.32 225.82,27.32 224.85,26.34 220.08,26.34 219.53,26.89 204.25,26.89 203.05,28.09 199.34,28.09 192.33,35.09 187.92,35.09 187.28,35.73 186.37,35.73 185.4,36.7 182.59,36.7 172.6,46.69 171.74,46.69 167.01,51.42 167.01,57.02 162.92,61.11 162.92,65.22 158.61,69.53 151.91,69.53 151.36,68.98 142.22,68.98 141.76,68.52 136.89,68.52 135.71,69.69 130.36,69.69 129.76,70.29 129.76,71.48 129.32,71.93 128.81,71.93 v1(128.63,72.1)
  BOTTOM w0.076: UC1.C16 128.4,68.76 128.4,69.18 128.5,69.37 128.5,70.86 129.01,71.37 129.01,71.72 v1(128.63,72.1)
USB3_PTX_L_DRX_N2: length 5.6
  TOP w0.094: v1(295.53,45.07) 295.73,45.27 295.73,45.4 295.64,45.5 295.29,45.5 295.06,45.72 295.06,45.93 294.9,46.09 LI17.3 294.74,46.49 RI30.2
  BOTTOM w0.094: JNGFF2.35 295.3,42.57 295.45,42.72 295.45,42.97 295.76,43.28 295.76,44.84 v1(295.53,45.07)
USB3_PTX_L_DRX_P2: length 5.6
  TOP w0.094: RI29.2 295.57,46.49 LI17.2 295.4,46.09 295.25,45.93 295.25,45.8 295.36,45.68 295.71,45.68 295.91,45.48 295.91,45.27 v1(296.11,45.07)
  BOTTOM w0.094: JNGFF2.37 295.8,42.58 295.64,42.74 295.64,42.89 295.94,43.2 295.94,44.9 v1(296.11,45.07)
USB3_PTX_RD_DRX_N6: length 13.2
  TOP w0.094: CI13.2 306.76,53.23 306.67,53.13 306.35,53.13 v1(306.09,53.4) ; UI5.11 304.06,57.16 304.29,57.39 304.63,57.39 304.87,57.15 v1(304.87,57.13)
  BOTTOM w0.094: v1(304.87,57.13) 305.13,57.39 305.4,57.39 305.66,57.13 307.63,57.13 309.19,55.57 309.19,55.03 309.18,55.02 309.18,54.44 309.19,54.43 309.19,53.69 308.54,53.04 v4(307.57,53.04) 306.44,53.04 v1(306.09,53.4)
USB3_PTX_RD_DRX_P6: length 13.2
  TOP w0.094: UI5.12 304.12,57.66 304.2,57.57 304.72,57.57 v1(304.87,57.71) ; CI16.2 306.76,52.68 306.5,52.95 306.22,52.95 v1(306.09,52.81)
  BOTTOM w0.094: v1(306.09,52.81) 306.12,52.85 307.28,52.85 307.28,52.85 307.86,52.85 307.87,52.85 308.62,52.85 309.38,53.61 v4(309.38,54.73) 309.38,55.64 307.71,57.31 305.74,57.31 305.47,57.58 305,57.58 v1(304.87,57.71)
USB20_N1: length 194.5
  TOP w0.076: 30.02,80.82 30.04,80.79 30.24,80.79 30.48,81.04 UT5.K5
  TOP w0.094: v1(29.41,80.94) 29.41,80.94 29.74,80.94 29.86,80.82 30.02,80.82
  IN4 w0.089: v1(29.41,80.94) 29.4,80.95 29.4,81.51 29.53,81.64 29.84,81.64 29.99,81.49 29.99,80.1 29.49,79.6 29.49,73.6 31.54,71.55 40.44,71.55 41.94,73.04 41.94,77.01 45.06,80.13 49.44,80.13 51.22,81.91 53.81,81.91 59.32,87.41 59.32,92.48 62.68,95.84 63.7,95.84 64.24,96.38 71.87,96.38 74.31,98.82 76.45,98.82 82.54,104.91 85.86,104.91 86.99,106.04 90.67,106.04 91.95,107.33 112.56,107.33 121.67,98.21 125.75,98.21 128.86,95.1 128.86,93.19 131.03,91.02 133.67,91.02 136.01,88.68 137.03,88.68 137.59,88.11 137.59,85.72 138.31,85.01 138.31,83.48 138.71,83.08 138.71,79.62 140.7,77.64 140.7,65.18 139.6,64.08 139.6,60.67 138.43,59.5 138.43,57.77 138.03,57.37 137.56,57.37 136.78,56.6 136.78,55.83 136.4,55.45 132.15,55.45 131.39,56.22 131.39,57.17 131.64,57.42 132.39,57.42 132.61,57.64 133.27,57.64 133.36,57.73 133.36,57.91 133.19,58.08 v1(133.09,58.08)
  BOTTOM w0.076: UC1.AB9 132.78,58.38 v1(133.09,58.08)
USB20_N2: length 172.1
  TOP w0.094: v1(30.76,70.5) 30.76,70.48 30.58,70.29 29.9,70.29 LI3.4
  IN4 w0.089: v1(30.76,70.5) 33.23,70.5 33.37,70.36 39.81,70.36 42.37,72.92 42.37,76.87 45.23,79.72 49.69,79.72 51.48,81.51 53.98,81.51 59.76,87.29 59.76,92.35 62.73,95.32 63.75,95.32 64.41,95.99 72.03,95.99 74.23,98.19 76.38,98.19 82.71,104.52 86.07,104.52 87.18,105.63 90.86,105.63 92.16,106.93 110.34,106.93 112.96,104.31 114.99,104.31 121.61,97.69 125.13,97.69 127.7,95.12 127.7,93.3 133.28,87.73 135.34,87.73 135.48,87.59 135.88,87.59 136.41,87.07 136.41,82.29 136.28,82.16 136.28,79.52 136.96,78.83 137.55,78.83 138.66,77.72 138.66,70.58 139.66,69.58 139.66,66.8 137.5,64.63 137.5,59.26 135.74,57.5 134.8,57.5 134.65,57.35 134.65,57.14 134.8,56.99 v1(134.99,56.99)
  BOTTOM w0.076: UC1.AD6 134.74,57.12 134.87,56.99 v1(134.99,56.99)
USB20_N2_R: length 17
  TOP w0.094: LI3.3 28.25,70.25 27.95,70.25 26.85,71.36 26.33,71.36 26.22,71.47 DI2.3 25.54,71.56 v1(25.41,71.56)
  BOTTOM w0.094: v1(25.41,71.56) 25.21,71.36 25.03,71.36 24.61,70.93 22.18,70.93 20.58,72.54 19.71,72.54 19.7,72.54 19.07,72.54 19.06,72.54 18.67,72.54 v4(17.56,73.65) 16.72,74.49 15.75,74.49 15.66,74.59 JUSB2.2
USB20_N3: length 119.9
  IN4 w0.089: v1(76.37,100.68) 76.92,100.68 77.37,101.12 77.37,102.3 80.73,105.67 85.54,105.67 86.67,106.8 90.34,106.8 91.62,108.08 112.87,108.08 121.71,99.24 126.56,99.24 130.47,95.33 130.47,92.82 131.51,91.78 136.55,91.78 138.36,89.97 138.36,86.12 139.07,85.41 139.07,84.7 139.5,84.27 139.5,79.95 141.49,77.96 141.49,64.9 140.36,63.77 140.36,57.87 141.63,56.6 141.63,55.74 140.63,54.74 139.35,54.74 139.2,54.59 139.2,54.4 139.34,54.26 v1(139.43,54.26)
  BOTTOM w0.076: v1(139.43,54.26) 139.22,54.47 139.22,54.64 138.99,54.88 137.83,54.88 137.65,54.7 137.33,54.7 137.21,54.66 137.09,54.66 136.91,54.71 136.91,54.71 136.88,54.72 136.73,54.72 136.57,54.66 136.4,54.66 136.29,54.72 136.28,54.72 135.84,54.93 UC1.AH3
  BOTTOM w0.094: v1(76.37,100.68) 76.56,100.49 76.95,100.49 77.15,100.69 LI4.4
USB20_N3_R: length 12
  BOTTOM w0.094: JUSB3.2 80.95,107.02 80.64,106.72 80.64,105.32 80.52,105.2 80.52,104.89 81.42,103.99 DI3.3 80.57,103.8 80.4,103.63 80.4,103.07 79.91,102.58 79.02,102.58 78.57,103.03 78.22,103.03 77.81,102.62 77.8,102.62 77.78,102.6 v4(77.78,101.69) 77.78,101.34 78.07,101.04 78.07,100.59 78.17,100.49 78.31,100.49 78.52,100.69 LI4.3
USB20_N4: length 204.4
  TOP w0.094: RI48.1 289.53,45.43 LI8.4 289.7,45.86 289.88,46.04 289.88,46.13 289.63,46.38 288.87,46.38 287.62,45.12 287.62,43.58 287.76,43.44 288.46,43.44 288.55,43.53 288.55,43.79 v1(288.4,43.94)
  IN2 w0.076: 136.7,56.96 136.69,56.97 136.69,57.02 136.16,57.54 132.83,57.54 132.76,57.47 132.76,57.26 133.01,57.01 v1(133.09,57.01)
  IN2 w0.122: 136.7,56.96 137.84,55.82 139.42,55.82 140.08,55.16 142.47,55.16 143.02,55.71 143.81,55.71 144.2,56.1 145.46,56.1 146.53,55.03 148.75,55.03 149.22,54.56 151.55,54.56 151.86,54.25 152.76,54.25 153.19,54.68 155.46,54.68 156.6,53.55 156.6,44.2 158.7,42.1 158.7,40.7 162.78,36.63 162.78,33.83 169.86,26.75 175.27,26.75 175.65,27.14 183.36,27.14 185.24,29.02 192.31,29.02 199.27,22.06 200.39,22.06 202.5,19.95 205.12,19.95 205.52,19.55 210.26,19.55 211.13,20.41 213.27,20.41 213.88,19.8 217.71,19.8 218.36,19.16 220.1,19.16 221.57,20.63 229.25,20.63 232.06,23.43 241.58,23.43 245.06,26.92 255.96,26.92 258.24,29.2 261.14,29.2 262.9,30.96 277.32,30.96 281.21,34.84 281.31,34.84 282.66,36.19 282.66,38.03 284.23,39.6 286.55,39.6 287.62,40.67 287.62,41.51 288.79,42.67 288.79,43.49 288.4,43.87 v1(288.4,43.94)
  BOTTOM w0.076: UC1.AD9 132.94,57.23 v1(133.09,57.01)
USB20_N4_L: length 5.5
  TOP w0.094: v1(289.73,43.13) 289.73,43.27 289.8,43.34 289.94,43.34 290.01,43.41 290.01,43.78 289.91,43.89 289.76,43.89 289.7,43.95 LI8.3 289.53,44.52 RI48.2
  BOTTOM w0.094: v1(289.73,43.13) 289.73,43.25 289.82,43.34 289.94,43.34 290.03,43.44 290.03,43.61 289.94,43.7 289.5,43.7 288.59,42.79 288.59,42.65 288.65,42.59 288.73,42.59 288.8,42.52 JNGFF2.9
USB20_N5: length 86.4
  IN4 w0.089: v1(132.53,92.37) 132.53,93.02 132.72,93.21 135.95,93.21 141.64,87.53 141.64,85.72 140.42,84.5 140.42,79.9 142.1,78.22 142.1,64.7 140.93,63.53 140.93,58.34 143.14,56.13 143.14,53.89 142.45,53.19 140.95,53.19 140.47,53.68 139.22,53.68 139.13,53.59 139.13,53.42 v1(139.3,53.26)
  BOTTOM w0.094: v1(132.53,92.37) 132.63,92.47 132.9,92.47 133.11,92.27 133.11,92.2 133.3,92.01 133.3,90.34 130.86,87.9 129.41,87.9 127.63,86.12 122.55,86.12 122.17,85.74 121.39,85.74 120.56,84.91 119.72,84.91 119.03,85.59 116.93,85.59 116.34,86.19 116.17,86.19 115.6,86.76 113.16,86.76 113.01,86.61 112.78,86.61 111.95,85.77 111.3,85.77 110.63,86.45 110.63,87.12 110.88,87.36 LZ1.1 ; UC1.AJ1 137.34,54.27 137.29,54.22 137.29,54.14 137.46,53.97 137.88,53.97 137.95,53.89 138.51,53.89 138.54,53.87 138.88,53.87 139.09,53.66 139.09,53.51 139.09,53.46 v1(139.3,53.26)
USB20_N5_R: length 3.5
  BOTTOM w0.094: JEDP1.12 110.8,91.53 110.63,91.36 110.63,89.16 110.88,88.92 LZ1.2
USB20_N7: length 85.4
  IN1 w0.089: v1(190.91,33.65) 190.93,33.65 191.24,33.96 191.24,34.05 191.16,34.14 190.59,34.14 189.16,32.71 177.75,32.71 176.2,34.25 168.86,34.25 168.3,33.7 164.37,33.7 162.64,35.43 162.64,36.39 159.77,39.26 154.31,39.26 150.38,43.19 146.16,43.19 142.52,46.83 142.52,48.1 143.65,49.23 143.65,51.62 142.14,53.13 141.01,53.13 140.78,53.36 140.78,54.23 v1(140.69,54.33)
  BOTTOM w0.076: UC1.AH1 137.2,54.87 137.4,54.87 137.45,54.92 137.45,55.14 137.49,55.18 137.68,55.18 137.72,55.14 137.72,55.09 137.77,55.04 137.94,55.04 137.97,55.07 137.97,55.15 137.99,55.18 138.22,55.18 138.25,55.15 140.58,55.15 140.98,55.15 141.11,55.02 141.11,54.8 141.03,54.72 140.61,54.72 140.53,54.65 140.53,54.49 v1(140.69,54.33)
  BOTTOM w0.094: RI50.1 196.72,23.48 LI9.1 196.32,23.64 196.17,23.79 195.73,23.79 195.37,24.15 195.37,28.47 190.91,32.93 v1(190.91,33.65)
USB20_N7_L: length 4
  BOTTOM w0.094: JNGFF1.5 200.48,23.75 200.32,23.91 199.64,23.91 199.53,23.8 v4(198.84,23.8) 198.21,23.8 198.05,23.64 LI9.2 197.63,23.48 RI50.2
USB20_N8: length 67.5
  IN4 w0.089: v1(132.07,90.57) 132.04,90.55 132.04,89.85 132.38,89.52 132.62,89.52 133.4,90.3 133.8,90.3 134.08,90.02 134.08,89.62 133.3,88.84 133.3,88.6 133.52,88.38 135.73,88.38 135.87,88.23 136.69,88.23 137.19,87.73 137.19,85.11 137.88,84.42 137.88,81.27 138.28,80.87 138.28,79.44 140.3,77.42 140.3,76.82 140.02,76.54 139.44,76.54 139.27,76.36 139.27,76.11 139.44,75.94 140.02,75.94 140.3,75.66 140.3,75.26 140.02,74.98 139.44,74.98 139.27,74.81 139.27,74.56 139.44,74.38 140.02,74.38 140.3,74.1 140.3,73.71 140.02,73.43 139.44,73.43 139.27,73.25 139.27,73 139.44,72.83 140.02,72.83 140.3,72.55 140.3,71.95 140.02,71.67 139.28,71.67 139.1,71.49 139.1,71.25 139.28,71.07 140.02,71.07 140.3,70.79 140.3,65.34 139.15,64.18 139.15,61.16 138.02,60.02 138.02,58.85 135.6,56.43 133.03,56.43 132.91,56.31 132.91,56.04 133.01,55.94 v1(133.2,55.94)
  BOTTOM w0.094: UC1.AF8 133.3,56.4 133.2,56.31 v1(133.2,55.94) ; LV27.3 122.27,86.87 122.32,86.82 127.37,86.82 130.07,89.52 130.07,90.67 130.77,91.37 131.52,91.37 131.9,90.99 131.9,90.75 v1(132.07,90.57)
USB20_N8_R: length 10.5
  BOTTOM w0.094: LV27.4 120.44,86.64 120.22,86.64 119.97,86.89 119.97,87.1 119.68,87.39 119.42,87.39 DV4.2 118.52,87.48 118.43,87.39 117.95,87.39 117.1,88.24 117.1,89.43 115.49,91.05 115.49,91.3 115.58,91.4 115.73,91.4 115.8,91.46 JEDP1.2
USB20_N9: length 228.1
  TOP w0.094: v1(303.08,64.8) 302.96,64.69 302.96,64.43 303.54,63.85 304.46,63.85 304.93,63.39 308.06,63.39 308.68,62.77 308.68,62.47 308.99,62.16 UI3.2
  IN2 w0.122: v1(139.69,56.53) 139.34,56.89 139.34,57.2 139.5,57.36 140.46,57.36 141.28,56.53 143.69,56.53 144.12,56.96 150.68,56.96 152.08,55.56 155.57,55.56 157.28,53.85 157.28,44.54 161.13,40.69 161.13,39.74 163.86,37.01 163.86,35.75 165.25,34.36 165.25,32.51 169.47,28.3 182.19,28.3 183.58,29.69 192.59,29.69 199.38,22.9 201.33,22.9 203.03,21.2 205.07,21.2 205.5,20.77 210.06,20.77 211.59,22.29 214.46,22.29 215.86,20.9 217.74,20.9 218.82,19.82 219.83,19.82 221.3,21.28 226.31,21.28 227.23,22.2 229.38,22.2 231.3,24.12 241.28,24.12 244.78,27.63 254.05,27.63 255.24,28.82 256.92,28.82 257.96,29.86 260.73,29.86 262.54,31.67 276.54,31.67 280.35,35.48 280.35,35.94 280.94,36.53 280.94,37.75 281.49,38.3 281.49,39.42 281.79,39.72 282.1,39.72 282.2,39.61 283.3,39.61 283.96,40.27 284.76,40.27 285.02,40.53 285.02,40.88 285.69,41.55 285.69,42.14 288.44,44.89 290.31,44.89 292.08,46.66 292.08,48.79 294.94,51.64 294.94,52.72 295.67,53.46 296.27,53.46 297.8,54.99 297.8,58.55 300.2,60.96 300.2,62.42 301.12,63.34 302.35,63.34 303.03,64.02 303.03,64.75 v1(303.08,64.8)
  BOTTOM w0.076: v1(139.69,56.53) 139.64,56.53 139.51,56.41 139.51,56.14 139.26,55.89 137.42,55.89 137.29,55.78 137.29,55.64 137.34,55.6 UC1.AG1
USB20_N9_R: length 9.8
  TOP w0.094: v1(308.83,49.73) 308.83,49.41 DI5.2 308.72,48.74 309.04,48.42 309.04,48.1 308.65,47.71 308.65,47.4 308.44,47.19 LI7.2
  IN1 w0.089: v1(308.83,49.73) 308.98,49.58 308.98,49.2 309.2,48.99 311.09,48.99 311.76,49.65 313.02,49.65 313.1,49.57 JUSB1.2
USB20_N10: length 131.9
  TOP w0.094: v1(225.53,17.81) 225.28,17.56 225.28,12.13 223.8,10.65 JUSH1.8
  IN2 w0.076: v1(134.36,54.88) 134.16,54.88 134.01,55.02 134.01,55.21 134.18,55.39 135.81,55.39 135.84,55.35 135.86,55.35
  IN2 w0.122: v1(225.53,17.81) 225.34,17.62 225.34,17.26 225.06,16.98 222.9,16.98 221.96,17.92 220.27,17.92 219.53,17.19 217.94,17.19 217.03,18.1 215.94,18.1 215.3,18.74 210.38,18.74 209.87,18.23 207,18.23 206.51,18.71 202.17,18.71 200.43,20.45 199.89,20.45 192.66,27.68 187.13,27.68 185.93,26.48 176.34,26.48 175.61,25.76 169.92,25.76 161,34.68 161,37.14 157.89,40.25 157.89,41.9 155.07,44.71 155.07,48.08 154.38,48.77 154.38,51.89 155.24,52.74 155.24,53.64 155.09,53.79 154.02,53.79 153.14,52.91 152.25,52.91 151.28,53.88 148.54,53.88 148.06,54.35 146.08,54.35 145.19,55.24 144.47,55.24 142.24,53 140.71,53 139.97,53.74 139.97,54.32 139.38,54.91 137.5,54.91 137.05,55.35 135.86,55.35
  BOTTOM w0.094: v1(134.36,54.88) UC1.AH7
USB20_P1: length 194.5
  TOP w0.094: UT5.L5 29.9,81.04 29.56,81.38 29.48,81.38 29.37,81.49 29.13,81.49 v1(29,81.36)
  IN4 w0.089: v1(29,81.36) 29.46,81.82 29.92,81.82 30.17,81.57 30.17,80.03 29.67,79.53 29.67,73.67 31.61,71.73 40.37,71.73 41.76,73.12 41.76,77.08 44.99,80.31 49.37,80.31 51.15,82.09 53.74,82.09 59.14,87.48 59.14,92.55 62.6,96.02 63.62,96.02 64.16,96.56 71.79,96.56 74.23,99 76.38,99 82.47,105.09 85.78,105.09 86.91,106.22 90.6,106.22 91.88,107.51 112.63,107.51 121.75,98.39 125.82,98.39 129.04,95.17 129.04,93.26 131.11,91.2 133.74,91.2 136.08,88.86 137.11,88.86 137.77,88.19 137.77,85.79 138.49,85.08 138.49,83.56 138.89,83.15 138.89,79.7 140.88,77.71 140.88,65.1 139.78,64.01 139.78,60.6 138.61,59.43 138.61,57.7 138.1,57.19 137.63,57.19 136.96,56.52 136.96,55.76 136.48,55.27 132.07,55.27 131.21,56.14 131.21,57.24 131.57,57.6 132.32,57.6 132.45,57.74 v1(132.45,58.08)
  BOTTOM w0.076: v1(132.45,58.08) UC1.AB10
USB20_P2: length 172
  TOP w0.094: v1(30.77,69.86) 30.77,69.87 30.59,70.05 29.97,70.05 29.79,69.87 LI3.1
  IN4 w0.089: v1(134.31,56.99) 134.47,57.15 134.47,57.43 134.72,57.68 135.66,57.68 137.31,59.33 137.31,64.71 139.48,66.88 139.48,69.5 138.48,70.51 138.48,77.65 137.47,78.65 136.89,78.65 136.1,79.45 136.1,82.24 136.23,82.36 136.23,86.99 135.81,87.41 135.4,87.41 135.26,87.55 133.2,87.55 127.52,93.23 127.52,95.05 125.06,97.51 121.53,97.51 114.92,104.13 112.89,104.13 110.26,106.75 92.24,106.75 90.94,105.45 87.25,105.45 86.14,104.34 82.79,104.34 76.46,98.01 74.31,98.01 72.11,95.81 64.49,95.81 63.82,95.14 62.81,95.14 59.94,92.27 59.94,87.22 54.05,81.33 51.55,81.33 49.76,79.54 45.3,79.54 42.55,76.79 42.55,72.84 39.89,70.18 33.3,70.18 33.15,70.32 31.75,70.32 31.66,70.23 31.66,70.15 31.58,70.06 31.4,70.06 31.31,70.15 31.31,70.23 31.22,70.32 31.15,70.32 31.07,70.25 31.07,70.24 30.75,69.92 30.75,69.87 v1(30.77,69.86)
  BOTTOM w0.076: v1(134.31,56.99) 134.31,57.24 UC1.AD7
USB20_P2_R: length 17
  TOP w0.094: v1(25.41,70.97) 25.54,70.97 DI2.2 26.22,71.06 26.33,71.17 26.77,71.17 27.88,70.06 28.28,70.06 LI3.2
  BOTTOM w0.094: v1(25.41,70.97) 25.21,71.17 25.11,71.17 24.69,70.75 22.11,70.75 20.5,72.35 v4(19.39,72.35) 18.6,72.35 18.29,72.66 17.65,73.29 17.64,73.29 17.18,73.76 17.18,73.77 16.64,74.31 15.75,74.31 15.66,74.21 JUSB2.3
USB20_P3: length 119.8
  IN4 w0.089: v1(76.37,100.09) 76.78,100.5 77,100.5 77.55,101.05 77.55,102.23 80.81,105.49 85.61,105.49 86.74,106.62 90.42,106.62 91.7,107.9 112.8,107.9 121.64,99.06 126.49,99.06 130.29,95.26 130.29,92.74 131.44,91.6 136.48,91.6 138.18,89.89 138.18,86.05 138.89,85.34 138.89,84.62 139.32,84.19 139.32,79.87 141.31,77.89 141.31,64.97 140.18,63.84 140.18,57.8 141.44,56.53 141.44,55.81 140.55,54.92 139.27,54.92 139.02,54.67 139.02,54.49 138.8,54.26 v1(138.65,54.26)
  BOTTOM w0.076: v1(138.65,54.26) 138.72,54.2 138.87,54.2 139.04,54.37 139.04,54.59 138.92,54.71 137.9,54.71 137.72,54.54 137.36,54.54 137.24,54.49 137.07,54.49 136.87,54.55 136.85,54.55 136.76,54.55 136.6,54.5 136.36,54.5 136.28,54.54 136.11,54.48 136.06,54.37 136.15,54.27 UC1.AJ3
  BOTTOM w0.094: v1(76.37,100.09) 76.58,100.3 76.99,100.3 77.2,100.09 LI4.1
USB20_P3_R: length 12
  BOTTOM w0.094: LI4.2 78.49,100.09 78.28,100.3 78.1,100.3 77.89,100.51 77.89,100.97 77.59,101.26 77.59,101.4 77.59,101.4 77.59,101.98 77.59,101.99 77.59,102.68 v4(77.88,102.96) 78.14,103.22 78.64,103.22 79.1,102.76 79.84,102.76 80.22,103.14 80.22,103.65 80.07,103.8 DI3.2 79.49,104.02 80.34,104.86 80.34,105.28 80.46,105.4 80.46,106.71 80.15,107.02 JUSB3.3
USB20_P4: length 204.4
  TOP w0.094: v1(288.03,43.02) 288.03,43.02 287.8,43.25 287.69,43.25 287.43,43.51 287.43,45.2 288.8,46.56 289.7,46.56 290.06,46.2 290.06,46.01 290.2,45.88 LI8.1 290.36,45.43 RI47.1
  IN2 w0.076: v1(132.45,57.01) 132.59,57.15 132.59,57.53 132.77,57.71 136.23,57.71 136.8,57.13 136.85,57.13 136.86,57.12
  IN2 w0.122: 136.86,57.12 137.93,56.05 139.52,56.05 140.18,55.39 142.37,55.39 142.92,55.94 143.71,55.94 144.1,56.33 145.56,56.33 146.62,55.26 148.85,55.26 149.32,54.79 151.64,54.79 151.96,54.48 152.66,54.48 153.09,54.91 155.56,54.91 156.83,53.64 156.83,44.3 158.94,42.19 158.94,40.8 163.01,36.72 163.01,33.92 169.95,26.98 175.17,26.98 175.56,27.37 183.26,27.37 185.15,29.25 192.41,29.25 199.37,22.29 200.48,22.29 202.59,20.19 205.21,20.19 205.62,19.78 210.17,19.78 211.03,20.64 213.37,20.64 213.97,20.04 217.81,20.04 218.45,19.39 220.01,19.39 221.47,20.86 229.15,20.86 231.96,23.67 241.49,23.67 244.97,27.15 255.86,27.15 258.15,29.43 261.04,29.43 262.8,31.19 277.23,31.19 281.11,35.07 281.21,35.07 282.43,36.29 282.43,38.12 284.13,39.83 286.45,39.83 287.39,40.76 287.39,41.6 288.55,42.77 288.55,43.39 288.43,43.52 288.15,43.52 288.03,43.4 v1(288.03,43.02)
  BOTTOM w0.076: v1(132.45,57.01) 132.3,57.23 UC1.AD10
USB20_P4_L: length 5.5
  TOP w0.094: v1(290.31,43.13) 290.2,43.25 LI8.2 290.36,44.52 RI47.2
  BOTTOM w0.094: JNGFF2.7 288.3,42.54 288.41,42.65 288.41,42.87 289.42,43.88 290.02,43.88 290.22,43.68 290.22,43.23 v1(290.31,43.13)
USB20_P5: length 86.3
  IN4 w0.089: v1(138.6,53.27) 138.95,53.62 138.95,53.66 139.15,53.86 140.54,53.86 141.03,53.37 142.37,53.37 142.96,53.97 142.96,56.05 140.75,58.27 140.75,63.6 141.92,64.77 141.92,78.14 140.24,79.83 140.24,84.57 141.46,85.8 141.46,87.45 135.88,93.03 132.8,93.03 132.71,92.94 132.71,92.76 133.08,92.38 v1(133.49,92.38)
  BOTTOM w0.094: v1(138.6,53.27) 138.87,53.54 138.87,53.62 138.81,53.68 138.47,53.68 138.44,53.71 137.88,53.71 137.8,53.78 137.38,53.78 136.98,54.19 UC1.AJ2 ; v1(133.49,92.38) 133.49,92.36 133.48,92.35 133.48,90.26 130.94,87.72 129.49,87.72 127.7,85.93 122.62,85.93 122.25,85.56 121.47,85.56 120.64,84.73 119.64,84.73 118.96,85.41 116.86,85.41 116.26,86 116.09,86 115.52,86.57 113.24,86.57 113.09,86.42 112.86,86.42 112.02,85.59 111.23,85.59 110.45,86.37 110.45,87.21 110.28,87.38 LZ1.4
USB20_P5_R: length 3.5
  BOTTOM w0.094: LZ1.3 110.28,88.89 110.45,89.06 110.45,91.37 110.3,91.51 JEDP1.13
USB20_P7: length 85.4
  IN1 w0.089: v1(141.27,54.33) 140.96,54.02 140.96,53.43 141.09,53.31 142.22,53.31 143.83,51.7 143.83,49.15 142.7,48.03 142.7,46.9 146.24,43.37 150.46,43.37 154.38,39.44 159.85,39.44 162.82,36.47 162.82,35.5 164.44,33.88 168.23,33.88 168.79,34.44 176.28,34.44 177.82,32.89 189.08,32.89 190.51,34.32 191.23,34.32 191.42,34.13 191.42,33.73 v1(191.5,33.65)
  BOTTOM w0.076: v1(141.27,54.33) 141.27,55.09 141.05,55.31 140.51,55.31 138.32,55.31 138.29,55.34 137.42,55.34 137.24,55.29 136.52,54.92 UC1.AH2
  BOTTOM w0.094: RI49.1 196.72,24.31 LI9.4 196.29,24.14 196.13,23.98 195.81,23.98 195.56,24.22 195.56,28.55 191.1,33.01 191.1,33.27 191.32,33.48 191.32,33.6 191.37,33.65 v1(191.5,33.65)
USB20_P7_L: length 4
  BOTTOM w0.094: RI49.2 197.63,24.31 LI9.3 198.05,24.14 198.21,23.98 198.51,23.98 198.54,24.01 199.13,24.01 199.16,23.98 199.45,23.98 199.56,24.09 200.36,24.09 200.51,24.25 JNGFF1.3
USB20_P8: length 67.5
  IN4 w0.089: v1(132.55,55.94) 132.73,56.12 132.73,56.39 132.95,56.61 135.52,56.61 137.84,58.92 137.84,60.1 138.97,61.23 138.97,64.26 140.12,65.41 140.12,70.72 139.95,70.89 139.2,70.89 138.92,71.17 138.92,71.57 139.2,71.85 139.95,71.85 140.12,72.02 140.12,72.47 139.95,72.65 139.37,72.65 139.09,72.93 139.09,73.33 139.37,73.61 139.95,73.61 140.12,73.78 140.12,74.03 139.95,74.2 139.37,74.2 139.09,74.48 139.09,74.88 139.37,75.16 139.95,75.16 140.12,75.34 140.12,75.58 139.95,75.76 139.37,75.76 139.09,76.04 139.09,76.44 139.37,76.72 139.95,76.72 140.12,76.89 140.12,77.35 138.1,79.37 138.1,80.79 137.7,81.2 137.7,84.35 137.01,85.03 137.01,87.66 136.61,88.05 135.79,88.05 135.65,88.2 133.44,88.2 133.12,88.52 133.12,88.92 133.9,89.7 133.9,89.94 133.72,90.12 133.48,90.12 132.7,89.34 132.3,89.34 131.86,89.78 131.86,90.13 131.43,90.57 v1(131.37,90.57)
  BOTTOM w0.094: v1(132.55,55.94) 132.78,56.17 UC1.AF9 ; LV27.2 122.03,86.27 122.39,86.63 127.45,86.63 130.26,89.44 130.26,90.59 130.85,91.18 131.44,91.18 131.71,90.91 131.71,90.76 131.52,90.57 v1(131.37,90.57)
USB20_P8_R: length 10.5
  BOTTOM w0.094: LV27.1 120.48,86.45 120.15,86.45 119.79,86.81 119.79,87.02 119.61,87.2 119.36,87.2 DV4.3 118.52,87.14 118.46,87.2 117.87,87.2 116.92,88.16 116.92,89.35 115.3,90.97 JEDP1.3
USB20_P9: length 228.1
  TOP w0.094: UI3.3 308.49,62.69 307.98,63.2 304.85,63.2 304.39,63.66 303.46,63.66 302.71,64.42 302.71,64.52 302.42,64.81 v1(302.39,64.81)
  IN2 w0.122: v1(139.11,56.55) 139.11,57.29 139.4,57.59 140.55,57.59 141.38,56.76 143.59,56.76 144.02,57.19 150.78,57.19 152.18,55.79 155.67,55.79 157.51,53.95 157.51,44.63 161.36,40.79 161.36,39.83 164.09,37.1 164.09,35.85 165.49,34.45 165.49,32.61 169.56,28.53 182.1,28.53 183.48,29.92 192.69,29.92 199.47,23.13 201.42,23.13 203.12,21.43 205.16,21.43 205.59,21 209.96,21 211.49,22.52 214.56,22.52 215.95,21.13 217.83,21.13 218.91,20.05 219.73,20.05 221.2,21.52 226.22,21.52 227.14,22.43 229.28,22.43 231.2,24.35 241.18,24.35 244.69,27.86 253.96,27.86 255.15,29.05 256.82,29.05 257.87,30.09 260.64,30.09 262.44,31.9 276.44,31.9 280.12,35.57 280.12,36.04 280.71,36.63 280.71,37.84 281.26,38.39 281.26,39.51 281.7,39.95 282.2,39.95 282.3,39.85 283.21,39.85 283.87,40.51 284.67,40.51 284.79,40.63 284.79,40.98 285.46,41.65 285.46,42.24 288.35,45.12 290.22,45.12 291.85,46.75 291.85,48.88 294.7,51.73 294.7,52.82 295.57,53.69 296.17,53.69 297.57,55.08 297.57,58.65 299.97,61.05 299.97,62.52 301.02,63.57 302.25,63.57 302.8,64.11 302.8,64.41 v1(302.39,64.81)
  BOTTOM w0.076: UC1.AG2 137.13,55.85 137.13,55.86 137.36,56.06 139.19,56.06 139.32,56.19 139.32,56.28
  BOTTOM w0.094: 139.32,56.28 139.32,56.33 v1(139.11,56.55)
