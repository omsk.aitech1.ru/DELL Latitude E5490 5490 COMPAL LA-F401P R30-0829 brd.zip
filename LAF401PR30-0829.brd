# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCD_VCC_TEST_EN: length 289
  TOP w0.102: UE1.E1 298.33,71.49 v1(298.33,70.2)
  IN3 w0.122: v1(92.61,89.53) 92.61,89.66 95.19,92.24 118.75,92.24 122.13,88.86 126.25,88.86 129.06,91.66 138.56,91.66 139.28,90.95 151.54,90.95 160.41,82.08 160.41,69.44 162.54,67.31 162.54,62.07 181.67,42.94 184.94,42.94 188.6,39.28 188.6,38.21 188.99,37.83 191.89,37.83 199.88,29.84 200.26,29.84 200.39,29.71 202.72,29.71 205.18,27.25 207.2,27.25 209.14,25.32 210.31,25.32 211.75,23.87 212.58,23.87 213.11,24.4 215.96,24.4 216.27,24.08 221.26,24.08 222.91,22.43 230.17,22.43 231.52,23.78 238.83,23.78 243.8,28.75 247.85,28.75 249.87,30.76 257.95,30.76 259.21,32.02 277.37,32.02 280.78,35.43 281.41,35.43 282.57,36.58 282.57,40.74 283.62,41.79 283.62,44.61 283.8,44.79 286.81,44.79 289.02,47 289.02,48.68 291.51,51.17 293.06,51.17 293.92,52.04 293.92,53.18 294.3,53.56 294.3,55.16 295.25,56.11 295.25,58.25 295.5,58.5 295.5,59.91 296.09,60.5 296.09,61.21 298,63.11 298,63.57 298.94,64.51 298.94,69.59 v1(298.33,70.2)
  BOTTOM w0.102: DV3.2 v2(92.32,87.95) 92.32,89.23 v1(92.61,89.53)
LED_10_GRN#: length 3.8
  TOP w0.102: QL2.6 280.1,99.46 280.17,99.52 RL19.1 279.74,100.96 279.74,102.5 v2(279.73,102.51)
LED_10_GRN_R#: length 44.7
  TOP w0.102: RL19.2 v1(280.17,102.25) 282.58,102.25 v3(282.71,102.13)
  IN3 w0.122: JLOM1.11 302.49,103.31 305.42,103.31 306.43,102.3 306.43,98.83 304.33,96.73 284.67,96.73 283.7,97.7 283.7,101.59 283.03,102.25 v1(280.17,102.25)
LED_100_ORG#: length 3.1
  TOP w0.102: v2(284.17,99.08) 284.06,98.97 QL1.3 282.82,98.97 282.38,99.41 RL20.1
LED_100_ORG_R#: length 37.2
  TOP w0.102: v1(283.29,99.77) RL20.2 283.29,100.55 283.47,100.73 v3(284.49,100.73)
  IN3 w0.122: JLOM1.13 305.44,104.58 306.66,103.36 306.66,98.73 304.4,96.47 284.55,96.47 283.29,97.73 v1(283.29,99.77)
LED_MASK#: length 83.8
  TOP w0.102: UZ10.1 279.93,49.41 283.65,53.13 283.65,54.83 283.47,55.01 283.47,56.09 283.7,56.32 283.7,58.16 285.42,59.89 288.75,59.89 288.93,60.07 290.34,60.07 v2(290.77,60.5) 291.49,61.22 293.49,61.22 294.65,62.38 294.65,65.68 295.38,66.42 v1(295.55,66.42) 295.55,65.88 295.99,65.44 296.32,65.44 296.93,66.05 297.25,66.05 298.18,65.12 298.43,65.12 RE21.1 ; UE1.A12 295.56,80.93 294.59,81.89 294.59,82.99 294.34,83.24 v1(293.86,83.24) ; QL2.2 v1(279.15,98.32) ; QL1.5 281.88,98.32 v1(282.13,98.56) 282.91,98.56 QL1.2
  IN1 w0.089: v1(293.86,83.24) 293.86,83.18 292.89,82.21 292.89,79.44 293.62,78.71 293.62,75.38 293.39,75.15 293.39,73.56 292.99,73.17 292.99,70.88 293.51,70.37 293.51,69.3 294.77,68.03 294.77,67.29 295.55,66.51 v1(295.55,66.42)
  IN3 w0.122: v1(279.15,98.32) 279.39,98.56 v1(282.13,98.56) 282.72,98.56 282.96,98.32 282.96,97.62 284.42,96.16 285.22,96.16 288.74,92.64 290.79,92.64 292.23,91.2 292.23,86.11 293.86,84.48 v1(293.86,83.24)
LG1_ISL9538: length 7.8
  IN1 w0.762: 21.44,20.39 21.44,22.52 19.51,24.45 16.54,24.45
  vias: v1(15.83,24.78) v1(15.85,24.15) v1(20.53,19.63) v1(20.96,20.03) v2(21.47,20.34)
LG2_ISL9538: length 11.5
  TOP w0.102: v1(21.85,18.5) 21.89,18.5 v2(22.51,19.12)
  IN1 w0.762: 32.36,20.92 24.26,20.92 22.48,19.14
  vias: v1(21.34,18.12) v1(33.38,21.61) v1(33.38,21)
LID_CL#: length 86
  TOP w0.102: UZ10.2 279.28,48.75 279.06,48.53 278.46,48.53 278.28,48.71 277.95,48.71 277.72,48.49 277.72,48.06 277.88,47.9 280.33,47.9 281.53,46.7 282.96,46.7 283.51,47.25 283.51,48.23 285.69,50.41 286.09,50.41 286.4,50.73 JLED1.5 286.4,52.26 v1(285.68,52.98) ; v3(311.23,86.45) 310.82,86.86 v1(309.99,86.86) 309.96,86.84 RE26.1
  IN4 w0.089: v1(309.99,86.86) 313.29,86.86 318.95,81.2 318.95,74.42 317.45,72.92 314.28,72.92 313.09,74.11 310.01,74.11 308.55,72.65 304.59,72.65 304.18,72.24 304.18,70.43 303.88,70.13 303.32,70.13 302.82,69.64 302.82,68.2 302.33,67.71 302.33,66.95 302.14,66.76 301.34,66.76 301.02,66.44 301.02,65.59 299.32,63.89 298.62,63.89 296.26,61.52 296.26,60.9 294.91,59.56 294.19,59.56 292.36,57.73 292.36,57.01 292.01,56.66 288.12,56.66 286.95,55.49 286.01,55.49 285.22,54.7 285.22,53.43 v1(285.68,52.98)
LID_CL#_PCH: length 12.9
  BOTTOM w0.076: UC1.AW7 133.71,48.85 134.03,48.54 134.03,47.13 134.9,46.26 135.23,46.26
  BOTTOM w0.102: 135.23,46.26 135.56,46.26 136.19,45.63 137.36,45.63 139.95,43.05 141.58,43.05 T268.1
LID_CL_SIO#: length 8
  TOP w0.102: RE26.2 308.55,85.22 RE25.2 307.87,84.54 307.85,84.54 CE8.1 307.46,83.5 v2(307.73,83.22) 307.73,81.96 305.7,79.93 UE1.N11
LINE1_L: length 6
  TOP w0.203: UA1.22 301,31.86 301.34,31.52 301.96,31.52
  TOP w0.381: 301.96,31.52 303.09,31.52 303.66,30.94 305.12,30.94 305.63,30.43 CA43.1
LINE1_R: length 4
  TOP w0.203: v2(302.28,30.88) 301.51,30.88 300.6,31.8 UA1.21
  TOP w0.381: CA44.1 303.28,30.29 302.68,30.88 v2(302.28,30.88)
LM393_P: length 107.4
  TOP w0.102: PR950.2 v2(30.71,27.95) 30.43,27.95 30.03,28.35 v1(30.03,29.93) 30.04,29.94 PC949.2 30.74,30.4 30.49,30.65 PU903.5
  IN1 w0.254: v1(65.64,106.71) 65.64,103.8 61.52,99.69 61.52,92.78 61.73,92.58 61.73,90.41 56.78,85.46 55.65,85.46 55.08,84.89 v1(55.08,84)
  IN2 w0.254: v1(30.03,29.93) 30.23,30.13 30.23,35.39 29.79,35.83 29.79,38.25 29.41,38.63 29.41,41.04 28.9,41.55 28.9,47.07 27.95,48.02 27.95,49.41 26.37,50.98 26.37,52.29 28.17,54.09 28.78,54.09 29.22,54.53 29.22,58.01 34.02,62.8 34.02,64.23 46.64,76.85 48.52,76.85 55.08,83.42 v1(55.08,84)
  BOTTOM w0.254: PC1201.2 65.76,106.84 v1(65.64,106.71) 65.5,106.58 PD1801.1 66.13,106.23 66.63,106.23 66.92,105.94 PU1201.8
LOM_ACTLED_YEL#: length 17.6
  TOP w0.102: v1(282.46,97.95) 282.74,97.67 QL1.1 284.03,97.67 v2(284.17,97.81) ; UL1.26 274.54,87.42 274.25,87.71 274.25,88.68 v1(274.81,89.24)
  IN4 w0.089: v1(282.46,97.95) 282.35,98.06 281.18,98.06 275.08,91.95 275.08,89.51 v1(274.81,89.24)
LOM_CABLE_DETECT#: length 62.5
  TOP w0.102: UL2.4 272.09,90.33 272.23,90.47 272.23,90.81 272.03,91.01 v1(271.72,91.01) v2(270.91,91.01) 270.9,91.02 RE505.1
  TOP w0.107: v1(297.34,70.19) 297.42,70.27 297.42,71.42 297.58,71.58 297.58,72.34 UE1.D2
  IN3 w0.122: v1(280.07,72.96) 280.24,73.13 280.24,75.84 283.41,79 283.41,79.35 284.11,80.05 284.11,81.09 281.69,83.51 281.69,86.89 282.83,88.03 282.83,89.7 280.57,91.97 274.07,91.97 272.8,90.69 272.04,90.69 v1(271.72,91.01)
  IN4 w0.089: v1(280.07,72.96) 280.07,69.03 282.14,66.97 284.11,66.97 284.98,67.83 291.85,67.83 292.49,68.47 293.91,68.47 294.42,68.98 296.13,68.98 v1(297.34,70.19)
LOM_SPD10LED_GRN#: length 24.9
  TOP w0.102: UL1.25 275.29,89.42 274.97,89.74 v2(274.68,89.74) 273.68,89.74 UL2.2 273.18,89.68 273.09,89.59 v1(272.46,89.59) ; QL2.1 278.2,100.03 278.26,100.09 RL30.2 278.14,100.65 v1(277.55,100.65)
  IN4 w0.089: v1(277.55,100.65) 280.69,100.65 281.06,100.28 281.06,98.46 272.46,89.86 v1(272.46,89.59)
LOM_SPD100LED_ORG#: length 22.2
  TOP w0.102: v1(271.48,89.69) 271.81,89.69 272.46,89.03 UL2.1 273.62,88.04 v2(273.74,87.93) 274.53,87.14 275.17,87.14 UL1.27 ; v1(280.68,99.9) 280.68,99.97 281.23,100.53 RL29.2 281.31,99.59 281.25,99.52 QL1.4
  IN4 w0.089: v1(280.68,99.9) 280.68,98.57 271.79,89.69 v1(271.48,89.69)
LPS_PROTECT#: length 1.7
  TOP w0.102: PT1.1 71.61,111.31 71.61,110.77 71.1,110.26 PR1248.2
LPSS_UART2_RXD: length 11.3
  BOTTOM w0.076: UC1.AD1 137.72,57.18 139.32,57.18
  BOTTOM w0.102: 139.32,57.18 139.7,57.56 v2(141.74,57.56) 142.12,57.56 144.07,55.61 144.54,55.61 145.1,55.05 145.1,54.23 RC402.1 RC330.1
LPSS_UART2_TXD: length 11.1
  BOTTOM w0.076: 139.25,57.39 139.21,57.35 137.65,57.35 137.5,57.19 137.09,57.19 UC1.AD2
  BOTTOM w0.102: 139.25,57.39 139.65,57.79 141.19,57.79 141.33,57.93 142.09,57.93 143.08,56.95 v2(143.67,56.95) 145.1,55.52 RC331.1 RC403.1
LX1_ISL9538: length 22
  TOP w1.016: 18.65,25.95 20.91,25.95 v3(21.62,25.24) 22.36,24.5 22.36,22.6
  IN4 w0.508: v1(15.85,25.65) 16.14,25.65 16.87,24.92 16.87,23.87 16.41,23.41 15.12,23.41 14.27,24.26 13.02,24.26 12.04,23.28 8.51,23.28 7.85,23.94 7.85,25.19 8.26,25.6 v1(8.77,25.6)
  BOTTOM w0.508: PQ905.2 8.84,25.6 v1(8.77,25.6)
  vias: v1(15.88,26.31)
LX2_ISL9538: length 22.2
  TOP w0.762: PR924.1 28.26,23.7 28.26,23.7 v3(25.85,21.29) 23.5,18.94
  IN4 w0.508: v1(31.5,21.89) 32.36,22.75 34.3,22.75 34.9,22.14 34.9,15.74 33.96,14.8 v1(31.35,14.8)
  BOTTOM w0.508: v1(31.35,14.8) PQ904.2
  vias: v1(29.81,24.06) v1(29.81,23.42)
LX_1.8VALW: length 1.5
  TOP w0.102: v2(127.13,103.78) 126.83,104.08 PR502.1
LX_1V_PRIM: length 1.1
  TOP w0.102: 128.25,107.18 v2(128.25,106.06)
LX_1VS_VCCIO: length 1.3
  TOP w0.102: PR405.1 v2(138.14,104.05)
LX_3V:
  vias: v1(155.95,107.84) v1(156.26,104.54) v1(156.65,107.73) v1(156.86,114.14) v1(156.86,113.56) v1(156.98,104.54) v1(157.15,109.55) v1(157.15,108.89) v1(157.28,108.08) v1(157.7,104.55) v1(157.76,109.56) v1(157.76,108.9) v1(157.86,107.71) v1(158.39,104.54) v2(157.46,106.42)
LX_5V: length 1.6
  BOTTOM w0.102: PR112.1 v2(160.61,110.66)
  vias: v1(166.1,111.88) v1(166.12,116.25) v1(166.4,116.78) v1(166.78,111.88)
LX_DDR:
  vias: v1(52.41,47.82) v1(53,47.82) v2(52.76,47.3)
M2280_DEVSLP: length 211.5
  TOP w0.102: v1(296.42,25.24) 296.42,25.82 v2(296.18,26.07) 294.91,27.34 RN37.2
  IN1 w0.089: v1(138.59,64.23) 140.01,64.23 141,65.22 144.07,65.22 144.51,64.79 150.75,64.79 152.65,62.89 154.38,62.89 157.04,60.23 157.04,48.22 161.79,43.48 v1(162.34,43.48)
  IN3 w0.122: v1(296.42,25.24) 295.92,24.73 267.63,24.73 266.76,23.86 262.51,23.86 261.65,22.99 257.38,22.99 255.64,21.25 248.54,21.25 234.9,7.61 221.45,7.61 220.73,8.34 217.85,8.34 216.84,9.35 211.83,9.35 209.33,11.86 209.33,12.58 203.98,17.93 201.74,17.93 201.05,18.62 199.08,18.62 198.72,18.26 195.56,18.26 193.96,19.87 193.96,22.77 192.38,24.35 190.73,24.35 190.43,24.05 187.88,24.05 186.08,25.85 183.22,25.85 182.29,26.78 181.78,26.78 179.2,29.35 179.2,31.58 175.86,34.92 173.26,34.92 167.89,40.28 v1(167.89,41.7)
  BOTTOM w0.102: v1(296.42,25.24) 296.94,24.72 298.26,24.72 298.7,25.16 JNGFF3.38 ; v1(167.89,41.7) 164.11,41.7 v1(162.34,43.48) ; v1(138.59,64.23) 138.21,63.85 136.98,63.85 136.8,64.03 136.8,64.39 136.32,64.88 UC1.J3
M2280_PCIE_SATA#: length 390.9
  TOP w0.102: 218.83,37.36 v2(214.13,37.36) v1(212.41,39.07) 210.7,37.36 209.8,37.36 RN182.1 208.41,36.85 208.11,36.54 208.11,35.27 208.31,35.07 QN4.2 ; 218.83,37.36 219.18,37.71 220.91,37.71 221.39,37.23 228.91,37.23 v1(229.62,36.52) 229.62,31.43 229.18,30.99 227.77,30.99 227.56,31.2 227.56,33.38 227.15,33.8 RN184.1 ; 218.83,37.36 218.83,35.76 219.26,35.32 RN187.1 ; v1(284.29,56.9) 284.36,56.9 284.55,56.71 UN5.20 ; UN4.20 v1(264.15,50.16)
  IN1 w0.089: v1(186.76,56.46) 188.51,56.46 191.24,53.73 201.27,43.71 203.66,43.71 208.3,39.07 v1(212.41,39.07)
  IN3 w0.122: v1(241.42,37.68) 252.23,37.68 252.74,37.18 255.53,37.18 257.84,39.49 265.97,39.49 268.11,41.63 269.12,41.63 271.88,44.38 272.9,44.38 274.09,45.57 274.09,46.16 274.76,46.83 275.72,46.83 276.8,47.91 276.8,49.34 277.21,49.76 277.21,50.6 277.92,51.3 277.92,52.01 278.8,52.89 278.8,53.38 279.43,54 279.43,54.57 280.34,55.48 282.4,55.48 283.82,56.9 v1(284.29,56.9)
  IN4 w0.089: v1(161.59,72.11) 161.59,71.97 162.39,71.17 163.55,71.17 164.62,70.11 164.62,67.52 165.44,66.7 165.44,54.8 171.07,49.17 171.07,48.21 173.08,46.21 v1(173.08,45.17) 173.57,44.67 174.62,44.67 180.72,38.57 182.94,38.57 188.23,33.28 188.63,33.28 198.97,22.94 205.17,22.94 205.64,22.48 207.47,22.48 207.65,22.66 215.3,22.66 215.49,22.47 218.24,22.47 218.58,22.81 221.25,22.81 221.89,22.18 226.22,22.18 226.5,22.46 230.53,22.46 231.63,21.37 252.11,21.37 253.26,20.21 261.5,20.21 262.96,21.67 262.96,23.63 264.32,24.99 264.32,25.14 268.75,29.58 280.4,29.58 282.15,31.32 284.1,31.32 288.66,35.88 v1(289.67,35.88)
  BOTTOM w0.076: UC1.G4 135.81,65.9 136.41,65.9 arc(136.61,65.91) 136.81,65.93 arc(136.88,65.94) 136.95,65.96 arc(137.04,65.97) 137.13,65.98 arc(137.17,65.97) 137.2,65.97 arc(137.3,65.95) 137.4,65.95 138.22,65.95 138.38,66.11
  BOTTOM w0.102: v1(289.67,35.88) 289.67,35.86 290.95,34.57 JNGFF3.69 ; v1(173.08,45.17) 177.17,49.26 177.17,50.85 179.87,53.55 182.54,53.55 185.45,56.46 v1(186.76,56.46) ; v1(264.15,50.16) 262.89,51.43 259.95,51.43 247.73,39.21 242.96,39.21 v1(241.42,37.68) 240.26,36.52 v1(229.62,36.52) ; 138.38,66.11 138.93,66.11 143.75,70.93 RPC4.4 146.17,70.93 146.75,71.52 147.33,71.52 147.79,71.99 161.47,71.99 v1(161.59,72.11)
M3042_DEVSLP: length 209.4
  IN4 w0.089: v1(166.37,68.24) 166.37,54.93 180.03,41.28 182.76,41.28 183.98,40.06 185.17,40.06 186.25,38.98 186.25,38.07 187.21,37.11 187.97,37.11 189.25,35.83 189.25,34.53 199.44,24.34 207.59,24.34 207.88,24.05 212.45,24.05 212.93,24.54 216.45,24.54 216.84,24.15 221.94,24.15 222.51,23.58 225.34,23.58 226.03,24.26 230.98,24.26 232.56,22.69 253.05,22.69 253.5,22.24 258.32,22.24 259.72,23.64 261.02,23.64 261.7,24.32 261.7,25.84 268.35,32.49 269.79,32.49 272.71,35.41 272.71,36.01 273.55,36.85 276.66,36.85 277.33,37.52 278.36,37.52 278.67,37.22 279.16,37.22 281.01,39.06 281.01,40.41 282.7,42.1 282.7,44.32 283.96,45.57 286.59,45.57 288.83,47.81 289.57,47.81 290.33,48.57 292.31,48.57 293.36,49.63 295.77,49.63 296.14,50 v1(296.14,50.74)
  BOTTOM w0.102: v1(296.14,50.74) 296.05,50.66 JNGFF2.38 ; UC1.J2 136.82,64.88 137.15,64.55 137.65,64.55 137.75,64.64 139.76,64.64 143.72,68.6 149.6,68.6 151.7,70.7 161.61,70.7 163.07,69.23 v2(164.75,69.23) 165.49,69.23 165.99,68.73 166.37,68.34 v1(166.37,68.24)
M3042_PCIE#_SATA: length 247.7
  TOP w0.102: v1(291.17,64) 291.83,64 292.14,64.32 292.14,65.21 293.31,66.37 QZ8.2
  TOP w0.107: UE1.J12 301.96,80.75 302.36,81.15 302.36,81.16 v1(302.37,81.16)
  IN2 w0.122: v1(302.37,81.16) 302.36,81.16 302.36,81.78 300.53,83.61 298.99,83.61 297.96,82.58 297.96,82.11 297.76,81.91 297.31,81.91 297.01,82.21 297.01,82.44 296.59,82.86 295.49,82.86 290.73,78.1 290.5,78.1 290.1,77.69 290.1,74.72 288.83,73.45 287.18,73.45 285.54,71.82 285.54,68.9 287.3,67.14 287.3,66.73 287.52,66.5 288.59,66.5 288.73,66.64 289.29,66.64 289.57,66.36 289.57,64.9 290.17,64.31 290.86,64.31 v1(291.17,64)
  IN3 w0.122: v1(163.58,70.02) 163.58,68.45 163.34,68.2 163.34,62.31 181.56,44.09 186.97,44.09 200.33,30.73 200.84,30.73 200.84,30.73 202.97,30.73 204.29,29.41 210.14,29.41 210.7,28.85 213.44,28.85 213.59,28.69 221.94,28.69 222.91,27.73 227.52,27.73 228.28,28.49 237.6,28.49 242.02,32.92 246.75,32.92 248.14,34.31 256.76,34.31 258.48,36.04 267.57,36.04 268.31,36.77 270.01,36.77 271.29,38.06 274.98,38.06 275.9,38.98 275.9,40 276.06,40.16 276.06,42.09 281.83,47.86 281.83,49.4 284.01,51.58 285.63,51.58 286.24,52.19 286.24,53.4 287.67,54.82 287.67,57.95 287.04,58.58 287.04,59.83 288.18,60.97 288.18,61.67 289.54,63.03 289.54,64.03 289.87,64.35 290.82,64.35 v1(291.17,64)
  BOTTOM w0.102: UC1.H3 136.07,65.54 136.33,65.27 138.49,65.27 138.64,65.42 139.39,65.42 143.01,69.04 145.36,69.04 145.75,69.43 RPC4.1 146.57,68.85 149.55,68.85 151.68,70.99 162.04,70.99 v2(163.01,70.02) v1(163.58,70.02)
M3042_PCIE_SATA#: length 6.3
  TOP w0.102: v2(291.22,67.66) 291.28,67.59 RZ360.2 ; QZ8.1 291.6,67.02 RZ360.2 ; RZ360.2 290.47,66.71 290.07,66.31 289.57,66.31 289.13,66.75 288.45,66.75 288.05,66.35 UZ36.20
M_ID2#: length 5.3
  BOTTOM w0.102: v2(317.44,75.09) CV135.1 318.87,75.09 319.02,74.94 320.78,74.94 JCRT1.4
MASK_BASE_LEDS#: length 83.7
  TOP w0.102: UZ10.4 278.34,47.49 v1(278.07,47.49)
  IN4 w0.089: v1(311.66,91.2) 311.79,91.2 313.42,89.58 313.42,87.01 319.14,81.28 319.14,74.25 317.36,72.47 312.62,72.47 312.42,72.67 309.94,72.67 309.74,72.46 304.67,72.46 304.37,72.16 304.37,70.35 303.98,69.97 303.98,68.55 302.84,67.4 302.84,66.69 301.95,65.8 301.66,65.8 299.68,63.83 299.68,63.64 298.93,62.89 298.51,62.89 293.88,58.26 293.88,57.65 292.69,56.46 288.85,56.46 288.14,55.75 288.14,54.91 286.15,52.91 286.15,52.22 285.94,52.01 283.34,52.01 280.84,49.51 280.14,49.51 278.12,47.49 v1(278.07,47.49)
  BOTTOM w0.102: v1(311.66,91.2) 312.6,91.2 v2(314.03,92.63) 316.36,94.96 QZ7.5
MASK_SATA_LED#: length 51.8
  TOP w0.102: 267.98,66.75 v1(267.98,65.93)
  TOP w0.107: v1(303.96,75.53) UE1.L6
  BOTTOM w0.102: v1(303.96,75.53) 304.36,75.13 304.36,72.99 304.11,72.73 302.33,72.73 302.09,72.48 301.13,72.48 300.68,72.94 300.68,74.02 300.39,74.31 296.52,74.31 296.48,74.34 295.38,74.34 294.3,75.42 291.3,75.42 289.39,73.5 287.39,73.5 285.64,75.25 285.15,75.25 284.9,75.01 284.9,73.74 285.12,73.53 285.12,72.15 280.78,67.81 275.44,67.81 275.06,67.43 275.06,66.41 274.4,65.75 272.47,65.75 271.84,65.12 270,65.12 269.64,64.76 268.58,64.76 v2(268.29,65.05) 267.98,65.37 v1(267.98,65.93)
ME_FWP: length 46.5
  TOP w0.102: v1(271.79,91.69) v3(271.79,92.25)
  TOP w0.107: v1(300.76,81.13) UE1.G12
  BOTTOM w0.102: RC221.1 278.44,91.69 v1(271.79,91.69) 271.72,91.69 270.94,90.91 270.94,89.07 271.61,88.39 SW1.1 275.5,88.39 276.23,89.13 276.23,89.86 276.81,90.44 280.68,90.44 284.83,86.28 286.71,86.28 289.35,83.65 290.3,83.65 291.32,82.63 292.36,82.63 293.46,81.53 299.52,81.53 299.92,81.13 v1(300.76,81.13)
ME_FWP_PCH: length 264
  TOP w0.102: v1(278.77,94.13) 278.77,94.38 v3(279.02,94.63) ; v1(129.18,37.75) RC223.1
  IN3 w0.122: v1(183.41,45.56) 186.97,45.56 200.79,31.74 203.38,31.74 204.39,30.73 217.52,30.73 218.3,31.51 225.77,31.51 226.56,30.73 228.73,30.73 229.42,31.41 236.38,31.41 241.23,36.26 255.9,36.26 258.14,38.5 266.35,38.5 268.39,40.54 270.43,40.54 274.77,44.89 275.34,44.89 276.94,46.48 277.81,46.48 279.21,47.89 279.21,49.56 279.5,49.84 279.5,51.14 281.33,52.97 281.78,52.97 282.73,53.92 282.91,53.92 285.05,56.06 285.05,57.47 283.69,58.84 283.69,68.2 283.39,68.5 283.24,68.5 282.78,68.95 282.78,72.46 283.7,73.37 283.7,74.39 283.34,74.74 283.34,76.22 284.18,77.06 284.18,79.45 284.56,79.83 284.56,81.73 283.1,83.19 283.1,89.79 v1(278.77,94.13)
  BOTTOM w0.102: SW1.3 277.4,92.39 277.93,92.93 RC221.2 v1(278.77,94.13) ; v1(129.18,37.75) 128.48,37.05 128.48,34.82 129.04,34.27 129.04,27.47 135.18,21.33 177.78,21.33 178.08,21.02 180.05,21.02 180.35,21.33 180.78,21.33 185.5,26.05 185.5,29.34 185.23,29.61 185.23,31.07 183.16,33.14 183.16,45.31 v1(183.41,45.56)
ME_RESET#: length 4.2
  BOTTOM w0.102: v2(152.34,89.44) RC227.1 RC225.1 151.25,90.81 150.69,90.25 UC12.2
ME_SUS_PWR_ACK: length 214.4
  TOP w0.102: RC74.1 RC444.1 145.66,37.09 146.31,37.74 146.79,37.74 147.05,37.48 148.09,37.48 148.42,37.81 151.01,37.81 151.42,38.22 152.85,38.22 153.5,37.57 153.5,35.07 v2(154.87,33.7) 156.73,31.84 161.05,31.84 161.8,31.08 169.7,31.08 v1(170.06,31.44) ; UE1.B13 296.36,81.8 v1(295.85,82.31)
  IN1 w0.089: v1(295.85,82.31) 295.85,82.31 294.78,82.31 294.35,81.88 294.35,75.42 293.88,74.95 293.88,74.3 294.35,73.83 294.35,69.6 296.71,67.24 296.71,65.03 296.98,64.76 296.98,62.98 298.18,61.79 298.18,60.85 297.27,59.95 297.27,53.22 297.87,52.62 297.87,52.27 297.5,51.9 297.5,51.12 296.64,50.26 295.08,50.26 293.95,49.13 293.95,47.43 290.82,44.29 290.29,44.29 289.24,43.24 289.24,42.73 285.95,39.44 285.95,37.96 281.59,33.6 257.32,33.6 256.59,32.87 252.72,32.87 248.29,28.44 239.03,28.44 237.89,27.31 231.57,27.31 227.65,23.39 226.13,23.39 225.05,22.31 221.48,22.31 221.12,22.67 219.08,22.67 217.77,21.36 216.64,21.36 215.61,22.38 211.87,22.38 211.49,22 204.08,22 203.87,21.8 200.83,21.8 193.47,29.16 184.93,29.16 184.37,28.6 182.76,28.6 181.56,29.8 173.99,29.8 172.35,31.44 v1(170.06,31.44)
ME_SUS_PWR_ACK_R: length 24.6
  TOP w0.102: v1(144.21,38.88) 144.48,38.88 RC444.2 147.06,38 v2(147.22,37.84)
  IN2 w0.122: v1(130.62,51.14) 130.57,51.14 130.19,50.76 130.19,49.43 133.04,46.59 135.87,46.59 139.9,42.56 141.1,42.56 144.21,39.45 v1(144.21,38.88)
  BOTTOM w0.102: v1(130.62,51.14) 130.59,51.14 UC1.AR13
MEC_XTAL1: length 6.2
  TOP w0.102: UE1.A1 294.63,71.93 294.29,71.59 v2(294.18,71.59) 293.06,71.59 CE28.1 291.16,71.16 290.79,70.79 YE1.1
MEC_XTAL2: length 2.8
  TOP w0.102: YE1.2 291.32,71.82 291.99,71.82 CE29.1 292.37,72.2 RE290.2
MEC_XTAL2_R: length 2.5
  TOP w0.102: UE1.A3 295.15,73.12 v2(294.19,73.12) RE290.1
MEDIACARD_IRQ#: length 224.1
  TOP w0.102: UR1.32 27.19,47.44 v1(27.74,46.88) RR19.1 v2(28.73,46.14)
  IN2 w0.122: v1(154.44,80.08) 153.91,80.08 153.12,80.87 153.12,83.88 151.77,85.23 151.77,88.74 150.89,89.62 145.93,89.62 145.17,90.38 134.31,90.38 133.16,89.24 126.43,89.24 125.93,88.73 120.29,88.73 119.65,89.36 116.15,89.36 115.26,90.25 110.61,90.25 109.22,88.87 104.88,88.87 104.37,89.38 103,89.38 102.6,89.77 102.47,89.77 100.88,91.37 95.4,91.37 94.23,92.53 92.49,92.53 90.72,90.76 88.03,90.76 87.2,91.59 73.03,91.59 72.14,92.47 68.9,92.47 67.46,91.04 65.11,91.04 62.47,88.39 61.14,88.39 58.93,86.18 56.51,86.18 55.1,84.78 54.97,84.78 49.74,79.55 45.14,79.55 42.5,76.91 42.5,75.79 39.32,72.61 39.32,70.36 33.37,64.41 33.37,63.75 24.22,54.6 24.22,52.4 27.37,49.25 27.37,47.25 v1(27.74,46.88)
  IN4 w0.089: v1(154.44,80.08) 153.93,79.57 153.93,77.84 150.99,74.91 150.99,68.88 150.18,68.06 150.18,64.82 149.61,64.26 149.61,60.93 150.28,60.26 150.28,57.32 152.46,55.14 152.46,54.52 152.29,54.35 152.29,53.18 151.32,52.2 145.98,52.2 145.41,51.63 135.3,51.63 134.78,52.15 134.01,52.15 133.56,52.61 133.45,52.61 v1(133.45,52.61)
  BOTTOM w0.102: UC1.AN8 133.25,52.8 133.44,52.61 v1(133.45,52.61)
MEM_INTERLEAVED: length 12.5
  BOTTOM w0.102: UC1.P2 137.15,62.56 137.63,62.56 138.14,63.07 139.39,63.07 142.27,65.96 v2(143.34,65.96) 143.92,65.96 144.53,65.35 146.16,65.35 RC372.1 RC371.1
MEM_SMBCLK: length 21
  TOP w0.102: QC2.6 149.19,65.6 CC320.1 RC12.1 148.67,64.91 149.15,64.91 149.25,64.81 149.25,64.67 v4(148.58,63.99) 148.2,63.62 146.62,63.62 146.15,63.15 143.39,63.15 142.11,61.87 140.15,61.87 139.71,61.43 136.66,61.43 135.85,60.62 135,60.62 v1(134.33,61.29)
  BOTTOM w0.076: v1(134.33,61.29) 134.09,61.54 UC1.R7
MEM_SMBDATA: length 25.9
  TOP w0.102: v1(133.78,61.32) 133.78,61.25 134.13,60.89 134.4,60.89 134.9,60.39 135.95,60.39 136.75,61.2 139.8,61.2 140.24,61.64 142.2,61.64 143.48,62.92 146.24,62.92 146.72,63.39 v4(147.34,63.39) 148.3,63.39 149.48,64.57 149.48,64.81 149.58,64.91 150.05,64.91 150.63,65.49 150.63,66.69 151.24,67.31 153.04,67.31 RC14.1 152.99,67.01 152.92,67.08 152.14,67.08 QC2.3
  BOTTOM w0.076: UC1.R8 133.44,61.67 v1(133.78,61.32)
MPHYP_PWR_EN: length 31.5
  TOP w0.102: v1(132.52,53.23) 132.57,53.23 v2(132.89,52.91) ; RC387.1 v1(149.74,34.44)
  IN2 w0.122: v1(149.74,34.44) 149.92,34.62 149.92,35.78 149.79,35.92 149.79,37.35 149.19,37.95 149.19,39.35 142.96,45.58 142.96,46.27 140.98,48.25 140.98,50.13 140.57,50.54 138.39,50.54 136.01,52.91 134.99,52.91 134.15,53.76 133.01,53.76 132.52,53.27 v1(132.52,53.23)
  BOTTOM w0.102: UC1.AM10 132.3,53.45 132.52,53.23 v1(132.52,53.23)
MSCLK: length 34
  TOP w0.102: v1(301.56,79.53) 301.56,79.52 UE1.H10
  IN4 w0.089: v1(301.56,79.53) 301,79.53 300.6,79.13 298.98,79.13 298.74,79.36 298.74,79.74 298.54,79.94 296.37,79.94 296.26,79.82 287.18,79.82 286.47,79.11 283.61,79.11 283.29,79.43 279.9,79.43 279.45,78.99 v1(276.83,78.99)
  BOTTOM w0.102: v1(276.83,78.99) 275.59,78.99 v2(275.46,79.12) 274.9,78.57 274.27,78.57 RE30.1 RE72.2 274.63,76.94 274.63,75.88 275.11,75.4 JDEG1.6
MSDATA: length 32.6
  TOP w0.112: v1(299.96,78.73) UE1.G9
  IN4 w0.089: v1(277.78,74.31) 277.78,74.28 278.96,73.09 v1(279.09,73.09)
  BOTTOM w0.102: v1(279.09,73.09) 279.58,73.09 280.32,73.83 280.32,74.62 280.93,75.23 281.13,75.23 281.97,76.07 281.97,76.46 284.99,79.49 286.84,79.49 287.56,80.21 v3(288.9,80.21) 289.89,80.21 290.48,79.62 295.35,79.62 295.86,79.11 299.57,79.11 v1(299.96,78.73) ; RE86.1 RE75.2 274.64,74.9 JDEG1.7 276.41,74.9 276.99,74.31 v1(277.78,74.31)
MUX1_DP_SEL: length 19.4
  TOP w0.102: RT89.1 25.38,82.92 v1(25.28,82.82) ; v2(22.43,90.82) 22.43,90.74 v1(23.08,90.1)
  IN4 w0.089: v1(25.28,82.82) 24.88,82.62 24.76,82.66 24.71,82.78 23.53,83.96 23.53,85.26 22.08,86.71 19.84,86.71 18.75,87.8 18.75,88.64 19.35,89.24 21.71,89.24 22.73,90.26 22.92,90.26 v1(23.08,90.1)
  BOTTOM w0.102: v1(23.08,90.1) 22.92,90.25 22.58,90.25 22.29,90.54 22.29,90.65 21.91,91.02 21.91,91.22 21.81,91.32 UT9.23
MUX1_DPEQ0: length 5.3
  TOP w0.102: v2(24,94.96) v1(24.56,94.96) 24.56,95.82 25.05,96.31 RT139.1 RT140.1 RT306.1
  BOTTOM w0.102: UT9.14 v1(24.56,94.96)
MUX1_DPEQ1: length 4.1
  BOTTOM w0.102: RT247.1 RT303.1 RT248.1 20.09,99.46 v2(20.09,98.95) 20.09,98.62 20.21,98.49 UT9.2
MUX1_FLIP_SEL: length 21.3
  TOP w0.102: v1(36.28,86.85) 36.62,86.51 RT69.2 ; RT375.1 v2(25.74,88.71) 26.52,88.71 v1(26.62,88.82) ; RT375.1 24.59,89.5 RT410.1 ; RT375.1 RT411.2
  BOTTOM w0.102: UT9.21 22.61,91.33 22.69,91.25 22.92,91.25 23.27,91.61 23.96,91.61 24.69,90.87 25.07,90.87 25.86,90.09 25.86,89.1 26.14,88.82 v1(26.62,88.82) 31.03,88.82 32.66,87.19 35.93,87.19 v1(36.28,86.85)
MUX1_FLIP_SEL_R: length 6.5
  TOP w0.076: 35.02,83.8 35.02,83.39 34.89,83.26 34.89,82.79 UT5.B2
  TOP w0.102: 35.02,83.8 35.02,83.82 35.5,84.3 v2(36.02,84.3) 36.62,84.89 RT69.1 36.62,85.4 37.44,86.23 RT405.2 38.28,87.17 RT417.1
MUX1_I2C_EN: length 5.2
  TOP w0.102: v2(24.42,93.38) 24.08,93.72 v1(24.08,93.76) 24.19,93.87 RT145.1 CT213.1 RT300.1 RT301.1
  BOTTOM w0.102: UT9.17 v1(24.08,93.76)
MUX1_SSEQ0: length 4.8
  TOP w0.102: RT138.1 RT302.1 RT137.1 25.19,97.22 v1(24.63,96.66) v2(23.99,96.66)
  BOTTOM w0.102: v1(24.63,96.66) 24.62,96.66 24.12,96.16 UT9.11
MUX1_SSEQ1: length 4.9
  TOP w0.102: v2(23.56,99.57) RT135.1 RT305.1 RT136.1 20.45,99.28 20.61,99.11 v1(20.61,98.82)
  BOTTOM w0.102: UT9.3 v1(20.61,98.82)
MUX1_USB_EQ0: length 60.2
  TOP w0.102: v2(17.52,100.11) RT143.1 RT144.1 RT304.1 17.52,96.49 v1(17.53,96.47) ; RT417.2 v1(36.81,87.17)
  IN4 w0.089: v1(17.53,96.47) 18.72,95.28 18.72,92.02 18.24,91.53 18.24,86.78 18.98,86.05 21.24,86.05 21.85,85.44 21.85,83.65 23.98,81.51 26.39,81.51 27.28,82.4 30.16,82.4 30.75,81.81 30.75,79.66 30.27,79.17 30.27,75.88 30.89,75.25 37.77,75.25 38.23,75.71 38.23,80.54 39.25,81.55 39.25,82.34 37.85,83.74 37.85,86.12 v1(36.81,87.17)
  BOTTOM w0.102: UT9.38 17.85,96.16 v1(17.53,96.47)
MUX1_USB_EQ1: length 24.1
  TOP w0.102: RT141.1 v2(16.58,94.43) 16.58,94.95 17.58,95.95 RT307.1 RT142.1 18,95.09 v1(17.86,94.95) ; RT418.2 v1(23.04,81.65)
  IN4 w0.089: v1(23.04,81.65) 21.47,83.23 21.47,85.28 21.11,85.64 18.75,85.64 17.86,86.53 v1(17.86,94.95)
  BOTTOM w0.102: UT9.35 19.15,94.95 v1(17.86,94.95)
MUX1_USB_SEL: length 23.7
  TOP w0.102: v1(24.14,82.25) 23.68,82.71 RT90.2 22.81,82.89 RT376.1 ; v1(23.08,90.68) 23.08,91.26 23.5,91.69 24.08,91.69 v2(24.34,91.43) 24.62,91.15 RT413.1 25.23,90.37 RT412.2
  IN4 w0.089: v1(23.08,90.68) 22.87,90.47 22.64,90.47 21.62,89.45 19.26,89.45 18.53,88.73 18.53,87.71 19.75,86.49 21.99,86.49 23.31,85.17 23.31,83.87 24.53,82.65 24.57,82.57 24.53,82.45 v1(24.14,82.25)
  BOTTOM w0.102: v1(23.08,90.68) 22.87,90.48 22.67,90.48 22.52,90.64 22.52,90.74 22.14,91.12 22.14,91.24 22.21,91.31 UT9.22
NB_MUTE#: length 49.7
  TOP w0.102: RA48.1 295.93,44.04 v1(295.35,43.45) 293.91,42.02 DA8.1
  TOP w0.107: UE1.A4 295.4,74.33 294.8,73.73 292.62,73.73 v2(292.31,74.05) 291.99,74.36 v1(291.99,74.65)
  IN1 w0.089: v1(288.78,44.39) 288.78,44.6 289.79,45.61 290.53,45.61 291.79,46.87 291.79,48.97 294.59,51.77 294.59,52.42 294.97,52.8 294.97,54.9 295.46,55.39 295.46,61.05 295.25,61.26 295.25,64.71 292.87,67.1 292.87,68.26 292.04,69.09 292.04,74.6 v1(291.99,74.65)
  BOTTOM w0.102: v1(295.35,43.45) 295.3,43.5 295.3,43.63 294.2,44.73 289.68,44.73 289.33,44.39 v1(288.78,44.39)
NB_PSID: length 0.7
  TOP w0.254: PL3.2 60.44,90.04 v1(60.41,90.01)
  vias: v2(59.63,88.33)
NGFF_CONFIG_0: length 65.6
  TOP w0.102: RPE9.3 v1(309.44,80.02) 308.74,80.02 307.98,79.27 306.64,79.27 v2(306.59,79.32) 305.59,78.33 UE1.N9
  IN2 w0.122: v1(296.15,40.11) 296.15,40.72 296.86,41.43 298.63,41.43 300.01,42.82 300.01,43.59 300.54,44.11 303.03,44.11 304.45,45.53 307.67,45.53 308.3,46.16 308.3,49.94 310.93,52.58 310.93,53.9 310.34,54.5 310.34,57.49 314.21,61.37 314.21,68.01 310.39,71.82 310.39,76.54 309.87,77.06 309.87,79.6 v1(309.44,80.02)
  BOTTOM w0.102: v1(296.15,40.11) 292.77,40.11 291.8,41.08 JNGFF2.21
NGFF_CONFIG_1: length 56.3
  TOP w0.102: UE1.M10 304.73,79.49 305.83,79.49 307.35,81.02 v2(308.11,81.02) v1(309.44,81.02) RPE9.1
  IN2 w0.122: v1(309.44,81.02) 310.16,81.02 311.4,79.79 311.4,74.56 311.72,74.23 311.72,72.05 314.66,69.11 314.66,60.62 310.92,56.88 310.92,54.55 311.69,53.78 311.69,50.62 309.07,48 309.07,45.48 307.75,44.16 305.49,44.16 305.31,44.34 304.78,44.34 v1(304.35,44.77)
  BOTTOM w0.102: JNGFF2.69 303.8,44.22 v1(304.35,44.77)
NGFF_CONFIG_2: length 54.7
  TOP w0.102: RPE9.2 v1(309.07,80.52) 307.14,80.52 305.74,79.13 UE1.N10
  IN2 w0.122: v1(309.07,80.52) 310.22,80.52 311.17,79.57 311.17,74.45 311.42,74.2 311.42,71.98 314.43,68.96 314.43,60.84 310.56,56.96 310.56,54.59 311.43,53.72 311.43,50.69 308.84,48.1 308.84,45.61 307.65,44.42 305.68,44.42 305.33,44.77 v1(304.98,44.77)
  BOTTOM w0.102: v1(304.98,44.77) 305.53,44.23 305.53,42.93 305.3,42.7 JNGFF2.75 ; v2(308.5,80.52) v1(309.07,80.52)
NGFF_CONFIG_3: length 60.5
  TOP w0.102: v1(309.06,79.52) RPE9.4 ; v1(294.96,44.79) v2(294.62,44.16)
  TOP w0.112: v1(299.16,73.93) UE1.F4
  IN1 w0.089: v1(294.96,44.79) 294.96,45.42 296.68,47.14 296.9,47.14 297.56,47.8 297.56,48.46 298.98,49.88 300.48,49.88 301.4,50.8 301.4,54.35 301.08,54.67 301.08,61.04 301.18,61.14 301.18,63.54 301.1,63.62 301.1,64.71 300.72,65.09 300.72,69.11 300.21,69.61 300.21,71.65 300.44,71.87 300.44,73.3 300.21,73.53 299.56,73.53 v1(299.16,73.93) 299.59,74.35 299.59,74.88 299.8,75.1 300.23,75.1 300.55,75.42 300.55,76.54 301.17,77.16 303.27,77.16 304.02,77.92 304.92,77.92 306.39,79.39 308.93,79.39 v1(309.06,79.52)
  BOTTOM w0.102: JNGFF2.1 286.8,41.88 286.8,43.35 288.29,44.85 288.78,44.85 289.03,45.1 294.65,45.1 v1(294.96,44.79)
NRB_BIT: length 26
  TOP w0.102: RC186.1 v1(148.72,34.44) 148.72,34.88 v2(148.79,34.94)
  IN2 w0.122: v1(133.49,51.15) 133.49,51.14 133.86,50.76 133.86,50.32 134.9,49.28 135.66,49.28 137.78,47.16 138.67,47.16 146.69,39.14 146.69,39.13 146.69,37.99 147.04,37.64 147.04,37.37 148.89,35.52 148.89,34.6 v1(148.72,34.44)
  BOTTOM w0.076: v1(133.49,51.15) 133.84,51.5 UC1.AR7
NTC_GT: length 3.7
  TOP w0.203: v1(64.62,50.64) 64.88,50.38 PU602.15
  BOTTOM w0.102: v1(64.62,50.64) 64.36,50.64 v2(64.05,50.34)
  BOTTOM w0.254: PR635.2 65.32,50.03 64.72,50.64 v1(64.62,50.64)
NVME_LED#: length 70.2
  TOP w0.102: v1(250.13,18.6) v2(250.13,19.28)
  IN1 w0.089: v1(250.13,18.6) 253.53,18.6 254.64,19.7 258.81,19.7 259.91,20.81 259.91,22 261.8,23.89 264.95,23.89 266.02,24.96 267.25,24.96 267.66,24.55 300.74,24.55 301.82,25.63 305.67,25.63 v1(306.11,25.2)
  BOTTOM w0.102: JNGFF3.10 305.7,25.6 v1(306.11,25.2) ; v1(250.13,18.6) 249.94,18.79 249.94,23.01 251.1,24.16 RN100.1
ONE_DIMM#: length 21.9
  TOP w0.102: v2(146.78,39.17) 146.87,39.26 v1(146.87,39.85) RC267.1 RC268.1
  IN2 w0.122: v1(134.39,51.75) 136.1,51.75 136.91,50.95 136.91,48.71 137.98,47.65 139.07,47.65 v1(146.87,39.85)
  BOTTOM w0.102: UC1.AP7 133.99,52.15 v1(134.39,51.75)
OTG_ID: length 2.6
  TOP w0.102: v1(33.52,79.04) 33.14,78.67 UT5.E10
  BOTTOM w0.102: v1(33.52,79.04) 33.52,78.63 RT74.1 33.83,78.3 33.15,78.3 v2(32.9,78.55)
OTGEN/CMIN: length 4.3
  TOP w0.203: 14.79,17.16 v2(15.23,17.16) PU901.20
  TOP w0.254: 14.79,17.16 13.71,17.16 PR919.2 PR960.2
PANEL_BKEN_EC: length 301.2
  TOP w0.102: v2(103.48,84.12) 103.13,84.47 v1(103.13,84.79)
  TOP w0.107: v1(302.36,78.73) UE1.J9
  IN2 w0.122: v1(103.13,84.79) 103.49,84.43 106.07,84.43 107.13,85.49 108.97,85.49 114.38,80.08 120.17,80.08 120.3,80.21 127.79,80.21 128.67,81.09 129.58,81.09 129.73,81.24 131.58,81.24 131.73,81.09 133.39,81.09 134.18,80.29 135.18,80.29 136.51,78.96 139.4,78.96 140.21,79.77 140.21,82.7 142.56,85.04 148.6,85.04 151.2,82.44 151.2,78.76 152.13,77.83 154.95,77.83 v1(155.3,78.17)
  IN3 w0.122: v1(155.3,78.17) 155.3,74.68 157,72.98 157,63.99 157.38,63.61 157.38,63.14 158.21,62.31 158.21,61.59 161.08,58.72 163.2,58.72 173.04,48.87 173.04,47.8 177.36,43.48 177.36,42.12 184.41,35.07 185.43,35.07 188.22,32.28 191.91,32.28 200.29,23.9 203.9,23.9 206.68,21.11 207.72,21.11 210.72,18.11 214.91,18.11 215.3,17.72 216.75,17.72 217.81,16.67 221.09,16.67 221.24,16.82 229.34,16.82 232.96,20.44 240.84,20.44 245.71,25.31 249.01,25.31 249.98,26.28 256.44,26.28 257.38,27.22 259.62,27.22 260.94,28.54 279.4,28.54 281.47,30.61 281.47,31.73 285.6,35.86 285.6,36.17 288.68,39.24 288.68,39.91 291.28,42.51 291.57,42.51 291.87,42.82 291.87,44.04 294.81,46.97 294.81,48.34 295.81,49.34 297.1,49.34 298.5,50.73 298.5,51.23 302.05,54.79 302.05,58.94 305.41,62.3 305.41,64.25 306.57,65.4 306.57,66.1 306.35,66.31 306.35,68.55 307.39,69.59 307.39,75.2 307.87,75.68 307.87,78.2 307.31,78.77 305.46,78.77 305.07,79.16 304.64,79.16 304.6,79.12 302.75,79.12 v1(302.36,78.73)
  BOTTOM w0.102: v1(103.13,84.79) 103.47,84.79 103.78,84.48 DV2.2
PANEL_BKLEN: length 70
  TOP w0.102: v1(102.48,84.79) 102.48,84.55 105.16,81.87 107.66,81.87 108.13,82.34 109.07,82.34 110.42,83.69 110.42,86.53 112.59,88.7 v2(113.26,88.7) 114.65,88.7 116.12,90.18 v1(124.28,90.18)
  IN4 w0.089: v1(124.28,90.18) 124.44,90.01 129.74,90.01 132.81,86.95 132.81,84.96 133.61,84.16 133.61,81.55 134.88,80.28 134.88,78.95 135.75,78.08 135.75,71.27 135.39,70.91 135.39,68.92 135.03,68.56 135.03,63.35 134.58,62.91 132.18,62.91 v1(130.55,61.28)
  BOTTOM w0.076: v1(130.55,61.28) 130.83,61.56 UC1.R12
  BOTTOM w0.102: DV2.3 v1(102.48,84.79)
PBAT_CHARGER_SMBCLK: length 374.5
  TOP w0.102: UE1.N2 306.16,71.73 306.16,71.4 v1(306.64,70.91) 307.36,70.91 RE43.1 ; v1(20.31,2.18) 20.13,2.35 20.13,3.77 PD2.3 20.54,4.7 20.45,4.79 20.45,5.54 PRP1.3 ; v1(11.35,15.98) 11.52,16.15 11.98,16.15 PR922.1
  IN1 w0.089: v1(20.31,2.18) 20.13,1.99 20.13,1.73 20.31,1.54 107.64,1.54 111.7,5.61 115.64,5.61 119.58,1.67 139.46,1.67 140.06,2.27 160.19,2.27 163.1,5.17 166.41,5.17 169.58,2.01 184.75,2.01 186.08,3.34 191.32,3.34 191.75,3.78 196.46,3.78 197.2,3.04 228.1,3.04 228.2,3.14 228.2,3.3 v1(228.02,3.48)
  IN2 w0.122: v1(11.35,15.98) 11.5,16.13 12.02,16.13 12.24,15.91 12.24,10.65 12.02,10.43 12.02,5.83 16.43,1.42 19.88,1.42 20.2,1.74 20.2,2.07 v1(20.31,2.18)
  IN4 w0.089: v1(234.14,24.91) 234.6,25.37 257.71,25.37 260.34,28 260.34,28.71 271.14,39.5 271.87,39.5 274.82,42.45 275.57,42.45 276.12,42.99 276.12,43.31 280.17,47.37 281.39,47.37 282.38,48.36 283.58,48.36 285.69,50.47 287.75,50.47 288.1,50.12 288.68,50.12 291.27,52.72 291.78,52.72 293.08,54.02 295.03,54.02 295.27,53.78 296.09,53.78 298.45,56.14 298.45,60.16 299.97,61.68 302.92,61.68 303.1,61.87 303.92,61.87 304.78,62.72 304.78,63.73 306.62,65.57 306.62,66.34 305.86,67.1 305.86,69.07 307.36,70.57 307.36,70.91 307.1,71.17 306.9,71.17 v1(306.64,70.91)
  BOTTOM w0.102: v1(234.14,24.91) 234.32,24.73 234.32,24.57 234.22,24.46 230.45,24.46 228.45,22.47 227.49,22.47 226.96,21.94 226.96,6.47 228.19,5.24 228.19,3.65 v1(228.02,3.48)
PBAT_CHARGER_SMBDAT: length 376
  TOP w0.102: RE37.1 307.13,71.51 v1(306.65,71.51) 306.61,71.56 306.61,71.6 305.62,72.59 305.62,72.81 305.35,73.08 304.8,73.08 UE1.M3 ; v1(19.73,2.18) 19.9,2.35 19.9,3.77 PD1.2 19.95,4.63 19.95,5.54 PRP1.2 ; v1(11.35,16.57) 11.53,16.38 11.94,16.38 PR920.1
  IN1 w0.089: v1(228.6,3.48) 228.42,3.3 228.42,3.05 228.19,2.82 197.11,2.82 196.37,3.56 191.84,3.56 191.41,3.13 186.17,3.13 184.84,1.8 169.49,1.8 166.32,4.96 163.19,4.96 160.28,2.05 140.15,2.05 139.55,1.45 119.49,1.45 115.55,5.39 111.79,5.39 107.73,1.33 20.22,1.33 19.91,1.64 19.91,1.99 v1(19.73,2.18)
  IN2 w0.122: v1(11.35,16.57) 11.53,16.38 12.12,16.38 12.49,16.01 12.49,10.55 12.27,10.33 12.27,5.93 16.54,1.66 19.78,1.66 19.96,1.84 19.96,1.95 v1(19.73,2.18)
  IN4 w0.089: v1(234.73,24.91) 234.97,25.15 257.8,25.15 260.56,27.91 260.56,28.62 271.23,39.29 271.96,39.29 274.91,42.23 275.66,42.23 276.33,42.91 276.33,43.22 280.26,47.16 281.48,47.16 282.46,48.14 283.67,48.14 285.78,50.25 287.66,50.25 288.01,49.9 288.77,49.9 291.36,52.5 291.87,52.5 293.17,53.8 294.94,53.8 295.18,53.56 296.18,53.56 298.67,56.05 298.67,60.07 300.06,61.47 303.01,61.47 303.19,61.65 304.01,61.65 305,62.63 305,63.64 306.84,65.48 306.84,66.43 306.08,67.19 306.08,68.98 307.57,70.48 307.57,71 307.19,71.39 306.78,71.39 v1(306.65,71.51)
  BOTTOM w0.102: v1(228.6,3.48) 228.41,3.67 228.41,5.34 227.19,6.56 227.19,21.84 227.59,22.24 228.55,22.24 230.54,24.24 234.31,24.24 234.55,24.47 234.55,24.73 v1(234.73,24.91)
PBAT_PRES#: length 371.3
  TOP w0.102: v1(209,2.34) 210.32,3.66 210.32,9.37 210.6,9.65 210.6,11.71 209.56,12.76 209.56,13.61 208.64,14.52 v1(208.64,27.77) ; PR931.1 12.2,10.25 12.2,8.02 v2(13.85,6.37) v1(17.51,6.37) 17.48,6.34 PR1.2 17.86,4.22 17.9,4.18 PD1.3 19.45,5.13 PRP1.1
  TOP w0.112: v1(299.16,78.73) UE1.F9
  IN3 w0.122: v1(17.51,6.37) 19.65,6.37 24.68,1.34 107.69,1.34 111.97,5.62 117.05,5.62 120.42,2.24 141.47,2.24 142.46,1.25 160.1,1.25 163.31,4.46 165.8,4.46 169,1.26 185.15,1.26 186.06,2.18 189.11,2.18 189.89,2.96 192.7,2.96 193.15,2.51 196.58,2.51 196.71,2.64 200.46,2.64 200.83,3.01 204.05,3.01 204.72,2.34 v1(209,2.34) ; v1(299.16,78.73) 298.94,78.73 298.54,79.14 296.6,79.14 296.58,79.15 296.17,79.15 293.31,76.3 293.31,74.78 292.35,73.83 292.35,72.23 291.06,70.93 291.06,66.93 292.44,65.55 292.44,64.09 291.84,63.49 291.84,59.83 291.6,59.58 291.6,58.57 291.01,57.98 289.13,57.98 288.34,57.2 288.34,54.5 286.91,53.07 286.91,51.92 286.29,51.29 286.29,50.76 283.73,48.2 283.12,48.2 278.41,43.5 278.41,42.36 277.91,41.85 277.91,40.06 277.65,39.8 277.65,38.38 276.53,37.27 271.62,37.27 270.38,36.03 268.58,36.03 267.91,35.36 258.75,35.36 256.97,33.57 248.44,33.57 247.03,32.16 242.36,32.16 238.02,27.82 228.56,27.82 227.73,27 221.92,27 220.99,27.93 213.34,27.93 213.21,28.06 210.36,28.06 209.62,27.32 209.09,27.32 v1(208.64,27.77)
PBAT_PRES#_C: length 7.3
  TOP w0.102: PRP1.8 19.45,7.12 19.28,7.28 v1(18.7,7.28) 18.43,7.28 v3(18.06,6.91)
  BOTTOM w0.102: v1(18.7,7.28) 18.5,7.48 PBATT1.6
PBAT_SMBCLK_C: length 6.4
  TOP w0.102: PRP1.6 20.45,7.02 20.31,7.16 20.31,7.89 v4(20.48,8.06) 20.62,8.2 20.62,9.15 v1(20.88,9.41)
  BOTTOM w0.102: PBATT1.4 21.5,11.63 20.86,11 20.86,10.2 20.73,10.06 20.73,9.56 v1(20.88,9.41)
PBAT_SMBDAT_C: length 6.4
  TOP w0.102: v1(20.29,9.44) 20.39,9.33 20.39,8.29 20.28,8.18 20.08,7.99 20.08,7.16 19.95,7.02 PRP1.7
  BOTTOM w0.102: PBATT1.5 20,11.62 20.64,10.99 20.64,10.29 20.5,10.16 20.5,9.65 v1(20.29,9.44)
PBATT+_C:
  vias: v1(22.93,9.76) v1(22.93,8.49) v1(23.25,10.39) v1(23.25,9.12) v1(23.63,9.76) v1(23.63,8.49) v1(23.94,10.39) v1(24.01,9.12) v1(24.33,9.76) v1(24.33,8.49) v1(24.64,10.39) v1(24.71,9.12) v1(25.02,9.76) v1(25.02,8.49) v1(25.34,10.39) v1(25.41,9.12) v1(25.72,9.76) v1(25.72,8.49) v1(26.17,9.12) v1(26.42,8.49) v3(22.61,9.16) v3(24.67,10.97)
PCH_3.3V_TS_EN: length 23.1
  TOP w0.102: RV324.1 152.86,54.96 RC282.1 152.15,54.88 v1(152.02,55.01)
  IN4 w0.089: v1(134.32,52.55) 134.55,52.55 134.76,52.76 135.44,52.76 136.37,51.84 145.33,51.84 145.89,52.39 151.24,52.39 152.02,53.18 v1(152.02,55.01)
  BOTTOM w0.076: UC1.AP5 134.58,52.15 134.32,52.41 v1(134.32,52.55)
PCH_ALW_ON: length 181.6
  TOP w0.102: v1(306.16,77.16) 304.87,77.16 304.5,77.53 UE1.M8 ; v1(207.6,11.47) 207.6,12.97 206.03,14.54 206.03,22.94 206.72,23.62 v1(206.79,23.62) ; v1(199.34,9.47) 199.14,9.28 RZ65.1 ; RPE10.3 v1(307.98,87.97)
  IN3 w0.122: v1(306.16,77.16) 306.49,76.83 306.49,76.2 306.86,75.82 306.86,73.02 306.2,72.36 306.2,69.15 305.54,68.49 304.34,68.49 303.21,67.36 303.21,66.68 304.66,65.23 304.66,64.29 302.95,62.58 302.95,60.98 300.1,58.13 300.1,53.84 297.83,51.57 297.83,51.01 296.82,50.01 295.53,50.01 294.12,48.6 294.12,47.24 291.69,44.8 290.81,44.8 289.3,43.29 289.3,41.88 284.89,37.47 284.89,36.24 278.72,30.07 260.32,30.07 258.98,28.72 255.33,28.72 254.35,27.74 249.38,27.74 248.44,26.8 245.13,26.8 240.24,21.91 232.35,21.91 230.25,19.82 224.93,19.82 224.01,20.74 222.38,20.74 220.82,22.31 219.05,22.31 217.2,20.47 213.21,20.47 212.91,20.77 211.66,20.77 209.56,22.87 208.79,22.87 208.12,23.54 206.87,23.54 v1(206.79,23.62)
  IN4 w0.089: v1(207.6,11.47) 206.5,10.38 205.39,10.38 204.81,10.97 201.77,10.97 200.93,10.12 199.98,10.12 v1(199.34,9.47)
  BOTTOM w0.102: v2(307.98,88.6) v1(307.98,87.97) 308.2,87.75 308.2,85.65 307.09,84.54 306.36,84.54 305.11,83.29 305.11,79.32 305.41,79.02 305.41,77.92 306.16,77.17 v1(306.16,77.16)
PCH_BATLOW#: length 31.7
  TOP w0.102: RC72.1 v1(150.75,34.44) 150.37,34.82 v2(150.09,34.82)
  IN1 w0.089: v1(150.75,34.44) 150.4,34.44 150.01,34.05 147.66,34.05 146.96,34.74 146.96,35.89 145.84,37 145.84,38.71 141.47,43.08 139.42,43.08 135.87,46.63 132.85,46.63 129.73,49.75 v1(129.73,49.89)
  BOTTOM w0.102: v1(129.73,49.89) 130.03,50.2 UC1.AU13
PCH_CL_CLK1: length 115.5
  TOP w0.102: v1(205.74,13.79) 205.83,13.88 205.83,22.02 197.1,30.75 197.1,47.46 186.25,58.3 186.07,58.3 v1(185.86,58.51)
  BOTTOM w0.076: UC1.G3 136.48,66.52 137.06,66.52 137.42,66.69 138.05,66.69 138.16,66.8 138.36,66.8 138.37,66.81
  BOTTOM w0.102: v1(185.86,58.51) 185.67,58.32 183.77,58.32 168.72,73.37 160.08,73.37 159.38,72.67 147.52,72.67 147.06,72.22 146.4,72.22 145.96,71.77 143.34,71.77 138.37,66.81 138.37,66.81 ; JNGFF1.42 206.45,14.5 v1(205.74,13.79)
PCH_CL_DATA1: length 114.9
  TOP w0.102: v1(185.86,57.93) 186.01,58.07 186.16,58.07 196.87,47.36 196.87,30.66 205.6,21.92 205.6,15.03 205.5,14.92 v1(204.63,14.92)
  BOTTOM w0.076: 138.54,66.65 138.5,66.62 138.26,66.62 138.16,66.52 137.48,66.52 137.05,66.31 136.92,66.31 UC1.G2
  BOTTOM w0.102: v1(204.63,14.92) 204.68,14.87 207.78,14.87 207.9,15 JNGFF1.40 ; 138.54,66.65 143.43,71.54 146.06,71.54 146.5,71.99 147.16,71.99 147.62,72.45 159.47,72.45 160.17,73.14 168.62,73.14 176.15,65.62 183.67,58.1 185.69,58.1 v1(185.86,57.93)
PCH_CL_RST1#: length 115.4
  TOP w0.102: v1(186.19,57.36) 186.59,57.36 196.55,47.39 196.55,30.36 v2(199,27.91) 204.17,22.74 v1(204.17,15.35)
  BOTTOM w0.076: UC1.G1 138.17,66.2 138.33,66.36
  BOTTOM w0.102: JNGFF1.38 205.23,15.5 205.13,15.6 205.13,17.06 205.03,17.16 204.83,17.16 204.73,17.06 204.73,15.6 204.63,15.5 204.33,15.5 v1(204.17,15.35) ; 138.33,66.36 138.74,66.36 143.64,71.27 146.18,71.27 146.69,71.77 147.26,71.77 147.71,72.22 160.27,72.22 160.96,72.92 168.56,72.92 184.12,57.36 v1(186.19,57.36)
PCH_DPWROK: length 248.4
  TOP w0.102: v1(285.59,75.75) 285.45,75.89 RE536.1 ; RC215.1 131.83,38.47 v3(130.99,37.64) 130.39,37.03 v1(129.87,37.03) 130.18,36.72 CC266.1 130.19,36.35 RC220.1
  IN1 w0.089: v1(285.59,75.75) 285.59,75.52 286.14,74.97 286.14,72.07 286.64,71.57 286.64,69.99 287.15,69.48 287.15,68.93 287.53,68.55 290.74,68.55 292.36,66.93 292.36,66.92 293.36,65.93 293.36,62.4 293.77,61.99 293.77,60 294.29,59.48 294.29,55.85 293.93,55.49 293.93,53.24 292.63,51.94 289.51,48.83 289.51,46.09 285.97,42.55 285.97,41.81 285.07,40.91 285.07,40.18 284.82,39.93 284.82,38.43 281.12,34.73 256.85,34.73 256.3,34.18 252.43,34.18 247.82,29.57 238.56,29.57 237.42,28.44 231.02,28.44 227.23,24.66 224.84,24.66 223.83,23.64 222.32,23.64 221.81,24.15 218.57,24.15 217.91,23.49 216.58,23.49 215.96,24.11 213.02,24.11 212.45,23.54 210.23,23.54 209.83,23.14 203.92,23.14 203.53,23.54 200.69,23.54 193.35,30.88 184.92,30.88 v1(184.73,30.69)
  BOTTOM w0.076: 128.51,43.61 128.51,43.89 127.22,45.18 127.22,45.57 126.53,46.26 126.53,47.05 UC1.BB20
  BOTTOM w0.102: 128.51,43.61 128.51,40.65 130.31,38.85 130.31,37.47 v1(129.87,37.03) 129.52,36.68 129.52,27.7 135.41,21.81 178.06,21.81 178.34,21.53 179.86,21.53 180.14,21.81 180.55,21.81 183.32,24.58 183.32,26.83 184.73,28.24 v1(184.73,30.69)
PCH_DPWROK_EC: length 16.9
  TOP w0.102: v2(285.88,76.17) 285.88,76.35 v1(285.56,76.66) 285.42,76.8 RE536.2
  TOP w0.112: v1(299.18,77.91) UE1.F8
  IN4 w0.089: v1(299.18,77.91) 298.95,77.91 298.54,78.31 298.24,78.31 297.95,78.02 297.95,77.59 297.74,77.38 295.61,77.38 295.2,77.79 289.9,77.79 289.18,77.08 285.98,77.08 v1(285.56,76.66)
PCH_JTAG_TCK: length 86.1
  TOP w0.102: JXDP1.55 61.96,35.83 61.96,34.82 61.56,34.42 60.62,34.42 60.25,34.79 60.25,36.19 v3(58.06,38.39) v1(57.14,39.31)
  IN1 w0.089: v1(104.41,74.07) 104.84,73.64 104.84,72.72 103.97,71.86 103.14,71.86 102.87,71.6 100.26,71.6 99.13,72.73 97.92,72.73 97.35,72.15 93.35,72.15 86.8,65.6 86.31,65.6 83.32,62.6 83.32,59.26 78.71,54.65 74.81,54.65 74.55,54.4 74.55,53.8 73.99,53.24 71.64,53.24 71.3,52.9 67.56,52.9 67.16,53.29 65.28,53.29 63.66,51.67 63.66,49.12 59.5,44.96 59.5,42.15 57.14,39.79 v1(57.14,39.31)
  BOTTOM w0.076: UC1.B56 105.35,69.27 105.35,69.49 105.29,69.61 105.29,69.87 105.42,70 105.42,70.67 105.24,70.85 105.24,72.21 104.73,72.73 104.73,73.75 v1(104.41,74.07)
  BOTTOM w0.102: RC86.1 104.91,74.57 v1(104.41,74.07)
PCH_JTAG_TDI: length 87.6
  TOP w0.102: v1(52.71,37.48) RC229.2
  IN1 w0.089: v1(52.71,37.48) 53.08,37.85 54.13,37.85 55.95,39.68 56.09,39.68 58.83,42.41 58.83,46.2 59.19,46.55 60.16,46.55 63,49.39 63,53.85 64.02,54.88 73.72,54.88 76.95,58.11 81.13,58.11 82.53,59.5 82.53,62.81 85.81,66.08 85.81,66.66 86.57,67.43 87.61,67.43 93.03,72.85 97.03,72.85 97.6,73.42 99.54,73.42 100.9,72.07 102.38,72.07 103.72,73.41 104.29,73.41 v1(104.3,73.43)
  BOTTOM w0.076: UC1.D59 104.42,68.09 104.5,68.36 104.5,68.47 104.58,68.75 104.62,68.91 104.64,68.95 104.64,69.2 104.6,69.29 104.6,69.48 104.64,69.58 104.64,69.94 104.48,70.1 104.48,71.98 104.3,72.16 v1(104.3,73.43) 104.3,73.65 103.89,74.06 103.89,75.33 CC304.1
  BOTTOM w0.102: CC304.1 104.45,75.89 104.45,77.22 103.76,77.9 RC81.1
PCH_JTAG_TDO: length 12.1
  TOP w0.102: v1(105.34,77.74) v3(106.05,77.74)
  BOTTOM w0.076: 104.93,73.73 104.93,72.77 105.41,72.28 105.41,70.97 105.6,70.79 105.6,69.75 UC1.A56
  BOTTOM w0.102: 104.93,73.73 104.93,73.82 105.8,74.69 CC303.1 105.34,75.9 v1(105.34,77.74) 105.34,78.44 RC230.2 RC82.1
PCH_JTAG_TMS: length 98.3
  TOP w0.102: v1(49.91,27.18) v3(50.68,27.18) 51.45,27.18 52.2,27.93 RC228.2
  IN1 w0.089: v1(103.82,72.41) 103.02,72.41 102.46,71.85 100.78,71.85 99.4,73.23 97.73,73.23 97.16,72.66 93.16,72.66 87.74,67.24 86.65,67.24 86.01,66.6 86.01,65.98 82.72,62.69 82.72,59.37 78.52,55.16 74.39,55.16 73.35,54.12 71.86,54.12 71.11,53.37 67.75,53.37 67.32,53.8 65.03,53.8 63.19,51.96 63.19,49.31 59.03,45.15 59.03,42.34 56.1,39.41 55.96,39.41 54.17,37.62 54.17,36.93 53.5,36.26 52.91,36.26 50.12,33.48 50.12,28.49 49.66,28.03 49.66,27.43 v1(49.91,27.18)
  BOTTOM w0.076: UC1.C59 104.39,68.72 104.47,68.98 104.47,69.15 104.41,69.34 104.41,69.49 104.47,69.61 104.47,69.87 104.3,70.04 104.3,71.93 v1(103.82,72.41)
  BOTTOM w0.102: RC130.1 103.16,78.59 103.16,78.01 103.58,77.6 103.58,74.71 103.64,74.65 103.64,73.81 103.82,73.62 v1(103.82,72.41)
PCH_PCIE_WAKE#: length 278.2
  TOP w0.102: RE274.2 309.12,67.53 307.27,67.53 306.96,67.84 v1(306.96,68.09) ; v1(133.1,36.21) 132.97,36.34 RC67.1 ; UE1.L1 v1(303.56,71.42)
  IN1 w0.089: v1(303.56,71.42) 303.73,71.42 304.36,70.8 304.36,69.25 305.52,68.09 v1(306.96,68.09)
  IN3 w0.122: v1(181.26,39.63) 184.28,36.6 185.33,36.6 187.5,34.44 192.32,34.44 199.56,27.2 199.83,27.2 199.84,27.2 201.95,27.2 206.49,22.65 207.53,22.65 211.07,19.11 213.79,19.11 214,19.32 218.5,19.32 219,18.81 222.71,18.81 223.12,19.22 224.08,19.22 224.49,18.81 230.59,18.81 232.72,20.95 240.63,20.95 245.5,25.81 248.8,25.81 249.78,26.79 256.17,26.79 257.1,27.73 259.42,27.73 260.74,29.05 279.18,29.05 v1(280.92,30.78)
  IN4 w0.089: v1(280.92,30.78) 282.95,32.82 282.95,38.54 285.07,40.66 285.07,41.03 285.35,41.3 287.01,41.3 288.79,43.08 288.79,43.53 289.89,44.64 293.8,44.64 293.83,44.67 294.32,44.67 294.68,44.32 299.16,44.32 299.52,43.96 303.79,43.96 304.17,44.34 305.25,44.34 305.5,44.6 305.5,45.29 305.88,45.67 306.91,45.67 307.67,46.44 307.67,52.4 306.6,53.47 306.6,56.98 305.76,57.82 305.76,58.8 304.98,59.58 304.18,59.58 303.91,59.3 300.54,59.3 300.2,59.64 300.2,60.09 300.39,60.27 303.51,60.27 303.75,60.52 304.47,60.52 307.15,63.2 307.15,64.43 307.42,64.69 308.64,65.91 308.64,67.48 308.03,68.09 v1(306.96,68.09)
  BOTTOM w0.076: 131.99,43.09 130.42,44.66 129.98,44.66 128.84,45.81 128.84,47 UC1.BB15
  BOTTOM w0.102: v1(181.26,39.63) 181.81,39.08 181.81,32.09 174.07,24.35 139.17,24.35 133.6,29.92 133.6,35.62 133.1,36.11 v1(133.1,36.21) 133.56,36.67 133.56,39.09 132.06,40.58 132.06,41.62 v2(132.36,41.93) 132.09,42.21 132.09,42.99 131.99,43.09
PCH_PLTRST#: length 48.8
  TOP w0.102: v1(155.9,39.96) v2(155.26,40.59) 153.28,42.58 143.34,42.58 139.78,46.14 139.47,46.14 137.13,48.47 137.13,50.93 136.4,51.66 135.11,51.66 134.63,52.14 133.02,52.14 132.56,52.59 v1(132.52,52.59)
  BOTTOM w0.102: 157.58,52.12 157.52,52.12 157.26,51.85 157.26,50.74 RC60.1 158.06,49.94 158.06,49.23 157.23,48.41 157.23,41.29 v1(155.9,39.96) ; 157.58,52.12 157.42,52.28 157.42,52.6 157.59,52.77 UC7.1 ; 157.58,52.12 UC7.2 158.05,52.05 RC244.1 RC62.1 ; v1(132.52,52.59) 132.27,52.59 UC1.AN10
PCH_PLTRST#_5105: length 48.3
  TOP w0.102: UE1.K1 302.76,71.38 303.3,70.84 v1(303.56,70.84)
  IN4 w0.089: v1(276.82,71.73) 277.03,71.73 279.3,69.47 279.3,69.25 282.14,66.41 285.6,66.41 286.57,67.38 293.55,67.38 294.73,68.56 297.81,68.56 300.33,71.09 303.13,71.09 303.38,70.84 v1(303.56,70.84)
  BOTTOM w0.102: UE6.4 268.09,75.77 RE340.1 268.09,76.26 268.3,76.46 270.17,76.46 270.75,75.89 v2(270.75,74.03) 270.75,72 271.96,70.79 274.61,70.79 275.55,71.73 v1(276.82,71.73)
PCH_PLTRST#_AND: length 464
  TOP w0.102: v1(219.08,20.77) 219.08,19.59 CZ61.1 220.1,19.53 RZ114.1 ; v1(28.83,48.41) 28.58,48.66 UR1.1 ; v1(206.35,12.46) 207.04,11.77 207.04,11.35 208.03,10.36 208.03,9.62 208.82,8.83 208.82,5.48 208.69,5.35 208.69,3.46 v2(207.51,2.28) v1(207.15,1.92)
  IN1 w0.089: v1(216.82,13.38) 217.35,13.91 218.8,13.91 220.93,11.78 222.1,11.78 222.68,12.36 229.86,12.36 231.39,13.89 231.39,16.78 233.75,19.13 245.1,19.13 246.38,20.41 252.84,20.41 255.6,23.17 257.61,23.17 259.99,25.55 262.13,25.55 262.7,24.97 263.59,24.97 264.23,25.61 264.95,25.61 265.28,25.94 267.6,25.94 268.05,25.49 294.44,25.49 294.75,25.8 295.28,25.8 295.7,25.38 v1(295.7,25.24)
  IN2 w0.122: v1(207.15,1.92) 204.5,1.92 203.39,3.04 196.69,3.04 195.79,3.93 194.4,3.93 191.52,6.81 191.52,7.86 185.65,13.73 138.69,13.73 127.64,24.78 59.85,24.78 55.28,29.35 51.13,29.35 50.49,29.99 46.74,29.99 30.64,46.09 30.64,46.45 28.83,48.25 v1(28.83,48.41)
  IN3 w0.122: v1(298.58,47.59) 297.19,46.2 297.19,44.9 296.88,44.6 295.86,44.6 294.91,43.65 294.91,43.01 293.22,41.32 293.22,40.59 292.84,40.21 292.84,39.94 292.21,39.32 292.21,38.33 291.22,37.33 290.45,37.33 v1(282.28,29.15)
  IN4 w0.089: v1(282.28,29.15) 282.85,29.73 284.63,29.73 285.2,30.29 288.96,30.29 289.72,29.53 291.52,29.53 292.26,28.8 292.26,27.6 292.41,27.45 292.41,27.04 292.87,26.59 293.55,26.59 294.37,25.77 295.17,25.77 v1(295.7,25.24) ; v1(162.72,55.21) 161.19,53.68 161.19,51.58 163.5,49.26 163.5,48.18 165.27,46.41 165.98,46.41 178.59,33.8 178.59,29.13 183.37,24.35 183.37,21 186.81,17.57 186.81,16.4 190.96,12.25 196.42,12.25 197.29,11.38 204.47,11.38 205.54,12.46 v1(206.35,12.46) 206.36,12.46 208.92,12.46 210.52,10.86 212.53,10.86 213.05,11.38 214.83,11.38 v1(216.82,13.38)
  BOTTOM w0.102: JNGFF2.50 299.05,48.06 v1(298.58,47.59) ; JNGFF3.50 v1(295.7,25.24) ; RC325.1 156.58,50.37 RC65.1 155.78,50.77 156.08,51.06 UC7.4 156.35,51.47 156.85,51.96 156.85,52.85 158.12,54.12 161.63,54.12 v1(162.72,55.21) ; v1(216.82,13.38) 217.33,13.89 217.33,17.99 217.94,18.6 217.94,18.79 218.45,19.3 218.45,20.13 v1(219.08,20.77) ; JNGFF1.52 207.26,12 206.8,12.46 v1(206.35,12.46) 205.56,12.46 205.11,12.01 205.11,9.52 206.46,8.17 207.7,8.17 208.03,8.5 JNGFF1.66
