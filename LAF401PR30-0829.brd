# Allegro board LAF401PR30-0829.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RV87  4.7K_0402_5%  [R_0402]  94.82 92.98 180 top
RV88  4.7K_0402_5%  [R_0402]  94.82 92.09 180 top
RV89  4.7K_0402_5%  [R_0402]  97.85 88.54 0 top
RV90  4.7K_0402_5%  [R_0402]  97.87 89.43 180 top
RV91  4.7K_0402_5%  [R_0402]  107.69 91.08 0 top
RV92  4.7K_0402_5%  [R_0402]  107.69 91.97 0 top
RV93  4.7K_0402_5%  [R_0402]  95.7 91.22 270 top
RV94  4.7K_0402_5%  [R_0402]  96.59 91.22 270 top
RV95  4.7K_0402_5%  [R_0402]  94.81 91.22 270 top
RV96  4.7K_0402_5%  [R_0402]  93.92 91.22 270 top
RV97  4.99K_0402_1%  [R_0402]  107.69 92.86 0 top
RV102  100K_0402_5%  [R_0402]  274.52 59.82 90 bottom
RV106  4.7K_0402_5%  [R_0402]  275.4 59.82 90 bottom
RV107  4.7K_0402_5%  [R_0402]  276.67 59.82 90 bottom
RV116  75_0402_1%  [R_0402]  281.74 58.57 0 top
RV117  75_0402_1%  [R_0402]  281.74 57.8 0 top
RV118  75_0402_1%  [R_0402]  281.74 57.04 0 top
RV119  2.2K_0402_5%  [R_0402]  317.63 80.93 270 top
RV120  2.2K_0402_5%  [R_0402]  317.89 74.44 180 top
RV121  1K_0402_5%  [R_0402]  315.6 76.36 270 top
RV122  1K_0402_5%  [R_0402]  315.6 78.64 270 top
RV123  4.7K_0402_5%  [R_0402]  277.45 50.11 180 top
RV124  4.7K_0402_5%  [R_0402]  275.21 51.25 0 top
RV323  0_0402_5%  [R0402_0OHM]  153.62 57.74 180 top
RV324  0_0402_5%  [R_0402]  152.86 55.83 180 top
RV326  100K_0402_5%  [R_0402]  153.62 56.79 180 top
RV400  0_0402_5%  [R_0402]  128.07 92.93 270 bottom
RV620  4.7K_0402_5%  [R_0402]  277.88 50.92 180 top
RV622  4.7K_0402_5%  [R_0402]  278.16 51.71 180 top
RV650  75_0402_1%  [R_0402]  316.62 77.73 90 top
RV651  75_0402_1%  [R_0402]  316.62 75.44 90 top
RZ8  2.2K_0402_5%  [R_0402]  217.86 10.43 0 top
RZ9  2.2K_0402_5%  [R_0402]  217.86 11.7 0 top
RZ10  100K_0402_5%  [R_0402]  220.4 20.44 0 top
RZ18  4.7K_0402_5%  [R_0402]  215.35 19.42 90 top
RZ19  4.7K_0402_5%  [R_0402]  215.35 22.12 270 top
RZ20  2.2K_0402_5%  [R_0402]  220.86 24.15 180 top
RZ21  2.2K_0402_5%  [R_0402]  220.86 25.29 180 top
RZ22  0_0402_5%  [R_0402]  216.24 20.34 270 top
RZ23  0_0402_5%  [R_0402]  216.24 21.2 90 top
RZ25  150_0402_5%  [R_0402]  269.12 75.71 180 top
RZ26  0_0402_5%  [R0402_0OHM]  216.74 24.15 180 top
RZ28  330_0402_5%  [R_0402]  284.61 53.61 270 top
RZ29  0_0402_5%  [R0402_0OHM]  216.74 25.16 180 top
RZ32  330_0402_5%  [R_0402]  316.92 98.57 0 bottom
RZ38  100K_0402_5%  [R_0402]  187.84 15.51 0 top
RZ40  100K_0402_5%  [R_0402]  272.29 50.97 0 bottom
RZ43  47K_0402_5%  [R_0402]  290.45 50.51 270 top
RZ56  0_0402_5%  [R0402_0OHM]  198.2 13.35 180 top
RZ58  33_0402_5%  [R_0402]  162.3 34.44 0 top
RZ59  33_0402_5%  [R_0402]  160.14 36.78 0 top
RZ60  33_0402_5%  [R_0402]  159.76 39.83 0 top
RZ61  0_0402_5%  [R0402_0OHM]  157.6 37.99 0 top
RZ62  10K_0402_5%  [R_0402]  165.75 33.36 180 top
RZ63  33_0402_5%  [R_0402]  159.76 38.94 0 top
RZ64  0_0402_5%  [R0402_0OHM]  199.14 7.77 0 top
RZ65  0_0402_5%  [R_0402]  199.14 8.65 0 top
RZ69  10K_0402_5%  [R_0402]  162.82 40.67 270 top
RZ70  0_0402_5%  [R_0402]  182.25 15.47 270 top
RZ71  0_0402_5%  [R_0402]  181.41 15.47 270 top
RZ76  0_0402_5%  [R_0402]  296.55 48.84 90 top
RZ77  0_0402_5%  [R_0402]  297.44 48.84 90 top
RZ78  0_0402_5%  [R_0402]  197.29 12.34 0 top
RZ79  0_0402_5%  [R_0402]  197.29 11.32 0 top
RZ80  0_0402_5%  [R_0402]  197.29 10.31 0 top
RZ81  0_0402_5%  [R_0402]  197.29 9.29 0 top
RZ89  0_0402_5%  [R0402_0OHM]  173.75 40.85 180 top
RZ112  0_0402_5%  [R0402_0OHM]  167.84 32.45 90 top
RZ114  0_0402_5%  [R_0402]  220.15 19.58 0 top
RZ116  10K_0402_5%  [R_0402]  219.08 24.02 180 top
RZ117  10K_0402_5%  [R_0402]  219.08 25.29 180 top
RZ119  0_0402_5%  [R_0402]  123.32 27.63 90 top
RZ120  0_0402_5%  [R0402_0OHM]  129.88 29.92 180 top
RZ128  0_0201_5%  [R_0201]  301.57 46.73 270 top
RZ129  0_0201_5%  [R_0201]  302.2 46.79 270 top
RZ130  0_0201_5%  [R_0201]  302.84 46.79 270 top
RZ132  0_0402_5%  [R_0402]  299.53 50.2 270 top
RZ151  0_0603_5%  [R_0603]  143.64 89.93 0 bottom
RZ154  10K_0402_5%  [R_0402]  282.88 61.3 0 top
RZ155  10K_0402_5%  [R_0402]  283.8 62.25 180 top
RZ156  10K_0402_5%  [R_0402]  286.1 59.67 90 bottom
RZ157  10K_0402_5%  [R_0402]  285.15 60.59 270 bottom
RZ158  10K_0402_5%  [R_0402]  293.2 62.76 180 bottom
RZ159  10K_0402_5%  [R_0402]  292.28 61.8 0 bottom
RZ160  10K_0402_5%  [R_0402]  287.03 59.67 90 bottom
RZ161  10K_0402_5%  [R_0402]  287.91 60.59 270 bottom
RZ162  10K_0402_5%  [R_0402]  290.61 59.67 90 bottom
RZ163  10K_0402_5%  [R_0402]  289.72 60.59 270 bottom
RZ164  10K_0402_5%  [R_0402]  289.81 68.46 270 bottom
RZ165  10K_0402_5%  [R_0402]  288.86 67.54 90 bottom
RZ166  10K_0402_5%  [R_0402]  293.2 63.65 180 bottom
RZ167  10K_0402_5%  [R_0402]  292.28 64.66 0 bottom
RZ320  0_0402_5%  [R_0402]  132.59 79.52 180 bottom
RZ326  0_0402_5%  [R_0402]  292.17 42.19 270 top
RZ334  51_0402_5%  [R_0402]  117.8 108.84 90 bottom
RZ335  15K_0402_5%  [R_0402]  117.8 111.54 270 bottom
RZ345  0_0402_5%  [R0402_0OHM]  268.79 53.36 0 top
RZ346  0_0402_5%  [R0402_0OHM]  214.91 24.1 270 top
RZ347  0_0402_5%  [R0402_0OHM]  214.91 24.96 90 top
RZ348  4.99K_0402_1%  [R_0402]  288.83 60.59 270 bottom
RZ354  10K_0402_5%  [R_0402]  286.03 68.46 270 bottom
RZ355  10K_0402_5%  [R_0402]  285.15 67.54 90 bottom
RZ356  10K_0402_5%  [R_0402]  286.95 68.46 270 bottom
RZ357  10K_0402_5%  [R_0402]  287.91 67.54 90 bottom
RZ358  10K_0402_5%  [R_0402]  290.76 68.46 270 bottom
RZ359  10K_0402_5%  [R_0402]  291.72 67.54 90 bottom
RZ360  100K_0402_5%  [R_0402]  291.28 65.79 90 top
RZ361  150_0402_5%  [R_0402]  267.72 68.98 90 top
RZ362  10K_0402_5%  [R_0402]  173.69 37.04 180 top
RZ363  0_0402_5%  [R_0402]  171.91 37.04 180 top
RZ364  100_0402_5%  [R_0402]  223.33 24.54 270 top
RZ365  0_0402_5%  [R0402_0OHM]  170.44 42.93 90 top
RZ366  0_0402_5%  [R_0402]  170.24 41.86 0 top
RZ367  0_0402_5%  [R_0402]  172.01 41.86 0 top
RZ368  0_0402_5%  [R0402_0OHM]  173.3 43.85 270 top
RZ369  0_0402_5%  [R_0402]  174.25 43.85 270 top
RZ370  100_0603_5%  [R_0603]  316.74 72.73 0 top
RZ380  0_0402_5%  [R_0402]  115.02 85.13 180 bottom
RZ518  10K_0402_5%  [R_0402]  180.78 13.12 180 top
SW1  SS3-CMFTQR9_3P  [SW_SS3-CMFTQR9_3P]  273.53 88.39 90 bottom
SW3  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  322.19 92.65 90 top
T1  PAD~D  [TPC12]  111.03 65.42 0 top
T2  PAD~D  [TPC12]  110.09 66.34 0 top
T3  PAD~D  [TPC12]  104.04 42.63 180 bottom
T4  PAD~D  [TPC12]  103.02 41.58 180 bottom
T5  PAD~D  [TPC12]  104.88 52.55 0 top
T6  PAD~D  [TPC12]  106.3 53.03 0 top
T9  PAD~D  [TPC12]  90.3 82.57 180 bottom
T10  PAD~D  [TPC12]  107.52 76.09 180 bottom
T11  PAD~D  [TPC12]  106.62 74.63 180 bottom
T12  PAD~D  [TPC12]  95.13 43.96 180 bottom
T13  PAD~D  [TPC12]  94.05 43.07 180 bottom
T14  PAD~D  [TPC12]  128.62 55 0 top
T15  PAD~D  [TPC12]  131.02 54.76 0 top
T16  PAD~D  [TPC12]  92.97 43.77 180 bottom
T17  PAD~D  [TPC12]  94.87 41.94 180 bottom
T18  PAD~D  [TPC12]  134.03 56.14 0 top
T19  PAD~D  [TPC12]  138.94 79.2 180 bottom
T50  PAD~D  [TPC12]  81.16 2.66 0 top
T51  PAD~D  [TPC12]  82.43 15.19 0 top
T54  PAD~D  [TPC12]  167.02 4.44 0 top
T55  PAD~D  [TPC12]  163.71 14.43 0 top
T87  PAD~D  [TPC12]  318.18 83.66 180 bottom
T88  PAD~D  [TPC12]  274.02 84.63 90 top
T89  PAD~D  [TPC12]  273.99 83.33 90 top
T113  PAD~D  [TPC12]  92.78 45.36 180 bottom
T114  PAD~D  [TPC12]  92.27 42.56 180 bottom
T115  PAD~D  [TPC12]  130.84 49.4 0 top
T120  PAD~D  [TPC12]  130.08 61.92 0 top
T122  PAD~D  [TPC12]  119.77 64.98 0 top
T123  PAD~D  [TPC12]  118.89 54.91 0 top
T126  PAD~D  [TPC12]  142.98 45.46 180 bottom
T127  PAD~D  [TPC12]  143.62 44.32 180 bottom
T128  PAD~D  [TPC12]  142.31 50.88 180 bottom
T129  PAD~D  [TPC12]  142.56 52.34 180 bottom
T130  PAD~D  [TPC12]  142.93 43.22 180 bottom
T132  PAD~D  [TPC12]  93.48 41.8 180 bottom
T141  PAD~D  [TPC12]  297.79 69.21 0 top
T142  PAD~D  [TPC12]  304.04 82.95 180 bottom
T143  PAD~D  [TPC12]  310.2 76.15 0 top
T144  PAD~D  [TPC12]  306.52 69.93 0 top
T147  PAD~D  [TPC12]  306.54 72.85 0 top
T204  PAD~D  [TPC12]  99.14 90.72 0 top
T219  PAD~D  [TPC12]  31.5 84.66 0 bottom
T220  PAD~D  [TPC12]  30.04 85.49 0 bottom
T223  PAD~D  [TPC12]  98.15 91.76 0 top
T224  PAD~D  [TPC12]  103.59 91.74 0 top
T225  PAD~D  [TPC12]  301.34 39.6 180 bottom
T258  PAD~D  [TPC12]  140.04 41.88 180 bottom
T262  PAD~D  [TPC12]  312.11 76.15 0 top
T264  PAD~D  [TPC12]  300.28 81.76 180 bottom
T268  PAD~D  [TPC12]  142.7 41.93 180 bottom
T281  PAD~D  [TPC12]  108.29 66.31 0 top
T282  PAD~D  [TPC12]  109.2 68.95 0 top
T283  PAD~D  [TPC12]  167.44 41.27 180 top
TL1  350UH_IH-160  [TAIMA_IH-160_24P]  301.71 92.78 180 bottom
UA1  ALC3246-CG_MQFN48_6X6  [ALC3246-CG_MQFN48_6X6-S]  296.55 37.52 0 top
UC1  KBL-RU42_BGA1356  [KBL-RU42_BGA_1356P-T]  137.46 69.71 0 bottom
UC5  W25Q128JVSIQ_SO8  [W25Q128FVSIQ_SO8]  160.91 67.23 270 bottom
UC6  W25Q128JVSIQ_SO8  [W25Q128FVSIQ_SO8]  160.53 58.59 270 bottom
UC7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  157.98 52.77 270 bottom
UC8  74CBTLV3126BQ_DHVQFN14_2P5X3  [74CBTLV3126BQ_DHVQFN14_2P5X3-S]  54.69 32.79 180 top
UC12  -  [74AHC1G09GW_TSSOP5]  149.74 90.9 270 bottom
UD1  -  [74AUP1G07GW_TSSOP5]  63.24 16.58 0 top
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  295.56 71.93 90 top
UE3  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  307.36 94.69 180 top
UE4  -  [74AUP1G07GW_TSSOP5]  289.56 87.03 270 top
UE5  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  304.82 94.69 180 top
UE6  -  [74AUP1G07GW_TSSOP5]  269.39 72.66 180 bottom
UI1  -  [SY6288D20AAC_SOT23-5]  21.27 76.08 270 top
UI2  -  [SY6288D20AAC_SOT23-5]  86.37 101.41 270 bottom
UI3  -  [SLGC55544CVTR_TQFN16_3X3]  309.49 61.77 180 top
UI5  PS8713BTQFN24GTR2_TQFN24_4X4  [PS8713BTQFN24GTR2_TQFN24_4X4-S]  300.38 54.36 0 top
UL1  WGI219LM-QREF- A0_QFN48_6X6~D  [WGI217LM-QPN9-A2_QFN48_6X6-S]  281.24 83.42 90 top
UL2  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  273.62 89.03 90 top
UN4  PS8558BTQFN24GTR2-A_TQFN24_4X4  [PS8558BTQFN24_TQFN24_4X4-S]  261.35 48.26 0 top
UN5  PS8558BTQFN24GTR2-A_TQFN24_4X4  [PS8558BTQFN24_TQFN24_4X4-S]  288.89 53.91 90 top
UN7  PI3EQX6741STZDEX_TQFN20_4X4  [PI3EQX6741STZDEX_TQFN20_4X4-S]  278.14 65.3 270 top
UR1  RTS5242-GR_QFN32_4X4  [RTS5242-GR_QFN32_4X4-S]  27.84 48.66 180 top
UT5  TPS65982DC_BGA96  [TPS65982_BGA_96P]  35.14 83.04 270 top
UT6  GD25Q80CSIGR_SO8  [W25Q80DVSSIG_SO8]  32.52 92.4 180 bottom
UT7  AP2112K-3.3TRG1_SOT23-5  [AP2112K-3P3TRG1_SOT23-5]  40.85 98.64 90 bottom
UT8  AP2204R-5.0TRG1_SOT89-3  [AP2204R-5P0TRG1_SOT89-3]  46.41 98.64 180 top
UT9  TUSB546A_QFN40_4X6  [TUSB546_QFN40_4X6]  19.81 97.81 270 bottom
UV2  -  [AP2330W-7_SC59-3]  114.11 104.53 180 top
UV4  -  [AP2330W-7_SC59-3]  316.11 75.71 0 bottom
UV6  RTD2166-CG_QFN32_4X4  [RTD2166-CG_QFN32_4X4-S]  275.64 56.47 0 top
UV7  PS8338BQFN60GTR-A0_QFN60_5X9  [PS8338BQFN60GTR-A0_QFN60_5X9-S]  98 92.97 0 top
UV24  -  [G524B1T11U_SOT23-5]  98.15 83.96 270 bottom
UZ2  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  274.82 48.98 90 bottom
UZ3  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  201.73 8.81 270 top
UZ4  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  190.88 17.73 270 top
UZ5  EM5209VF_SON14_2X3  [TPS22966DPUR_SON14_2X3-S]  276.16 75.46 180 top
UZ6  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  137.42 27.7 0 top
UZ8  AOZ1336_DFN8_2X2  [AOZ1336_DFN8_2X2-S]  271.65 51.92 180 top
UZ10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  279.93 49.1 180 top
UZ12  NPCT750JAAYX_QFN32_5X5  [NPCT650JB2YX_QFN32_5X5]  169.62 35.67 180 top
UZ19  -  [TPS22961DNYR_WSON8]  131.83 81.43 180 bottom
UZ21  -  [TPS22961DNYR_WSON8]  128.48 83.73 270 bottom
UZ23  AOZ1336_DFN8_2X2  [AOZ1336_DFN8_2X2-S]  277.8 40.73 90 bottom
UZ26  -  [TPS22961DNYR_WSON8]  127.22 27.86 90 top
UZ34  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  130.88 27.5 90 top
UZ35  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  136.6 82.48 120 bottom
UZ36  PS8558BTQFN24GTR2-A_TQFN24_4X4  [PS8558BTQFN24_TQFN24_4X4-S]  285.25 65.33 0 top
YC1  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  118.07 81.91 180 bottom
YC2  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  153.93 42.18 90 bottom
YC3  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  148.87 76.3 270 bottom
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  290.79 69.85 90 top
YL1  25MHZ_18PF_7V25000034  [Y_7V25000034_4P]  290.03 90.58 180 top

## Library data of the parts
CA1-CA4 CA12 CA13 CA19 CA22-CA24 CA27 CA28 CA33 CA35 CA41 CA54 CA69 CZ126 CZ127 = C_0402: room: CODEC
CA5 CA6 CA62 CA72 = C_0402: room: CAMERA
CA7 CV12 CZ1 CZ2 = C_0201: room: LCD
CA8 PC1030-PC1053 PC1055 PC1056 PC1083-PC1099 PC1147-PC1153 = C_0201: room: ETY-ROOM
CA9 CA25 CA29 CA31 CA43 CA44 CA46 CA48 CA49 CA51-CA53 CA56 CA58 CA59 CA61 = C_0603: room: CODEC
CA10 CA45 CA47 CA55 CA57 CA60 CZ125 CZ128 = C_0201: room: CODEC
CA63-CA68 CE59 CE60 CI43-CI48 CL29 CL30 CR25-CR28 CT189 CT190 CV18-CV25 CZ3 CZ41 CZ62 CZ63 CZ83-CZ89 = C_0402: room: TBT
CC7 CC8 CC316 CC318-CC321 CE57 = C_0402: room: SPI ROM
CC9 CC10 = C_0201: room: SPI ROM
CC21-CC23 CC26 CC27 CC176-CC179 CC202 CC224 CC225 CC250 CC252 CC266 CC288 CC297 CC300-CC305 CC310 CC312 CC322-CC325 CE61 = C_0402: room: CPU
CC28-CC30 = C_0201: room: CPU XDP
CC32 CC33 CC269 CC306-CC308 = C_0402: room: CPU XDP
CC78-CC81 CC84-CC113 CC118 CC119 CC122-CC129 CD64-CD111 CE101 CE102 CE141 CE142 CE301 CE302 CE311 CE312 CE631 CE632 CN17 CR1501 CR1502 CR2201 CR2202 CZ50 CZ51 CZ54 CZ133 CZ1000-CZ1005 PC1328-PC1334 = C_0201
CC195 CC331-CC337 CC340 CC341 CE62 CE64-CE66 CE70 CI50-CI52 CN12-CN16 CT213 CV635 CZ10 CZ11 CZ57-CZ60 CZ75 CZ134-CZ136 CZ141 CZ142 CZ200 CZ210-CZ212 PC131-PC145 PC224 PC314-PC321 PC635 PC638 PC668 PC669 PC676 PC687 PC689-PC692 PC697 PC918 PC955-PC959 PC1215-PC1217 PC1335 = C_0402
CC210 = C_0805: room: CPU
CC214 CC223 CC270 CC281 CC313 CC314 = C_0201: room: CPU
CC219-CC221 CC226 CC279 CC280 CC294-CC296 = C_0603: room: CPU
CD1-CD8 CD20-CD22 CD33-CD40 CD52-CD54 = C_0603: room: MEMORY
CD17 CD49 = C_D3: room: MEMORY
CD25-CD27 CD29 CD31 CD57-CD59 CD61 CD62 = C_0402: room: MEMORY
CD28 CD32 CD60 = C_0201: room: MEMORY
CE3 CE4 CE12 CE24 CE26-CE29 CE35-CE40 CE46 CE47 CE54 = C_0402: room: KBC
CE8 = C_0402: room: SIO
CE11 CE13 CE15 CE18-CE23 CE25 = C_0201: room: KBC
CE16 CE17 CE32 = C_0603: room: KBC
CE52 CE53 = C_0402: room: PCH
CI1 = C_1206: room: JUSB2
CI3 CI7 = C_0201: room: JUSB2
CI4 CI5 = C_0402: room: JUSB2
CI6 = C_0603: room: JUSB2
CI8 = C_1206: room: JUSB3
CI10 CI12 = C_0201: room: JUSB3
CI11 = C_0603: room: JUSB3
CI13 CI16 CI31 CI37-CI42 = C_0402: room: JUSB1
CI14 = C_1206: room: JUSB1
CI17 CI19 = C_0201: room: JUSB1
CI27 CI28 = C_0402: room: JUSB3
CI29 CI30 CZ17-CZ19 CZ21 CZ23-CZ25 CZ198 = C_0402: room: WWAN
CI32 = C_B2-NPM: room: JUSB1
CI33 CI34 = C_0603: room: JUSB1
CI801 = C_A
CL1 CL2 CL5 CL6 CL13 CL14 CL18 = C_0402: room: LAN
CL3 CL7-CL11 CL15-CL17 CL19-CL21 = C_0201: room: LAN
CL4 CL12 = C_0603: room: LAN
CL22 = C_1808: room: LAN
CL28 = C_0805: room: LAN
CLIP1 = CLIP_SH1506X616
CMOS1 = SHORTPADS-NPM: User Part Number: PART#; room: CPU
CN1 = C_0603: room: HDD
CN2 CN3 CN9-CN11 CZ129 = C_0201: room: HDD
CN4-CN8 CZ130 = C_0402: room: HDD
CN20 CN30 CN61 CN62 = C_0201: room: SATA EXPRESS
CN21-CN23 CN26 CN27 CN31-CN33 CN36 CN37 CN69-CN72 = C_0402: room: SATA EXPRESS
CN60 CZ61 CZ64 CZ67-CZ69 CZ71-CZ73 = C_0402: room: USH
CN63 CN64 = C_0603: room: SATA EXPRESS
CR1 CR4 CR11-CR14 CR21 = C_0402: room: RTS5242
CR2 CR3 CR6 CR7 CR17 CR19 = C_0201: room: RTS5242
CR5 CR18 CR20 = C_0603: room: RTS5242
CT70-CT74 CT83 CT85-CT87 CT89-CT93 = C_0402: room: PD
CT75-CT78 = C_0805: room: PD
CT80 CT81 CT88 = C_0201: room: PD
CT82 CT84 CT94 = C_0603: room: PD
CT95-CT102 = C_0201: room: TBT
CT103-CT117 CT122 = C_0402: room: PS8740
CT118-CT121 = C_0201: room: PS8740
CV1-CV6 CV11 CV13 CV14 CV16 CV17 = C_0402: room: LCD
CV15 = C_0603: room: LCD
CV31-CV38 = C_0402: room: HDMI
CV39 CV40 = C_0201: room: HDMI
CV41 = C_0603: room: HDMI
CV81 CV82 CV96 = C_0402: room: PS8348
CV83-CV95 = C_0201: room: PS8348
CV100-CV112 CV126-CV135 = C_0402: room: CRT
CZ12 CZ13 CZ28 CZ29 CZ33-CZ36 = C_0402: room: WLAN
CZ20 = C_0603: room: WWAN
CZ26 = C_B2: room: WWAN
CZ27 CZ32 = C_0603: room: WLAN
CZ30 CZ31 = C_0201: room: WLAN
CZ37-CZ40 = C_0402: room: SIM
CZ52 CZ55 PC223 PC425 PC426 PC502 PC663-PC665 PC670 PC674 PC675 PC682-PC684 PC1322-PC1327 = C_0603
CZ53 = C_0201: room: TPM
CZ56 = C_0402: room: TPM
CZ66 = C_0201: room: USH
CZ80 CZ81 CZ91 CZ92 = C_0402: room: KBTP
CZ82 = C_0201: room: RSMRST
CZ90 = C_0201: room: KBTP
CZ93 = C_0201: room: LED
CZ101 = C_0201: room: +1.0V_VCCST
CZ103 = C_0201: room: +VCC_SFR_OC
CZ104 = C_0402: room: +VCC_SFR_OC
CZ106 = C_0201: room: +1.0V_VCCSTG
CZ109 CZ110 = C_0402: room: UZ2
CZ111 CZ122 = C_0201: room: UZ2
CZ112 CZ115 = C_0201: room: UZ3
CZ113 CZ114 = C_0402: room: UZ3
CZ116 CZ119 = C_0201: room: UZ4
CZ117 CZ118 CZ124 = C_0402: room: UZ4
CZ120 = C_0201: room: UZ8
CZ121 CZ197 = C_0402: room: UZ8
DA1-DA3 DA6 DA7 = L03ESDL5V0CC3-2_SOT23-3: room: CODEC
DA8 = RB520SM-30T2R_EMD2-2: room: KBC
DC1 DC2 DE2 DZ8 = RB520SM-30T2R_EMD2-2
DE1 = BZV55-B5V1_SOD80C2: room: KBC
DI1 = L05ESDL5V0NA-4_SLP2510P8-10-9: room: JUSB2
DI2 = AZC199-02SPR7G_SOT23-3: room: JUSB2
DI3 = AZC199-02SPR7G_SOT23-3: room: JUSB3
DI4 = L05ESDL5V0NA-4_SLP2510P8-10-9: room: JUSB1
DI5 = AZC199-02SPR7G_SOT23-3: room: JUSB1
DI6 = L05ESDL5V0NA-4_SLP2510P8-10-9: room: JUSB3
DT1-DT3 = 1N4148WS-7-F_SOD323-2: room: PD
DT4 = L30ESD24VC3-2_SOT23-3: room: ETY-ROOM
DT5 DT6 DT9 DT10 DT13 DT14 DT17 DT18 = ESD8011MUT5G_X3DFN2-2-S: room: ETY-ROOM
DT39 DT40 = L05ESDL5V0NA-4_SLP2510P8-10-9
DV1-DV3 = BAT54CW_SOT323-3: room: LCD
DV4 = AZC199-02SPR7G_SOT23-3: room: TOUCH
DV5 DV6 = PJDLC05C_SOT23-3: room: CRT
DZ1 DZ2 = RB520SM-30T2R_EMD2-2: room: WLAN
DZ5 DZ6 = RB520SM-30T2R_EMD2-2: room: WWAN
DZ7 = RB520SM-30T2R_EMD2-2: room: USH
DZ9 PD905 = BAT54CW_SOT323-3
FD1-FD4 = FIDUCIAL_C40M80: room: LED
H1-H4 = H_3P8: room: LED
H5 H6 = H_1P1N: room: LED
H7 H8 = H_3P2: room: LED
H9 H16 H26 = H_2P3-G: room: LED
H10 = H_3P0-G: room: LED
H12 H18 H23 H24 H28 H29 = H_2P5-G: room: LED
H14 H15 H17 H20 H22 = H_4P0-G: room: LED
H25 = H_2P2-G: room: LED
H32 = H_2P6X3P6-G: room: LED
H34 H35 = H_3P3: room: LED
H38 = H_3P8
H42 = H_0P7N
H43 = H_0P9N
JAPS1 = ACES_50506-01841-P01_18P: room: CPU
JCRT1 = CCM_C070546HR015M29CZR_15P-T: room: CRT
JDB1 = JXT_FP241AH-006GAAM_6P: room: PD
JDEG1 = JXT_FP241AH-010GAAM_10P: room: KBC
JDIMM1 JDIMM2 = LCN_DAN05-Q0406-0103_260P: room: ETY-ROOM
JEDP1 = ACES_50398-04041-001_40P: room: LCD
JESPI = JXT_FP241AH-010GAAM_10P: room: ETY-ROOM
JFAN1 = ACES_50271-0040N-001_4P: room: KBC
JHDMI1 = CONCR_099BKAC19YBLCNF_19P: room: HDMI
JHP1 = SINGA_2SJ3095-136111F_7P-T: room: CODEC
JIR1 = ACES_50208-0060N-P01_6P: room: CAMERA
JKBTP1 = CVILU_CF5020FD0RK-05-NH_20P-T: room: KBTP
JLED1 = CVILU_CF5006FD0R0-05-NH_6P: room: LED
JLOM1 = SANTA_130456-831_13P-T: room: LAN
JNGFF1 = CONCR_213AAAA42FA_75P: room: WLAN
JNGFF2 = CONCR_213BAAA42FA_75P: room: WWAN
JNGFF3 = LCN_DAN05-67356-0103_75P: room: SATA EXPRESS
JRTC1 = ACES_50271-0020N-001_2P: room: ETY-ROOM
JSATA1 = ACES_59003-02006-002_20P: room: ETY-ROOM
JSD1 = T-SOL_156-2000302608_19P_NR: room: RTS5242
JSIM1 = T-SOL_5-991503004000-6_8P-T: room: SIM
JSPI1 = ACES_50506-02041-P01_20P: room: ETY-ROOM
JSPK1 = ACES_50278-00401-001_4P: room: CODEC
JTAG1 = SHORTPADS: User Part Number: PART#; room: KBC
JUSB1 = C-K_26230A-8K1A-02_9P-T: room: JUSB3
JUSB2 = LOTES_AUSB0014-P003A_9P: room: JUSB3
JUSB3 = C-K_26210B-8K1A-02_9P: room: JUSB3
JUSBC1 = JAE_DX07BD24JJ2_24P-T: room: TBT
JUSH1 = CVILU_CF5026FD0RK-05-NH_26P-T: room: USH
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P: room: CPU XDP
LA5 LA12 LA14 = MURAT_BLM15PX600SN1D_2P: room: CODEC
LA6-LA9 = MURAT_BLM15PD800SN1D_2P: room: CODEC
LA10 LA11 = MURAT_BLM15PX330SN1D_2P: room: CODEC
LA13 = TAI-T_HCB2012KF-121T50_2P: room: CODEC
LA15 LA16 = MURAT_BLM15PX330SN1D_2P
LC1 LC2 = MURAT_BLM15GA750SN1D_2P: room: ETY-ROOM
LE1 LZ2 = MURAT_BLM15GA750SN1D_2P
LED3 = LED_LTW-C193DC-C_2P: room: LED
LGA1 = LNG2DMTR_LGA12_2X2
LI3 = PANAS_EXC24CQ900U_4P: room: JUSB2
LI4 = PANAS_EXC24CQ900U_4P: room: JUSB3
LI7 = PANAS_EXC24CQ900U_4P: room: JUSB1
LI8 LI9 = INPAQ_MCM1012B900F06BP_4P: room: ETY-ROOM
LI16 LI17 = INPAQ_HCM1012GH900BP_4P: room: ETY-ROOM
LL1 = TAIYO_BRC2012T4R7MD_2P: room: LAN
LT11 LV14 LV30 = MURAT_BLM15PX600SN1D_2P: room: CRT
LV1 = MURAT_BLM15PX221SN1D_2P: room: LCD
LV3 LV6 LV9 LV12 = TAIYO_MCF12102G900-T_4P-NPM: room: HDMI
LV16-LV18 = MURAT_BLM15BB470SN1D_2P: room: CRT
LV27 = PANAS_EXC24CQ900U_4P: room: TOUCH
LZ1 = PANAS_EXC24CQ900U_4P: room: CAMERA
PBATT1 = DEREN_40-42251-01001RHF_10P-T: room: ETY-ROOM
PC1 PC2 PC1203 PC1208-PC1210 = C_0402: room: P_DCIN
PC3-PC7 PC1202 = C_0603: room: P_DCIN
PC8 PC106-PC110 PC120-PC124 PC129 PC130 PC200 PC201 = C_0805: room: ETY-ROOM
PC9 PC605 PC618-PC620 PC626 PC627 PC632 PC637 PC639 PC641 PC642 PC644 PC645 PC647 PC649-PC654 PC659-PC661 PC677 PC685 PC949 PC1204 = C_0402: room: CPU_CORE
PC10 PC113 PC127 PC301 PC303 PC307 PC401 PC402 PC408-PC411 PC417-PC420 PC513 PC515 PC601 PC602 PC613 PC614 PC616 PC617 PC621 PC624 PC625 PC628-PC631 PC633 PC636 PC640 PC643 PC646 PC686 PC688 PC944 PC1211 PC1212 PC1214 = C_0402: room: ETY-ROOM
PC11 = C_0603: room: UPD
PC100 PC103 PC115 PC116 = C_0402: room: 3_5V
PC102 PC111 PC114 PC119 PC126 = C_0603: room: 3_5V
PC104 PC105 PC117 PC118 = C_0805: room: 3_5V
PC112 PC125 PC128 PC302 PC304-PC306 PC308-PC313 PC403 PC404 PC406 PC407 PC412 PC413 PC415 PC416 PC424 PC501 PC504 PC514 PC516 PC940 PC941 PC1001-PC1026 PC1057-PC1061 PC1064-PC1082 PC1129 PC1132-PC1134 PC1136 PC1137 PC1139-PC1146 PC1175-PC1181 = C_0603: room: ETY-ROOM
PC202 PC203 PC206-PC208 PC216-PC218 PC221 PC222 = C_0402: room: P_1.2V
PC204 PC205 PC209-PC214 PC219 = C_0603: room: P_1.2V
PC503 PC505 PC506 = C_0402: room: 1.8V
PC603 PC604 PC608 PC611 PC612 PC622 PC655-PC658 PC662 PC671-PC673 PC678 = C_0603: room: CPU_CORE
PC606 = C_D: room: ETY-ROOM
PC607 = C_D
PC902 PC903 PC925-PC927 PC932 PC933 PC937-PC939 PC942 PC943 PC945-PC947 PC950 PC1201 PC1205-PC1207 PC1213 = C_0402: room: CHARGER
PC904-PC906 PC911 PC935 PC936 = C_0805: room: CHARGER
PC909 = C_B2: room: ETY-ROOM
PC913-PC916 = C_0805: room: PWR_CHARGER
PC921 = C_B2
PC928 PC929 = C_0402: room: PWR_CHARGER
PC930 PC934 = C_0603: room: CHARGER
PC931 = C_0603: room: PWR_CHARGER
PC951 PC952 = C_0805
PC1062 PC1063 PC1127 PC1128 = C_D2: room: CPU
PC1321 = C_D2
PD1 PD2 = TVNST52302AB0_SOT523-3: room: ETY-ROOM
PD3 = DB3J315E0L_SMINI3-F2-B3: room: ETY-ROOM
PD4 = PESD5V0U2BT_SOT23-3: room: ETY-ROOM
PD5 PD1202 = PDS5100H-13_POWERDI5-3: room: P_SELECTOR
PD6 = DFLS160-7_POWERDI123-2
PD901 PD904 = SDMK0340L-7-F_SOD323-2: room: ETY-ROOM
PD903 = RB520SM-30T2R_EMD2-2: room: ETY-ROOM
PD906 = SMF22A-SOD123FL-2-S
PD1205 = SDMK0340L-7-F_SOD323-2: room: P_SELECTOR
PD1801 = BAT54CW_SOT323-3: room: ETY-ROOM
PH601 PH603-PH605 PR612 PR623 PR628 PR632 PR633 PR636 PR638 PR641-PR643 PR645-PR650 PR652 PR656 PR657 = R_0402: room: CPU_CORE
PH602 PR102 PR108 PR116 PR117 PR205 PR207 PR302 PR306 PR308 PR311 PR403 PR404 PR407 PR408 PR410-PR412 PR422 PR427 PR428 PR514-PR516 PR601 PR604 PR605 PR608 PR610 PR611 PR613 PR617 PR618 PR621 PR622 PR626 PR629-PR631 PR635 PR639 PR640 PR644 PR651 PR671 PR678 PR919 PR927 PR932-PR934 PR1201 PR1208 PR1217 PR1219 PR1237 PR1239 PR1240 PR1246 PR1247 RC211 RC214 RC337 RE300 RE361 RE362 RN171 RN174 RN176 RN179 RN182-RN185 RN188 RN189 RZ22 RZ23 RZ43 RZ60 RZ70 RZ334 RZ335 = R_0402: room: ETY-ROOM
PJP1 = JUMP_43X39: room: +1.0V_VCCST
PJP2 = JUMP_43X39: room: +1.0V_VCCSTG
PJP3 = JUMP_43X118: room: +1.0V_MPHYGT
PJP4 PJP19 PJP37 = JUMP_43X39: room: UZ2
PJP7 = JUMP_43X39: room: PD
PJP8 = JUMP_43X118: room: PD
PJP12 = JUMP_43X39: room: LCD
PJP14 = JUMP_43X79: room: RTS5242
PJP15 PJP16 PJP18 = JUMP_43X39: room: CODEC
PJP17 PJP34 PJP40 = JUMP_43X79: room: UZ4
PJP20-PJP22 = JUMP_43X39: room: KBC
PJP31 = JUMP_43X118: room: SATA EXPRESS
PJP32 PJP33 = JUMP_43X39: room: HDD
PJP35 = JUMP_43X39: room: KBTP
PJP36 = JUMP_43X79: room: UZ2
PJP38 = JUMP_43X39: room: UZ3
PJP39 = JUMP_43X118: room: UZ3
PJP41 = JUMP_43X118: room: UZ4
PJP42 = JUMP_43X39: room: UZ8
PJP100 PJP101 PJP202 PJP301 PJP602 = JUMP_43X79: room: DDR_VTT_0.75V
PJP102 PJP103 PJP1202 = JUMP_43X118: room: 1.5V
PJP200 = JUMP_43X118: room: P_1.2V
PJP201 = JUMP_43X39: room: P_1.2V
PJP302 = JUMP_43X118: room: ETY-ROOM
PJP391 PJP403 PJP404 PJP501 = JUMP_43X39
PJP401 PJP402 = JUMP_43X79: room: 1.5V
PJP502 PJP505 PJP506 PJP603 = JUMP_43X39: room: VGA_CORE
PJP601 = JUMP_43X118: room: CHARGER
PJP901 = JUMP_43X118-NPM: room: CHARGER
PJPDC1 = CVILU_CI0805M1HRC-NH_5P-T: room: ETY-ROOM
PL1 PL2 PL4 = TAIYO_FBMJ4516HS720NT_2P: room: P_DCIN
PL3 = MURAT_BLM15AG102SN1D_2P: room: P_DCIN
PL100 = L_7X7X3_M_2P: room: ETY-ROOM
PL101 = L_7X7X3_M_2P: room: VDDCI
PL201 = CYNTE_PCMB063T-1R0MS_2P: room: ETY-ROOM
PL301 = L_5X5X3_M_2P: room: ETY-ROOM
PL402 PL404 PL501 = MAG_MLV-FY12N1R0M-O1L_2P: room: ETY-ROOM
PL405 PL406 PL502 = 3A_Z120_0603_2P
PL602 = 9A_Z80_1812_2P-NPM: room: CPU_CORE
PL610 PL612 PL613 = L_7X7X3_M
PL614 = MAG_MMD05CZR47M_4P
PL901 = MAGLA_MMD-05CZ-1R0M-M7L_2P: room: ETY-ROOM
PL902 = CYNTE_PCMB103T-2R2MS_2P: room: ETY-ROOM
PL1201 PL1202 = TAI-T_HCB2012KF-121T50_2P: room: ETY-ROOM
PQ1 PQ1201 PQ1204 PQ1209 PQ1214 QE2 = DMN65D8LDW-7_SOT363-6: room: ETY-ROOM
PQ2 = FDV301N-G_SOT23-3: room: P_DCIN
PQ3 = MMST3904-7-F_SOT323-3: room: P_DCIN
PQ4 = FDMC6679AZ_MLP8-5: room: CHARGER
PQ5 PQ1203 PQ1215 = NTR4502PT1G_SOT23-3: room: P_CHARGER
PQ6-PQ8 PQ909 PQ1205 PQ1212 = DMN65D8LW-7_SOT323-3: room: ETY-ROOM
PQ9 PQ906 PQ1202 PQ1206 PQ1213 = FDMC6679AZ_MLP8-5: room: ETY-ROOM
PQ614 = AON7934_DFN3X3A8-10
PQ904 PQ905 = AOE6930_DFN5X6E8-10: room: ETY-ROOM
PQ1207 PQ1208 PQ1210 PQ1211 = DMN66D0LDW-7_SOT363-6: room: P_USBB
PQ1216 = DMN65D8LW-7_SOT323-3
PR1-PR8 PR11 PR12 PR14 PR16 PR18 PR24 PR27 PR1207 PR1210 PR1222 PR1224 PR1227-PR1229 PR1248 = R_0402: room: P_DCIN
PR10 PR15 PR17 PR28 PR944 PR945 PR1202 PR1205 PR1206 PR1209 PR1212-PR1214 PR1226 PR1230-PR1236 PR1249 PR1251-PR1253 = R_0402: room: P_SELECTOR
PR13 = R_0805: room: P_DCIN
PR19 PR21 PR22 PR25 PR1211 PR1215 PR1216 PR1218 PR1220 PR1223 PR1238 PR1250 = R0402_0OHM: room: P_DCIN
PR20 PR23 PR104 PR105 PR114 PR119 PR120 PR208 PR210 PR312 PR402 PR406 PR423 PR425 PR426 PR504 PR513 PR602 PR603 PR614 PR616 PR620 PR625 PR659 PR662 PR679 PR920 PR922 PR926 PR928 PR935 PR936 PR947 PR1243 RA35-RA37 RC37 RC170 RC173 RC228-RC231 RC235 RC300-RC308 RC328 RE32 RE275 RE290 RE318 RN99 RN186 RN187 RN192 RN223-RN225 RR6-RR10 RZ64 RZ345-RZ347 = R0402_0OHM: room: ETY-ROOM
PR26 PR1221 = R0402_0OHM: room: P_USBA
PR29 PR1225 = R0402_0OHM: room: P_SELECTOR
PR30 PR615 PR634 PR653 PR658 PR666 PR668 PR670 PR673 PR675 PR677 PR681 PR686 PR689 PR692 PR948 PR950 PR953 PR961 PR1254 PR1255 PR1258-PR1262 RA59-RA61 RC50 RC413 RC414 RC417-RC421 RC431-RC433 RC436-RC438 RC440 RC442 RC443 RC551 RC553-RC556 RC560 RC561 RE79 RE505 RE507 RE508 RE524-RE526 RE532 RE539 RE541 RE543 RE546 RE547 RE549-RE551 RE560 RE561 RE565 RN6-RN21 RN100 RN101 RN226-RN230 RT375-RT379 RT393 RT405-RT407 RT410-RT418 RV324 RV326 RV400 RV620 RV622 RV650 RV651 RZ62 RZ132 RZ154-RZ167 RZ348 RZ354-RZ364 RZ366 RZ367 RZ369 RZ380 RZ518 = R_0402
PR100 PR111 PR304 R274 RC169 RC299 RC309 RC310 = R0603_0OHM: room: ETY-ROOM
PR103 = R_0402: room: 3_5V
PR106 PR112 = R_1206: room: 1.5V
PR107 PR113 PR307 PR310 = R_0402: room: 1P5V
PR202 = R_1206: room: P_1.2V
PR203 = R0603_0OHM: room: P_1.2V
PR204 PR206 PR209 PR212 PR517 = R_0402: room: P_1.2V
PR303 PR923 PR924 = R_1206: room: ETY-ROOM
PR405 PR409 PR502 = R_0603: room: 1.8V
PR413-PR420 PR424 PR918 PR925 PR930 PR931 PR940 PR1203 = R_0402: room: CHARGER
PR421 RC1-RC7 RC10-RC12 RC14-RC17 RC19-RC23 RC25 RC27 RC44-RC48 RC51 RC52 RC54 RC56 RC57 RC59 RC60 RC65 RC67-RC69 RC71-RC75 RC77-RC84 RC86-RC96 RC109 RC110 RC112-RC115 RC120 RC130 RC140 RC141 RC152 RC153 RC157 RC161 RC163 RC165-RC168 RC175-RC178 RC183 RC184 RC186 RC187 RC189 RC190 RC215 RC220 RC222-RC225 RC227 RC234 RC237 RC243 RC267 RC268 RC272 RC278 RC279 RC282 RC283 RC287 RC288 RC291 RC292 RC297 RC298 RC311 RC313 RC317-RC319 RC323 RC324 RC330 RC331 RC338 RC344-RC349 RC362 RC363 RC366-RC370 RC387 RC402-RC405 RC411 RE95 RE349 RL70 RV7 = R_0402: room: CPU
PR501 PR505 PR506 = R_0402: room: 1.8V
PR606 PR664 PR687 PR951 PR960 PR1257 RC294 RC422 RC439 RC441 RC444 RC445 RC550 RE536 RE548 RE552 RI81 RT380 RV323 RZ89 RZ112 RZ365 RZ368 = R0402_0OHM
PR619 PR624 PR660 PR661 PR672 PR674 = R_0603: room: CPU_CORE
PR627 PR663 PR676 = R_1206: room: CPU_CORE
PR665 PR667 PR688 PR691 RI79 RT397 RZ370 = R_0603
PR669 = R_1206
PR680 PR909 PR910 PR937 PR938 RA3 RC171 = R_0603: room: ETY-ROOM
PR682-PR684 = SOLDER_PREFORMS_0603
PR901 PR917 = R_1206_4P-D: room: CHARGER
PR914 PR915 PR921 PR943 = R_0603: room: CHARGER
PR916 = R_0805: room: CHARGER
PR929 = R0402_0OHM: room: CHARGER
PR939 PR941 PR942 PR946 = R0402_0OHM: room: PWR_CHARGER
PR1241 PR1242 PR1244 PR1245 = R0402_0OHM: room: P_USBB
PRP1 = RP_0804_8P4R: room: ETY-ROOM
PT1 T141-T144 T147 T258 T262 T264 T268 T281-T283 = TPC12
PU1 PU1200 = TC7SH08FU_SSOP5: room: PCH
PU2 = AP2204R-5P0TRG1_SOT89-3: room: ETY-ROOM
PU100 = SY8288BRAC_QFN20_3X3: room: ETY-ROOM
PU102 = SY8288CRAC_QFN20_3X3: room: ETY-ROOM
PU200 = SY8210AQVC_QFN19_4X3: room: P_1.2V
PU301 = SY8288RAC_QFN20_3X3: room: ETY-ROOM
PU401 PU402 = SY8057QDC_QFN16_3X3: room: ETY-ROOM
PU501 = RT8097ALGE_SOT23-6: room: ETY-ROOM
PU503 = AP7361C-FGE-7_U-DFN3030-8_3X3: room: ETY-ROOM
PU602 = ISL62883CHRTZ-T_TQFN40_5X5-S: room: GPU_CORE
PU610 PU612 PU613 = NCP302045MNTWG_PQFN33_5X5
PU614 = ISL95808HRZ-TS2378_DFN8_2X2-S
PU901 = ISL88738HRTZ-T_TQFN32_4X4: room: ETY-ROOM
PU903 = TC7SH08FU_SSOP5: room: ETY-ROOM
PU1201 = LM393DGKR_VSSOP8: room: ETY-ROOM
QC2 = DMN65D8LDW-7_SOT363-6: room: CPU
QC6 QE17 QN6 QN7 QZ4 QZ8 QZ15 = L2N7002WT1G_SC-70-3
QC7 QE15 = LP2301ALT1G_SOT23-3
QE3-QE7 = MMST3904-7-F_SOT323-3: room: KBC
QE11 QE12 = L2N7002WT1G_SC-70-3: room: ETY-ROOM
QL1 QL2 = DMN65D8LDW-7_SOT363-6: room: LAN
QN1 = DMN65D8LDW-7_SOT363-6: room: HDD
QN4 QN5 = DMN66D0LDW-7_SOT363-6: room: CODEC
QR1 = L2N7002WT1G_SC-70-3: room: RTS5242
QT1 = DMN66D0LDW-7_SOT363-6: room: PD
QV1 = AO6405_TSOP6: room: LCD
QV2 = L2N7002WT1G_SC-70-3: room: LCD
QV3 = DMN65D8LDW-7_SOT363-6: room: HDMI
QV4 QV5 = L2N7002WT1G_SC-70-3: room: HDMI
QV7 = L2N7002WT1G_SC-70-3: room: TOUCH
QV8 = LP2301ALT1G_SOT23-3: room: TOUCH
QZ1 = LP2301ALT1G_SOT23-3: room: CAMERA
QZ2 = DMN65D8LDW-7_SOT363-6
QZ3 = DDTA144VCA-7-F_SOT23-3
QZ7 = DMN65D8LDW-7_SOT363-6: room: LED
RA5-RA9 RA12-RA14 RA17 RA18 RA44 RA45 RA51 RA52 = R_0402: room: CODEC
RA48 RA54 RE90 = R0402_0OHM: room: UZ8
RA50 RA53 RA57 RA58 = R_0402: room: UZ8
RC28-RC32 RC39 RC42 RC43 RC316 RC407-RC410 RE350 = R_0402: room: SPI ROM
RC33-RC36 RC38 RC40 RC41 = R0402_0OHM: room: SPI ROM
RC62 RC212 RC221 RC244 RC290 RC295 RC296 RC325 RC373 RC374 RC376-RC378 = R0402_0OHM: room: CPU
RC121-RC124 RC126 RC128 RC129 RC131-RC139 RC217-RC219 RC239-RC241 = R_0402: room: CPU XDP
RC143 = R0603_0OHM: room: CPU
RC216 = R0603_0OHM: room: CPU XDP
RC371 RC372 RC400 RC401 RE31 RE33 RE37 RE43 RE48 RE51 RE55-RE58 RE60 RE63-RE65 RE67-RE75 RE77 RE86 RE280 RE292 RE301-RE304 RE306 RE308 RE312-RE314 RE340 RE342 RE343 RE375 = R_0402: room: KBC
RD4 RD6 RD8 RD11 RD14-RD20 RD23 RD24 RD27-RD31 = R_0402: room: MEMORY
RD5 RD7 RD9 RD12 RD21 RD22 RD25 = R0402_0OHM: room: MEMORY
RD10 RD26 = R0603_0OHM: room: MEMORY
RE5 RE8 RE10-RE12 RE20 RE21 RE25 RE26 RE35 RE38 RE83-RE85 RE91 RE92 RE94 RE274 RE288 RE324 RE365 = R_0402: room: SIO
RE30 RE59 = R0402_0OHM: room: KBC
RE93 = R_0201: room: SIO
RI13 RI14 RI34-RI45 RI51-RI58 = R_0402: room: JUSB1
RI27-RI30 RI47-RI50 = R_0402-NPM: room: ETY-ROOM
RI80 RT398 = R0603_0OHM
RL1 RL2 RL4-RL6 RL9 RL11-RL20 RL29 RL30 = R_0402: room: LAN
RL3 RL7 RL34 = R0402_0OHM: room: LAN
RL8 = R0603_0OHM: room: LAN
RL71-RL78 = R_0603: room: LAN
RN1-RN5 = R_0402: room: HDD
RN25-RN28 RN30 RN31 RN37-RN44 RN49-RN65 RN69-RN74 = R_0402: room: SATA EXPRESS
RN77 RN78 RN81 RN82 = R0402_0OHM: room: SATA EXPRESS
RPC1 = RP_0804_8P4R: room: SPI ROM
RPC3 RPC4 = RP_0804_8P4R: room: CPU
RPE7 RPE10 RPE12 = RP_0804_8P4R: room: KBC
RPE9 RPE11 = RP_0804_8P4R: room: SIO
RR3 RR4 RR19 = R_0402: room: RTS5242
RR5 = R0402_0OHM: room: RTS5242
RT50-RT53 RT64-RT69 RT71 RT75 RT76 RT81 RT82 RT84-RT88 RT90 RT95-RT98 RT100 RT101 RT103 RT106-RT111 = R_0402: room: PD
RT54-RT60 RT63 RT70 RT72 RT73 RT83 RT89 RT92 RT93 RT99 RT104 RT105 = R0402_0OHM: room: PD
RT74 RT120-RT123 = R0402_0OHM: room: TBT
RT130-RT133 RT135-RT145 RT246-RT248 RT300-RT308 = R_0402: room: PS8740
RT339 = R_0402: room: TBT
RV1-RV5 = R_0402: room: LCD
RV6 RV8 = R_0402: room: TOUCH
RV10-RV35 = R_0402: room: HDMI
RV70 RV72 RV73 RV75 RV76 RV78-RV97 = R_0402: room: PS8348
RV102 RV106 RV107 RV116-RV124 = R_0402: room: CRT
RZ8-RZ10 RZ114 = R_0402: room: USH
RZ18-RZ21 RZ116 RZ117 = R_0402: room: KBTP
RZ25 RZ28 RZ32 = R_0402: room: LED
RZ26 RZ29 = R0402_0OHM: room: KBTP
RZ38 RZ71 = R_0402: room: UZ2
RZ40 = R_0402: room: UZ4
RZ56 = R0402_0OHM: room: WLAN
RZ58 RZ59 RZ63 RZ69 = R_0402: room: TPM
RZ61 = R0402_0OHM: room: TPM
RZ65 = R_0402: room: UZ3
RZ76 RZ77 RZ326 = R_0402: room: WWAN
RZ78-RZ81 = R_0402: room: WLAN
RZ119 = R_0402: room: +VCC_SFR_OC
RZ120 = R0402_0OHM: room: +VCC_SFR_OC
RZ128-RZ130 = R_0201
RZ151 = R_0603: room: +1.0V_VCCSTG
RZ320 = R_0402: room: +1.0V_VCCSTG
SW1 = SW_SS3-CMFTQR9_3P: room: CPU
SW3 = SW_SKRBAAE010_4P: room: LED
T1-T6 T9-T19 T113-T115 T120 T122 T123 T126-T130 T132 = TPC12: room: CPU
T50 T51 T54 T55 T225 = TPC12: room: MEMORY
T87 = TPC12: room: CRT
T88 T89 = TPC12: room: LAN
T204 T223 T224 = TPC12: room: PS8348
T219 T220 = TPC12: room: PD
TL1 = TAIMA_IH-160_24P: room: LAN
UA1 = ALC3246-CG_MQFN48_6X6-S: room: ETY-ROOM
UC1 = KBL-RU42_BGA_1356P-T: room: CPU
UC5 UC6 = W25Q128FVSIQ_SO8: room: SPI ROM
UC7 UE3 UE5 = TC7SH08FU_SSOP5: room: CPU
UC8 = 74CBTLV3126BQ_DHVQFN14_2P5X3-S: room: CPU XDP
UC12 = 74AHC1G09GW_TSSOP5: room: CPU
UD1 = 74AUP1G07GW_TSSOP5: room: MEMORY
UE1 = MEC5105_WFBGA_169P: room: ETY-ROOM
UE4 UE6 = 74AUP1G07GW_TSSOP5: room: ETY-ROOM
UI1 = SY6288D20AAC_SOT23-5: room: JUSB2
UI2 = SY6288D20AAC_SOT23-5: room: JUSB3
UI3 = SLGC55544CVTR_TQFN16_3X3: room: JUSB1
UI5 = PS8713BTQFN24GTR2_TQFN24_4X4-S: room: JUSB1
UL1 = WGI217LM-QPN9-A2_QFN48_6X6-S: room: LAN
UL2 = TC7SH08FU_SSOP5: room: LAN
UN4 UN5 = PS8558BTQFN24_TQFN24_4X4-S: room: SATA EXPRESS
UN7 = PI3EQX6741STZDEX_TQFN20_4X4-S
UR1 = RTS5242-GR_QFN32_4X4-S: room: RTS5242
UT5 = TPS65982_BGA_96P: room: PD
UT6 = W25Q80DVSSIG_SO8: room: PD
UT7 = AP2112K-3P3TRG1_SOT23-5: room: PD
UT8 = AP2204R-5P0TRG1_SOT89-3: room: PD
UT9 = TUSB546_QFN40_4X6: room: ETY-ROOM
UV2 = AP2330W-7_SC59-3: room: HDMI
UV4 = AP2330W-7_SC59-3: room: CRT
UV6 = RTD2166-CG_QFN32_4X4-S: room: CRT
UV7 = PS8338BQFN60GTR-A0_QFN60_5X9-S: room: PS8348
UV24 = G524B1T11U_SOT23-5: room: LCD
UZ2 = TPS22966DPUR_SON14_2X3-S: room: UZ2
UZ3 = TPS22966DPUR_SON14_2X3-S: room: UZ3
UZ4 = TPS22966DPUR_SON14_2X3-S: room: UZ4
UZ5 = TPS22966DPUR_SON14_2X3-S: room: CODEC
UZ6 = TC7SH08FU_SSOP5: room: RSMRST
UZ8 = AOZ1336_DFN8_2X2-S: room: UZ8
UZ10 = TC7SH08FU_SSOP5: room: LED
UZ12 = NPCT650JB2YX_QFN32_5X5: room: ETY-ROOM
UZ19 = TPS22961DNYR_WSON8: room: +1.0V_VCCSTG
UZ21 = TPS22961DNYR_WSON8: room: +1.0V_VCCST
UZ23 = AOZ1336_DFN8_2X2-S: room: HDD
UZ26 = TPS22961DNYR_WSON8: room: +VCC_SFR_OC
UZ34 = TC7SH08FU_SSOP5: room: +VCC_SFR_OC
UZ35 = TC7SH08FU_SSOP5: room: +1.0V_VCCSTG
UZ36 = PS8558BTQFN24_TQFN24_4X4-S
YC1 = Y_X3G024000DC1H_4P: room: CPU
YC2 = Y_9H03200042_2P: room: CPU
YC3 = Y_X3G024000DC1H_4P
YE1 = Y_X1A000141000200_2P: room: ETY-ROOM
YL1 = Y_7V25000034_4P: room: LAN

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
3A_Z120_0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
9A_Z80_1812_2P-NPM
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74CBTLV3126BQ_DHVQFN14_2P5X3-S
  oval 1.041x0.254 smd: 1(0,0) 7(2.95,0) 8(2.95,0.5) 14(0,0.5)
  oval 0.254x1.041 smd: 2(0.475,-0.975) 3(0.975,-0.975) 4(1.475,-0.975) 5(1.975,-0.975) 6(2.475,-0.975) 9(2.475,1.475) 10(1.975,1.475) 11(1.475,1.475) 12(0.975,1.475) 13(0.475,1.475)
  rect 1.499x0.991 smd: 15(1.475,0.25)
ACES_50208-0060N-P01_6P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,-1.95) 8(5.3,-1.95)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50278-00401-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50506-02041-P01_20P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 0.991x2.007 smd: 21(-2.1,-3.05) 22(11.6,-3.05)
ACES_59003-02006-002_20P
  oval 0.254x1.397 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.295x1.397 smd: 21(10.55,0.125) 22(10.55,4.125) 23(-1.05,4.125) 24(-1.05,0.125)
ALC3246-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AO6405_TSOP6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
AOE6930_DFN5X6E8-10
  rect 0.61x0.61 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.5) 6(2.54,5.5) 7(1.27,5.5)
  rect 0.61x1.676 smd: 8(0,4.96)
  rect 4.191x1.041 smd: 9(1.905,1.215)
  custom 0.617x0.617 smd: 10(1.905,3.465)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ1336_DFN8_2X2-S
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2112K-3P3TRG1_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.375) 5(0,2.375)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AP7361C-FGE-7_U-DFN3030-8_3X3
  oval 0.457x0.94 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.05) 6(1.3,3.05) 7(0.65,3.05) 8(0,3.05)
  rect 2.261x1.499 smd: 9(0.975,1.525)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BZV55-B5V1_SOD80C2
  rect 0.889x1.6 smd: 1(0,0) 2(3.3,0)
C-K_26210B-8K1A-02_9P
  round 1.118 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.549x3.353 hole 0.787x2.591: 10(4.35,-2.43) 11(-11.35,-2.43)
  oval 1.549x2.464 hole 0.787x1.702: 12(-11.35,-9.23) 13(4.35,-9.23)
C-K_26230A-8K1A-02_9P-T
  round 1.194 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x2.388 hole 0.711x1.803: 10(2.9,-0.4) 11(4.2,-8.95) 12(-9.9,-0.4) 13(-11.2,-8.95)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_A
  rect 1.626x1.829 smd: 1(0.389,0) 2(2.989,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_B2-NPM
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CCM_C070546HR015M29CZR_15P-T
  round 0.965 hole 0.711: 1(0,0) 2(-2.29,0) 3(-4.58,0) 4(-6.87,0) 5(-9.16,0) 6(1.145,0) 7(-1.145,0) 8(-3.435,0) 9(-5.725,0) 10(-8.015,0) 11(0,-1.4) 12(-2.29,-1.4) 13(-4.58,-1.4) 14(-6.87,-1.4) 15(-9.16,-1.4)
  oval 1.092x2.896 hole 0.787x2.591: 16(-14.63,0.1) 17(5.47,0.1)
CLIP_SH1506X616
  custom 3.922x3.922 smd: 1(0,0)
CONCR_099BKAC19YBLCNF_19P
  round 0.813 hole 0.508: 1(0,0) 2(0.5,1.5) 3(1,0) 4(1.5,1.5) 5(2,0) 6(2.5,1.5) 7(3,0) 8(3.5,1.5) 9(4,0) 10(4.5,1.5) 11(5,0) 12(5.5,1.5) 13(6,0) 14(6.5,1.5) 15(7,0) 16(7.5,1.5) 17(8,0) 18(8.5,1.5) 19(9,0)
  oval 1.397x3.15 hole 0.787x2.54: 20(-2.75,0.9) 21(11.75,0.9)
  oval 1.803x2.794 hole 0.787x1.803: 22(-4.75,-6.08) 23(13.75,-6.08)
CONCR_213AAAA42FA_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
CONCR_213BAAA42FA_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
CVILU_CF5006FD0R0-05-NH_6P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.991x2.007 smd: 7(-2.1,-3.15) 8(4.6,-3.15)
CVILU_CF5020FD0RK-05-NH_20P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.651x1.397 smd: 21(-2.325,-3.375) 22(11.825,-3.375)
CVILU_CF5026FD0RK-05-NH_26P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 1.651x1.397 smd: 27(14.825,-3.375) 28(-2.325,-3.375)
CVILU_CI0805M1HRC-NH_5P-T
  round 1.803 hole 1.803 unplated: (-0.2,5.2) (8.2,5.2)
  oval 0.889x2.388 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0)
  rect 1.6x2.489 smd: 6(11.15,9.05) 7(-3.15,9.05)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB103T-2R2MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
DB3J315E0L_SMINI3-F2-B3
  oval 0.889x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DDTA144VCA-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DEREN_40-42251-01001RHF_10P-T
  oval 0.838x2.21 smd: 1(0,0.1) 2(1.5,0.1) 3(3,0.1) 4(4.5,0.1) 5(6,0.1) 6(7.5,0.1) 7(9,0.1) 8(10.5,0.1) 9(12,0.1) 10(13.5,0.1)
  custom 0.75x0.75 smd: 11(-3.4,-3.15) 12(16.9,-3.15)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
ESD8011MUT5G_X3DFN2-2-S
  rect 0.33x0.356 smd: 1(0,0) 2(0.43,0)
FDMC6679AZ_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H_0P7N
  round 0.711 hole 0.711 unplated: (0,0)
H_0P9N
  round 0.889 hole 0.889 unplated: (0,0)
H_1P1N
  round 1.092 hole 1.092 unplated: (0,0)
H_2P2-G
  round 2.718 hole 2.21: 1(0,0)
H_2P3-G
  round 2.819 hole 2.311: 1(0,0)
H_2P5-G
  round 2.997 hole 2.489: 1(0,0)
H_2P6X3P6-G
  oval 3.099x4.115 hole 2.591x3.607: 1(0,0)
H_3P0-G
  round 3.505 hole 2.997: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_4P0-G
  round 4.496 hole 3.988: 1(0,0)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL62883CHRTZ-T_TQFN40_5X5-S
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
ISL88738HRTZ-T_TQFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
ISL95808HRZ-TS2378_DFN8_2X2-S
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.889 smd: 9(0.75,1.1)
JAE_DX07BD24JJ2_24P-T
  oval 1.194x2.311 hole 0.61x1.905: 1(-1.695,-0.7) 2(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 3(-1.37,-1.3) 4(6.62,-1.3)
  custom 0.325x0.325 hole 0.711x1.499: 5(-3.225,-6) 6(8.475,-6)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-006GAAM_6P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.305x1.143 smd: 7(-0.885,-2.965) 8(3.385,-2.965)
JXT_FP241AH-010GAAM_10P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.65) 12(5.5,-2.65)
KBL-RU42_BGA_1356P-T
  round 0.356 smd: A3(-0.965,0) A70(-40.166,0) B2(-0.483,0.483) B71(-40.629,0.462) BA1(0,22.166) BA71(-40.629,22.166) BB2(-0.462,22.628) BB70(-40.166,22.628) C1(0,0.965)
  round 0.33 smd: A4(-1.615,0) A69(-39.516,0) AY1(0,21.516) AY71(-40.629,21.516) B3(-1.118,0.635) B70(-39.999,0.63) BA2(-0.629,21.999) BA70(-39.999,21.999) BB3(-1.113,22.628) BB69(-39.516,22.628) C2(-0.635,1.118) C71(-40.629,1.113) D1(0,1.615)
  round 0.305 smd: A5(-2.266,0) A68(-38.866,0) AA2(-0.975,10.804) AA4(-1.951,10.804) AA63(-35.427,10.719) AA64(-36.077,10.719) AA65(-36.727,10.719) AA66(-37.377,10.719) AA67(-38.028,10.719) AA68(-38.678,10.719) AA69(-39.328,10.719) AA70(-39.978,10.719) AA71(-40.629,10.719) AB4(-1.951,11.467) AB6(-2.729,11.181) AB7(-3.379,11.181) AB8(-4.029,11.181) AB9(-4.679,11.181) AB10(-5.33,11.181) AB11(-5.98,11.181) AB12(-6.63,11.181) AB13(-7.28,11.181) AB15(-8.126,11.305) AB16(-8.776,11.305) AB17(-9.426,11.305) AB18(-10.077,11.305) AB19(-10.727,11.305) AB20(-11.377,11.305) AB21(-12.027,11.305) AB62(-34.958,11.176) AC3(-1.626,12.13) AC63(-35.427,11.633) AC64(-36.077,11.633) AC65(-36.727,11.633) AC66(-37.377,11.633) AC67(-38.028,11.633) AC68(-38.678,11.633) AC69(-39.328,11.633) AC70(-39.978,11.633) AC71(-40.629,11.633) AD4(-1.951,12.792) AD6(-2.729,12.248) AD7(-3.379,12.248) AD8(-4.029,12.248) AD9(-4.679,12.248) AD10(-5.33,12.248) AD11(-5.98,12.248) AD12(-6.63,12.248) AD13(-7.28,12.248) AD15(-8.126,12.143) AD16(-8.776,12.143) AD17(-9.426,12.143) AD18(-10.077,12.143) AD19(-10.727,12.143) AD20(-11.377,12.143) AD21(-12.027,12.143) AD62(-34.958,12.09) AE62(-34.958,13.005) AE63(-35.427,12.547) AE64(-36.077,12.547) AE65(-36.727,12.547) AE66(-37.377,12.547) AE67(-38.028,12.547) AE68(-38.678,12.547) AE69(-39.328,12.547) AF2(-0.975,13.455) AF4(-1.951,13.455) AF6(-2.729,13.315) AF7(-3.379,13.315) AF8(-4.029,13.315) AF9(-4.679,13.315) AF10(-5.33,13.315) AF11(-5.98,13.315) AF12(-6.63,13.315) AF13(-7.28,13.315) AF15(-8.126,12.982) AF16(-8.776,12.982) AF17(-9.426,12.982) AF18(-10.077,12.982) AF19(-10.727,12.982) AF20(-11.377,12.982) AF21(-12.027,12.982) AF63(-35.427,13.462) AF64(-36.077,13.462) AF65(-36.727,13.462) AF66(-37.377,13.462) AF67(-38.028,13.462) AF68(-38.678,13.253) AF69(-39.328,13.253) AG4(-1.951,14.118) AG15(-8.126,13.82) AG16(-8.776,13.82) AG17(-9.426,13.82) AG18(-10.077,13.82) AG19(-10.727,13.82) AG20(-11.377,13.82) AG21(-12.027,13.82) AG62(-34.958,13.919) AG69(-39.003,13.916) AH3(-1.626,14.781) AH6(-2.729,14.381) AH7(-3.379,14.381) AH8(-4.029,14.381) AH9(-4.679,14.381) AH10(-5.33,14.381) AH11(-5.98,14.381) AH12(-6.63,14.381) AH13(-7.28,14.381) AH63(-35.427,14.376) AH64(-36.077,14.376) AH65(-36.727,14.376) AH66(-37.377,14.376) AH67(-38.028,14.376) AJ4(-1.951,15.444) AJ15(-8.126,14.658) AJ16(-8.776,14.658) AJ17(-9.426,14.658) AJ18(-10.077,14.658) AJ19(-10.727,14.658) AJ20(-11.377,14.658) AJ21(-12.027,14.658) AJ62(-34.958,14.833) AK6(-2.729,15.321) AK7(-3.379,15.321) AK8(-4.029,15.321) AK9(-4.679,15.321) AK10(-5.33,15.321) AK11(-5.98,15.321) AK12(-6.63,15.321) AK13(-7.28,15.321) AK15(-8.126,15.496) AK16(-8.776,15.496) AK17(-9.426,15.496) AK18(-10.077,15.496) AK19(-10.727,15.496) AK20(-11.377,15.496) AK21(-12.027,15.496) AK22(-12.719,15.323) AK23(-13.633,15.323) AK25(-14.547,15.323) AK27(-15.462,15.323) AK28(-16.376,15.323) AK30(-17.291,15.323) AK32(-18.205,15.323) AK33(-19.119,15.323) AK35(-20.034,15.323) AK37(-20.948,15.323) AK38(-21.863,15.323) AK40(-22.777,15.323) AK42(-23.691,15.323) AK43(-24.606,15.323) AK45(-25.52,15.323) AK46(-26.435,15.323) AK48(-27.349,15.323) AK50(-28.263,15.323) AK52(-29.178,15.323) AK53(-30.092,15.323) AK55(-31.007,15.323) AK56(-31.921,15.323) AK58(-32.835,15.323) AK60(-33.75,15.323) AK62(-34.774,15.458) AK63(-35.427,15.291) AK64(-36.077,15.291) AK65(-36.727,15.291) AK66(-37.377,15.291) AK67(-38.028,15.291) AK68(-38.678,15.143) AK69(-39.653,15.143) AL2(-0.975,16.107) AL4(-1.951,16.107) AL23(-13.176,15.788) AL25(-14.09,15.788) AL27(-15.005,15.788) AL28(-15.919,15.788) AL30(-16.833,15.788) AL32(-17.748,15.788) AL33(-18.662,15.788) AL35(-19.577,15.788) AL37(-20.491,15.788) AL38(-21.405,15.788) AL40(-22.32,15.788) AL42(-23.234,15.788) AL43(-24.149,15.788) AL45(-25.063,15.788) AL46(-25.977,15.788) AL48(-26.892,15.788) AL50(-27.806,15.788) AL52(-28.721,15.788) AL53(-29.635,15.788) AL55(-30.549,15.788) AL56(-31.464,15.788) AL58(-32.378,15.788) AL60(-33.293,15.788) AL61(-34.207,15.788) AL63(-35.427,16.159) AL64(-36.077,16.159) AL65(-36.727,16.159) AL66(-37.377,16.159) AM4(-1.951,16.77) AM5(-2.66,16.261) AM7(-3.575,16.261) AM8(-4.489,16.261) AM10(-5.403,16.261) AM11(-6.318,16.261) AM13(-7.232,16.261) AM15(-8.147,16.261) AM16(-9.061,16.261) AM18(-9.975,16.261) AM20(-10.89,16.261) AM21(-11.804,16.261) AM22(-12.719,16.261) AM23(-13.633,16.261) AM25(-14.547,16.261) AM27(-15.462,16.261) AM28(-16.376,16.261) AM30(-17.291,16.261) AM32(-18.205,16.261) AM33(-19.119,16.261) AM35(-20.034,16.261) AM37(-20.948,16.261) AM38(-21.863,16.261) AM40(-22.777,16.261) AM42(-23.691,16.261) AM43(-24.606,16.261) AM45(-25.52,16.261) AM46(-26.435,16.261) AM48(-27.349,16.261) AM50(-28.263,16.261) AM52(-29.178,16.261) AM53(-30.092,16.261) AM55(-31.007,16.261) AM56(-31.921,16.261) AM58(-32.835,16.261) AM60(-33.75,16.261) AM61(-34.664,16.261) AM68(-38.353,16.37) AM69(-39.003,16.37) AN3(-1.626,17.433) AN5(-2.66,16.911) AN7(-3.575,16.911) AN8(-4.489,16.911) AN10(-5.403,16.911) AN11(-6.318,16.911) AN13(-7.232,16.911) AN15(-8.147,16.911) AN16(-9.061,16.911) AN18(-9.975,16.911) AN20(-10.89,16.911) AN21(-11.804,16.911) AN22(-12.719,16.911) AN23(-13.633,16.911) AN25(-14.547,16.911) AN27(-15.462,16.911) AN28(-16.376,16.911) AN30(-17.291,16.911) AN32(-18.205,16.911) AN33(-19.119,16.911) AN35(-20.034,16.911) AN37(-20.948,16.911) AN38(-21.863,16.911) AN40(-22.777,16.911) AN42(-23.691,16.911) AN43(-24.606,16.911) AN45(-25.52,16.911) AN46(-26.435,16.911) AN48(-27.349,16.911) AN50(-28.263,16.911) AN52(-29.178,16.911) AN53(-30.092,16.911) AN55(-31.007,16.911) AN56(-31.921,16.911) AN58(-32.835,16.911) AN60(-33.75,16.911) AN61(-34.664,16.911) AN63(-35.579,16.911) AN65(-36.493,16.911) AN66(-37.407,16.911) AN68(-38.678,17.033) AN69(-39.328,17.033) AP4(-1.951,18.096) AP5(-2.66,17.561) AP7(-3.575,17.561) AP8(-4.489,17.561) AP10(-5.403,17.561) AP11(-6.318,17.561) AP13(-7.232,17.561) AP15(-8.147,17.561) AP16(-9.061,17.561) AP18(-9.975,17.561) AP20(-10.89,17.561) AP21(-11.804,17.561) AP22(-12.719,17.561) AP23(-13.633,17.561) AP25(-14.547,17.561) AP27(-15.462,17.561) AP28(-16.376,17.561) AP30(-17.291,17.561) AP32(-18.205,17.561) AP33(-19.119,17.561) AP35(-20.034,17.561) AP37(-20.948,17.561) AP38(-21.863,17.561) AP40(-22.777,17.561) AP42(-23.691,17.561) AP43(-24.606,17.561) AP45(-25.52,17.561) AP46(-26.435,17.561) AP48(-27.349,17.561) AP50(-28.263,17.561) AP52(-29.178,17.561) AP53(-30.092,17.561) AP55(-31.007,17.561) AP56(-31.921,17.561) AP58(-32.835,17.561) AP60(-33.75,17.561) AP61(-34.664,17.561) AP63(-35.579,17.561) AP65(-36.493,17.561) AP66(-37.407,17.561) AP68(-38.353,17.646) AP70(-39.572,17.646) AR5(-2.66,18.211) AR7(-3.575,18.211) AR8(-4.489,18.211) AR10(-5.403,18.211) AR11(-6.318,18.211) AR13(-7.232,18.211) AR15(-8.147,18.211) AR16(-9.061,18.211) AR18(-9.975,18.211) AR20(-10.89,18.211) AR21(-11.804,18.211) AR22(-12.719,18.211) AR23(-13.633,18.211) AR25(-14.547,18.211) AR27(-15.462,18.211) AR28(-16.376,18.211) AR30(-17.291,18.211) AR32(-18.205,18.211) AR33(-19.119,18.211) AR35(-20.034,18.211) AR37(-20.948,18.211) AR38(-21.863,18.211) AR40(-22.777,18.211) AR42(-23.691,18.211) AR43(-24.606,18.211) AR45(-25.52,18.211) AR46(-26.435,18.211) AR48(-27.349,18.211) AR50(-28.263,18.211) AR52(-29.178,18.211) AR53(-30.092,18.211) AR55(-31.007,18.211) AR56(-31.921,18.211) AR58(-32.835,18.211) AR60(-33.75,18.211) AR61(-34.664,18.211) AR63(-35.579,18.211) AR65(-36.493,18.211) AR66(-37.407,18.211) AR68(-38.678,18.26) AR69(-39.328,18.26) AT2(-0.975,18.759) AT4(-1.951,18.759) AT5(-2.66,18.862) AT7(-3.575,18.862) AT8(-4.489,18.862) AT10(-5.403,18.862) AT11(-6.318,18.862) AT13(-7.232,18.862) AT15(-8.147,18.862) AT16(-9.061,18.862) AT18(-9.975,18.862) AT20(-10.89,18.862) AT21(-11.804,18.862) AT22(-12.719,18.862) AT23(-13.633,18.862) AT25(-14.547,18.862) AT27(-15.462,18.862) AT28(-16.376,18.862) AT30(-17.291,18.862) AT32(-18.205,18.862) AT33(-19.119,18.862) AT35(-20.034,18.862) AT37(-20.948,18.862) AT38(-21.863,18.862) AT40(-22.777,18.862) AT42(-23.691,18.862) AT43(-24.606,18.862) AT45(-25.52,18.862) AT46(-26.435,18.862) AT48(-27.349,18.862) AT50(-28.263,18.862) AT52(-29.178,18.862) AT53(-30.092,18.862) AT55(-31.007,18.862) AT56(-31.921,18.862) AT58(-32.835,18.862) AT60(-33.75,18.862) AT61(-34.664,18.862) AT63(-35.579,18.862) AT65(-36.493,18.862) AT66(-37.407,18.862) AT68(-38.353,18.823) AT69(-39.003,18.823) AU4(-1.951,19.422) AU5(-2.66,19.512) AU7(-3.575,19.512) AU8(-4.489,19.512) AU10(-5.403,19.512) AU11(-6.318,19.512) AU13(-7.232,19.512) AU15(-8.147,19.512) AU16(-9.061,19.512) AU18(-9.975,19.512) AU20(-10.89,19.512) AU21(-11.804,19.512) AU22(-12.719,19.512) AU23(-13.633,19.512) AU25(-14.547,19.512) AU27(-15.462,19.512) AU28(-16.376,19.512) AU30(-17.291,19.512) AU32(-18.205,19.512) AU33(-19.119,19.512) AU35(-20.034,19.512) AU37(-20.948,19.512) AU38(-21.863,19.512) AU40(-22.777,19.512) AU42(-23.691,19.512) AU43(-24.606,19.512) AU45(-25.52,19.512) AU46(-26.435,19.512) AU48(-27.349,19.512) AU50(-28.263,19.512) AU52(-29.178,19.512) AU53(-30.092,19.512) AU55(-31.007,19.512) AU56(-31.921,19.512) AU58(-32.835,19.512) AU60(-33.75,19.512) AU61(-34.664,19.512) AU63(-35.579,19.512) AU65(-36.493,19.512) AU66(-37.407,19.512) AV3(-1.626,20.113) AV68(-38.343,20.026) AV69(-39.328,20.215) AV70(-39.978,20.215) AW1(0,20.866) AW5(-2.534,20.226) AW6(-3.184,20.353) AW7(-3.75,20.678) AW8(-4.328,20.353) AW9(-4.898,20.678) AW10(-5.561,20.353) AW11(-6.171,20.678) AW12(-6.749,20.353) AW13(-7.319,20.678) AW14(-7.982,20.353) AW15(-8.592,20.678) AW16(-9.17,20.353) AW17(-9.74,20.678) AW18(-10.403,20.353) AW20(-11.012,20.678) AW21(-11.59,20.353) AW22(-12.16,20.678) AW23(-12.849,20.353) AW25(-13.486,20.678) AW26(-14.05,20.353) AW27(-14.713,20.678) AW28(-15.326,20.353) AW29(-15.94,20.678) AW30(-16.603,20.353) AW31(-17.167,20.678) AW32(-17.83,20.353) AW33(-18.467,20.678) AW34(-19.031,20.353) AW35(-19.694,20.678) AW36(-20.307,20.353) AW37(-20.921,20.678) AW38(-21.584,20.353) AW39(-22.148,20.678) AW41(-22.785,20.353) AW42(-23.423,20.678) AW43(-23.986,20.353) AW44(-24.649,20.678) AW45(-25.263,20.353) AW46(-25.876,20.678) AW47(-26.477,20.353) AW48(-27.041,20.678) AW49(-27.669,20.353) AW50(-28.298,20.678) AW51(-28.862,20.353) AW52(-29.463,20.678) AW53(-30.076,20.353) AW54(-30.69,20.678) AW55(-31.352,20.353) AW56(-31.916,20.678) AW57(-32.554,20.353) AW59(-33.191,20.678) AW60(-33.755,20.353) AW61(-34.418,20.678) AW62(-35.032,20.353) AW63(-35.645,20.678) AW64(-36.308,20.353) AW65(-36.872,20.678) AW66(-37.407,20.215) AW67(-38.332,20.685) AW68(-38.936,20.936) AW69(-39.581,20.85) AW70(-39.999,21.349) AW71(-40.629,20.866) AY2(-0.629,21.348) AY3(-1.286,21.342) AY4(-2.04,21.357) AY5(-2.649,21.003) AY8(-4.328,21.003) AY12(-6.749,21.003) AY16(-9.17,21.003) AY21(-11.59,21.003) AY26(-14.05,21.003) AY27(-14.713,21.328) AY29(-15.94,21.328) AY30(-16.603,21.003) AY34(-19.031,21.003) AY35(-19.694,21.328) AY37(-20.921,21.328) AY38(-21.584,21.003) AY43(-23.986,21.003) AY44(-24.649,21.328) AY46(-25.876,21.328) AY47(-26.477,21.003) AY51(-28.862,21.003) AY52(-29.463,21.328) AY54(-30.69,21.328) AY55(-31.352,21.003) AY60(-33.755,21.003) AY61(-34.418,21.328) AY63(-35.645,21.328) AY64(-36.308,21.003) AY66(-37.535,21.003) AY68(-38.85,21.581) B5(-2.266,0.65) B6(-2.847,0.975) B10(-5.325,0.975) B14(-7.803,0.975) B18(-10.281,0.975) B22(-12.759,0.975) B26(-15.237,0.975) B30(-17.715,0.975) B34(-20.194,0.975) B39(-22.672,0.975) B44(-25.15,0.975) B48(-27.628,0.975) B53(-30.106,0.975) B58(-32.584,0.975) B62(-35.062,0.975) B66(-37.54,0.975) B69(-39.349,0.63) BA3(-1.279,21.999) BA5(-2.599,21.94) BA8(-4.328,21.653) BA12(-6.749,21.653) BA16(-9.17,21.653) BA21(-11.59,21.653) BA23(-12.849,21.572) BA28(-15.326,21.572) BA32(-17.83,21.572) BA36(-20.307,21.572) BA41(-22.785,21.572) BA45(-25.263,21.572) BA49(-27.669,21.653) BA53(-30.076,21.572) BA57(-32.554,21.572) BA62(-35.032,21.572) BA68(-39.349,21.999) BB4(-1.763,22.628) BB68(-38.866,22.628) C4(-1.699,0.978) C5(-2.266,1.3) C7(-3.523,1.3) C8(-4.086,0.975) C9(-4.65,1.3) C11(-6.001,1.3) C12(-6.564,0.975) C13(-7.128,1.3) C15(-8.479,1.3) C16(-9.042,0.975) C17(-9.606,1.3) C19(-10.957,1.3) C20(-11.52,0.975) C21(-12.084,1.3) C23(-13.435,1.3) C24(-13.998,0.975) C25(-14.562,1.3) C27(-15.913,1.3) C28(-16.476,0.975) C29(-17.04,1.3) C31(-18.391,1.3) C32(-18.954,0.975) C33(-19.518,1.3) C36(-20.869,1.3) C37(-21.433,0.975) C38(-21.996,1.3) C40(-23.347,1.3) C41(-23.911,0.975) C42(-24.474,1.3) C45(-25.825,1.3) C46(-26.389,0.975) C47(-26.952,1.3) C50(-28.303,1.3) C51(-28.867,0.975) C52(-29.43,1.3) C54(-30.781,1.3) C55(-31.345,0.975) C56(-31.908,1.3) C59(-33.259,1.3) C60(-33.823,0.975) C61(-34.386,1.3) C63(-35.737,1.3) C64(-36.301,0.975) C65(-36.864,1.3) C67(-38.799,1.015) C68(-38.936,1.693) C70(-39.999,1.28) D3(-0.975,1.706) D4(-1.624,1.646) D5(-2.224,1.951) D6(-2.873,1.991) D7(-3.523,1.951) D8(-4.086,1.626) D9(-4.65,1.951) D10(-5.325,1.991) D11(-6.001,1.951) D12(-6.564,1.626) D13(-7.128,1.951) D14(-7.803,1.991) D15(-8.479,1.951) D16(-9.042,1.626) D17(-9.606,1.951) D18(-10.281,1.991) D19(-10.957,1.951) D20(-11.52,1.626) D21(-12.084,1.951) D22(-12.759,1.991) D23(-13.435,1.951) D24(-13.998,1.626) D25(-14.562,1.951) D26(-15.237,1.991) D27(-15.913,1.951) D28(-16.476,1.626) D29(-17.04,1.951) D30(-17.715,1.991) D31(-18.391,1.951) D32(-18.954,1.626) D33(-19.518,1.951) D34(-20.194,1.991) D36(-20.869,1.951) D37(-21.433,1.626) D38(-21.996,1.951) D39(-22.672,1.991) D40(-23.347,1.951) D41(-23.911,1.626) D42(-24.474,1.951) D44(-25.15,1.991) D45(-25.825,1.951) D46(-26.389,1.626) D47(-26.952,1.951) D48(-27.628,1.991) D50(-28.303,1.951) D51(-28.867,1.626) D52(-29.43,1.951) D53(-30.106,1.991) D54(-30.781,1.951) D55(-31.345,1.626) D56(-31.908,1.951) D58(-32.584,1.991) D59(-33.259,1.951) D60(-33.823,1.626) D61(-34.386,1.951) D62(-35.062,1.991) D63(-35.737,1.951) D64(-36.301,1.626) D65(-36.864,1.951) D66(-37.54,1.991) D67(-38.213,1.3) D68(-39.582,1.779) D69(-38.876,2.343) D71(-40.629,1.763) E1(0,2.274) E2(-0.65,2.274) E3(-1.3,2.274) E5(-2.66,2.723) E6(-3.575,2.723) E8(-4.489,2.723) E10(-5.403,2.723) E11(-6.318,2.723) E13(-7.232,2.723) E15(-8.147,2.723) E16(-9.061,2.723) E18(-9.975,2.723) E20(-10.89,2.723) E21(-11.804,2.723) E22(-12.719,2.723) E23(-13.633,2.723) E25(-14.547,2.723) E27(-15.462,2.723) E28(-16.376,2.723) E30(-17.291,2.723) E32(-18.205,2.723) E33(-19.119,2.723) E35(-20.034,2.723) E37(-20.948,2.723) E38(-21.863,2.723) E40(-22.777,2.723) E42(-23.691,2.723) E43(-24.606,2.723) E45(-25.52,2.723) E46(-26.435,2.723) E48(-27.349,2.723) E50(-28.263,2.723) E52(-29.178,2.723) E53(-30.092,2.723) E55(-31.007,2.723) E56(-31.921,2.723) E58(-32.835,2.723) E60(-33.75,2.723) E61(-34.664,2.723) E63(-35.629,2.659) E65(-36.645,2.659) E66(-37.661,2.659) E68(-38.213,1.951) F2(-0.975,2.848) F4(-1.951,2.848) F5(-2.66,3.373) F6(-3.575,3.373) F8(-4.489,3.373) F10(-5.403,3.373) F11(-6.318,3.373) F13(-7.232,3.373) F15(-8.147,3.373) F16(-9.061,3.373) F18(-9.975,3.373) F20(-10.89,3.373) F21(-11.804,3.373) F22(-12.719,3.373) F23(-13.633,3.373) F25(-14.547,3.373) F27(-15.462,3.373) F28(-16.376,3.373) F30(-17.291,3.373) F32(-18.205,3.373) F33(-19.119,3.373) F35(-20.034,3.373) F37(-20.948,3.373) F38(-21.863,3.373) F40(-22.777,3.373) F42(-23.691,3.373) F43(-24.606,3.373) F45(-25.52,3.373) F46(-26.435,3.373) F48(-27.349,3.373) F50(-28.263,3.373) F52(-29.178,3.373) F53(-30.092,3.373) F55(-31.007,3.373) F56(-31.921,3.373) F58(-32.835,3.373) F60(-33.75,3.373) F61(-34.664,3.373) F63(-35.629,3.31) F65(-36.645,3.31) F66(-37.661,3.31) F68(-38.876,2.994) G4(-1.951,3.511) G5(-2.66,4.023) G6(-3.575,4.023) G8(-4.489,4.023) G10(-5.403,4.023) G11(-6.318,4.023) G13(-7.232,4.023) G15(-8.147,4.023) G16(-9.061,4.023) G18(-9.975,4.023) G20(-10.89,4.023) G21(-11.804,4.023) G22(-12.719,4.023) G23(-13.633,4.023) G25(-14.547,4.023) G27(-15.462,4.023) G28(-16.376,4.023) G30(-17.291,4.023) G32(-18.205,4.023) G33(-19.119,4.023) G35(-20.034,4.023) G37(-20.948,4.023) G38(-21.863,4.023) G40(-22.777,4.023) G42(-23.691,4.023) G43(-24.606,4.023) G45(-25.52,4.023) G46(-26.435,4.023) G48(-27.349,4.023) G50(-28.263,4.023) G52(-29.178,4.023) G53(-30.092,4.023) G55(-31.007,4.023) G56(-31.921,4.023) G58(-32.835,4.023) G60(-33.75,4.023) G61(-34.664,4.023) G63(-35.629,3.96) G65(-36.645,3.96) G66(-37.661,3.96) G68(-38.678,3.655) G69(-39.328,3.655) H3(-1.626,4.174) H5(-2.66,4.674) H6(-3.575,4.674) H8(-4.489,4.674) H10(-5.403,4.674) H11(-6.318,4.674) H13(-7.232,4.674) H15(-8.147,4.674) H16(-9.061,4.674) H18(-9.975,4.674) H20(-10.89,4.674) H21(-11.804,4.674) H63(-35.629,4.61) H65(-36.645,4.61) H66(-37.661,4.61) H69(-39.003,4.218) J4(-1.951,4.837) J5(-2.66,5.324) J6(-3.575,5.324) J8(-4.489,5.324) J10(-5.403,5.324) J11(-6.318,5.324) J13(-7.232,5.324) J22(-13.176,4.488) J23(-14.09,4.488) J25(-15.005,4.488) J27(-15.919,4.488) J28(-16.833,4.488) J30(-17.748,4.488) J32(-18.662,4.488) J33(-19.577,4.488) J35(-20.491,4.488) J37(-21.405,4.488) J38(-22.32,4.488) J40(-23.234,4.488) J42(-24.149,4.488) J43(-25.063,4.488) J45(-25.977,4.488) J46(-26.892,4.488) J48(-27.806,4.488) J50(-28.721,4.488) J52(-29.635,4.488) J53(-30.549,4.488) J55(-31.464,4.488) J56(-32.378,4.488) J58(-33.293,4.488) J60(-34.207,4.488) J68(-38.676,4.794) K15(-8.126,5.438) K16(-8.776,5.438) K17(-9.426,5.438) K18(-10.077,5.438) K19(-10.727,5.438) K20(-11.377,5.438) K21(-12.027,5.438) K22(-12.719,4.952) K23(-13.633,4.952) K25(-14.547,4.952) K27(-15.462,4.952) K28(-16.376,4.952) K30(-17.291,4.952) K32(-18.205,4.952) K33(-19.119,4.952) K35(-20.034,4.952) K37(-20.948,4.952) K38(-21.863,4.952) K40(-22.777,4.952) K42(-23.691,4.952) K43(-24.606,4.952) K45(-25.52,4.952) K46(-26.435,4.952) K48(-27.349,4.952) K50(-28.263,4.952) K52(-29.178,4.952) K53(-30.092,4.952) K55(-31.007,4.952) K56(-31.921,4.952) K58(-32.835,4.952) K60(-33.75,4.952) K61(-34.664,4.952) K63(-35.447,5.26) K64(-36.097,5.26) K65(-36.747,5.26) K66(-37.398,5.26) K67(-38.048,5.26) K68(-38.666,5.468) K70(-39.653,5.57) L2(-0.975,5.5) L4(-1.951,5.5) L6(-2.729,5.974) L7(-3.379,5.974) L8(-4.029,5.974) L9(-4.679,5.974) L10(-5.33,5.974) L11(-5.98,5.974) L12(-6.63,5.974) L13(-7.28,5.974) L15(-8.126,6.276) L16(-8.776,6.276) L17(-9.426,6.276) L18(-10.077,6.276) L19(-10.727,6.276) L20(-11.377,6.276) L21(-12.027,6.276) L62(-34.958,5.689) L63(-35.427,6.147) L64(-36.077,6.147) L65(-36.727,6.147) L66(-37.377,6.147) L67(-38.028,6.147) L68(-38.678,6.147) L69(-39.328,6.147) L70(-39.978,6.147) L71(-40.629,6.147) M4(-1.951,6.163) M62(-34.958,6.604) N3(-1.626,6.826) N6(-2.729,6.914) N7(-3.379,6.914) N8(-4.029,6.914) N9(-4.679,6.914) N10(-5.33,6.914) N11(-5.98,6.914) N12(-6.63,6.914) N13(-7.28,6.914) N15(-8.126,7.114) N16(-8.776,7.114) N17(-9.426,7.114) N18(-10.077,7.114) N19(-10.727,7.114) N20(-11.377,7.114) N21(-12.027,7.114) N63(-35.427,7.061) N64(-36.077,7.061) N65(-36.727,7.061) N66(-37.377,7.061) N67(-38.028,7.061) N68(-38.678,7.061) N69(-39.328,7.061) N70(-39.978,7.061) N71(-40.629,7.061) P4(-1.951,7.489) P15(-8.126,7.952) P16(-8.776,7.952) P17(-9.426,7.952) P18(-10.077,7.952) P19(-10.727,7.952) P20(-11.377,7.952) P21(-12.027,7.952) P62(-34.958,7.518) R6(-2.729,7.981) R7(-3.379,7.981) R8(-4.029,7.981) R9(-4.679,7.981) R10(-5.33,7.981) R11(-5.98,7.981) R12(-6.63,7.981) R13(-7.28,7.981) R63(-35.427,7.975) R64(-36.077,7.975) R65(-36.727,7.975) R66(-37.377,7.975) R67(-38.028,7.975) R68(-38.678,7.975) R69(-39.328,7.975) R70(-39.978,7.975) R71(-40.629,7.975) T2(-0.975,8.152) T4(-1.951,8.152) T15(-8.126,8.791) T16(-8.776,8.791) T17(-9.426,8.791) T18(-10.077,8.791) T19(-10.727,8.791) T20(-11.377,8.791) T21(-12.027,8.791) T62(-34.958,8.433) U4(-1.951,8.815) U6(-2.729,9.047) U7(-3.379,9.047) U8(-4.029,9.047) U9(-4.679,9.047) U10(-5.33,9.047) U11(-5.98,9.047) U12(-6.63,9.047) U13(-7.28,9.047) U63(-35.427,8.89) U64(-36.077,8.89) U65(-36.727,8.89) U66(-37.377,8.89) U67(-38.028,8.89) U68(-38.678,8.89) U69(-39.328,8.89) U70(-39.978,8.89) U71(-40.629,8.89) V3(-1.626,9.478) V15(-8.126,9.629) V16(-8.776,9.629) V17(-9.426,9.629) V18(-10.077,9.629) V19(-10.727,9.629) V20(-11.377,9.629) V21(-12.027,9.629) V62(-34.958,9.347) W4(-1.951,10.141) W6(-2.729,10.114) W7(-3.379,10.114) W8(-4.029,10.114) W9(-4.679,10.114) W10(-5.33,10.114) W11(-5.98,10.114) W12(-6.63,10.114) W13(-7.28,10.114) W63(-35.427,9.804) W64(-36.077,9.804) W65(-36.727,9.804) W66(-37.377,9.804) W67(-38.028,9.804) W68(-38.678,9.804) W69(-39.328,9.804) W70(-39.978,9.804) W71(-40.629,9.804) Y15(-8.126,10.467) Y16(-8.776,10.467) Y17(-9.426,10.467) Y18(-10.077,10.467) Y19(-10.727,10.467) Y20(-11.377,10.467) Y21(-12.027,10.467) Y62(-34.958,10.261)
  oval 0.254x0.343 smd: A6(-2.847,0.325) A7(-3.523,0) A9(-4.65,0) A10(-5.325,0.325) A11(-6.001,0) A13(-7.128,0) A14(-7.803,0.325) A15(-8.479,0) A17(-9.606,0) A18(-10.281,0.325) A19(-10.957,0) A21(-12.084,0) A22(-12.759,0.325) A23(-13.435,0) A25(-14.562,0) A26(-15.237,0.325) A27(-15.913,0) A29(-17.04,0) A30(-17.715,0.325) A31(-18.391,0) A33(-19.518,0) A34(-20.194,0.325) A36(-20.869,0) A38(-21.996,0) A39(-22.672,0.325) A40(-23.347,0) A42(-24.474,0) A44(-25.15,0.325) A45(-25.825,0) A47(-26.952,0) A48(-27.628,0.325) A50(-28.303,0) A52(-29.43,0) A53(-30.106,0.325) A54(-30.781,0) A56(-31.908,0) A58(-32.584,0.325) A59(-33.259,0) A61(-34.386,0) A62(-35.062,0.325) A63(-35.737,0) A65(-36.864,0) A66(-37.54,0.325) A67(-38.215,0) AY7(-3.763,21.328) AY9(-4.898,21.328) AY11(-6.184,21.328) AY13(-7.319,21.328) AY15(-8.604,21.328) AY17(-9.74,21.328) AY20(-11.025,21.328) AY22(-12.16,21.328) AY25(-13.486,21.328) AY31(-17.167,21.328) AY33(-18.467,21.328) AY39(-22.148,21.328) AY42(-23.423,21.328) AY48(-27.103,21.328) AY50(-28.236,21.328) AY56(-31.916,21.328) AY59(-33.191,21.328) AY65(-36.872,21.328) AY67(-38.216,21.328) B7(-3.523,0.65) B9(-4.65,0.65) B11(-6.001,0.65) B13(-7.128,0.65) B15(-8.479,0.65) B17(-9.606,0.65) B19(-10.957,0.65) B21(-12.084,0.65) B23(-13.435,0.65) B25(-14.562,0.65) B27(-15.913,0.65) B29(-17.04,0.65) B31(-18.391,0.65) B33(-19.518,0.65) B36(-20.869,0.65) B38(-21.996,0.65) B40(-23.347,0.65) B42(-24.474,0.65) B45(-25.825,0.65) B47(-26.952,0.65) B50(-28.303,0.65) B52(-29.43,0.65) B54(-30.781,0.65) B56(-31.908,0.65) B59(-33.259,0.65) B61(-34.386,0.65) B63(-35.737,0.65) B65(-36.864,0.65) B67(-38.215,0.65) BA4(-1.948,22.004) BA6(-3.141,21.572) BA7(-3.705,21.978) BA9(-4.898,21.978) BA10(-5.561,21.572) BA11(-6.125,21.978) BA13(-7.319,21.978) BA14(-7.982,21.572) BA15(-8.546,21.978) BA17(-9.74,21.978) BA18(-10.403,21.572) BA20(-10.966,21.978) BA22(-12.16,21.978) BA25(-13.486,21.978) BA26(-14.149,21.653) BA27(-14.812,21.978) BA29(-15.841,21.978) BA30(-16.504,21.653) BA31(-17.167,21.978) BA33(-18.467,21.978) BA34(-19.13,21.653) BA35(-19.793,21.978) BA37(-20.822,21.978) BA38(-21.485,21.653) BA39(-22.148,21.978) BA42(-23.423,21.978) BA43(-24.086,21.653) BA44(-24.748,21.978) BA46(-25.777,21.978) BA47(-26.44,21.653) BA48(-27.103,21.978) BA50(-28.236,21.978) BA51(-28.899,21.653) BA52(-29.562,21.978) BA54(-30.59,21.978) BA55(-31.253,21.653) BA56(-31.916,21.978) BA59(-33.191,21.978) BA60(-33.854,21.653) BA61(-34.517,21.978) BA63(-35.546,21.978) BA64(-36.209,21.653) BA65(-36.872,21.978) BA66(-37.535,21.653) BA67(-38.216,21.978) BB5(-2.529,22.628) BB6(-3.141,22.303) BB7(-3.705,22.628) BB9(-4.898,22.628) BB10(-5.561,22.303) BB11(-6.125,22.628) BB13(-7.319,22.628) BB14(-7.982,22.303) BB15(-8.546,22.628) BB17(-9.74,22.628) BB18(-10.403,22.303) BB20(-10.966,22.628) BB22(-12.16,22.628) BB23(-12.849,22.222) BB25(-13.486,22.628) BB26(-14.149,22.303) BB27(-14.812,22.628) BB29(-15.841,22.628) BB30(-16.504,22.303) BB31(-17.167,22.628) BB32(-17.83,22.222) BB33(-18.467,22.628) BB34(-19.13,22.303) BB35(-19.793,22.628) BB37(-20.822,22.628) BB38(-21.485,22.303) BB39(-22.148,22.628) BB41(-22.785,22.222) BB42(-23.423,22.628) BB43(-24.086,22.303) BB44(-24.748,22.628) BB46(-25.777,22.628) BB47(-26.44,22.303) BB48(-27.103,22.628) BB50(-28.236,22.628) BB51(-28.899,22.303) BB52(-29.562,22.628) BB54(-30.59,22.628) BB55(-31.253,22.303) BB56(-31.916,22.628) BB57(-32.554,22.222) BB59(-33.191,22.628) BB60(-33.854,22.303) BB61(-34.517,22.628) BB63(-35.546,22.628) BB64(-36.209,22.303) BB65(-36.872,22.628) BB66(-37.535,22.303) BB67(-38.216,22.628)
  oval 0.343x0.254 smd: AA1(-0.325,10.804) AB1(0,11.467) AB2(-0.65,11.467) AB3(-1.3,11.467) AC1(-0.325,12.13) AC2(-0.975,12.13) AD1(0,12.792) AD2(-0.65,12.792) AD3(-1.3,12.792) AF1(-0.325,13.455) AF70(-39.978,13.154) AF71(-40.629,13.154) AG1(0,14.118) AG2(-0.65,14.118) AG3(-1.3,14.118) AG70(-39.653,13.817) AG71(-40.303,13.817) AH1(-0.325,14.781) AH2(-0.975,14.781) AH68(-38.678,14.48) AH69(-39.328,14.48) AH70(-39.978,14.48) AH71(-40.629,14.48) AJ1(0,15.444) AJ2(-0.65,15.444) AJ3(-1.3,15.444) AK70(-40.303,15.143) AL1(-0.325,16.107) AL68(-38.678,15.806) AL69(-39.328,15.806) AL70(-39.978,15.806) AL71(-40.629,15.806) AM1(0,16.77) AM2(-0.65,16.77) AM3(-1.3,16.77) AM70(-39.653,16.469) AM71(-40.303,16.469) AN1(-0.325,17.433) AN2(-0.975,17.433) AN70(-39.978,17.132) AN71(-40.629,17.132) AP1(0,18.096) AP2(-0.65,18.096) AP3(-1.3,18.096) AR70(-39.978,18.16) AR71(-40.629,18.16) AT1(-0.325,18.759) AT70(-39.653,18.823) AT71(-40.303,18.823) AU1(0,19.422) AU2(-0.65,19.422) AU3(-1.3,19.422) AU68(-38.678,19.461) AU69(-39.328,19.486) AU70(-39.978,19.486) AU71(-40.629,19.486) AV1(0,20.142) AV2(-0.95,20.113) AV71(-40.629,20.215) AW2(-0.625,20.677) AW3(-1.275,20.677) E70(-39.978,2.305) E71(-40.629,2.413) F1(-0.325,2.848) F70(-39.526,2.994) F71(-40.176,2.931) G1(0,3.511) G2(-0.65,3.511) G3(-1.3,3.511) G70(-39.978,3.555) G71(-40.629,3.555) H1(-0.325,4.174) H2(-0.975,4.174) H70(-39.653,4.218) H71(-40.303,4.218) J1(0,4.837) J2(-0.65,4.837) J3(-1.3,4.837) J69(-39.328,4.881) J70(-39.978,4.881) J71(-40.629,4.881) K71(-40.303,5.57) L1(-0.325,5.5) M1(0,6.163) M2(-0.65,6.163) M3(-1.3,6.163) N1(-0.325,6.826) N2(-0.975,6.826) P1(0,7.489) P2(-0.65,7.489) P3(-1.3,7.489) T1(-0.325,8.152) U1(0,8.815) U2(-0.65,8.815) U3(-1.3,8.815) V1(-0.325,9.478) V2(-0.975,9.478) W1(0,10.141) W2(-0.65,10.141) W3(-1.3,10.141)
