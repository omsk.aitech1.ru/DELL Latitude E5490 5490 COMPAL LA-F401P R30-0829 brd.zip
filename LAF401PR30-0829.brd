# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PLTRST#_EC: length 156.4
  IN4 w0.089: v1(181.3,55.25) 181.76,55.71 189.86,55.71 203.31,42.26 206.49,42.26 213.87,34.88 216.16,34.88 217.37,36.09 237.27,36.09 241.38,31.97 245.97,31.97 254.46,40.46 255.25,40.46 255.71,40.91 255.71,41.27 258.85,44.42 258.85,44.8 261.14,47.09 261.14,47.8 262.13,48.79 262.13,50.56 263.15,51.58 263.15,53.05 263.96,53.87 264.5,53.87 265.73,55.1 268.59,55.1 271.11,57.62 271.11,61.12 268.86,63.36 267.56,63.36 266.86,64.06 266.86,67.29 v1(267.28,67.71)
  BOTTOM w0.102: UE6.2 268.74,72.26 267.21,70.74 v2(267.21,70.25) 267.21,68.67 RE375.2 267.77,67.71 v1(267.28,67.71) ; RC244.2 160.83,53.66 161.37,53.66 162.34,52.7 177.83,52.7 180.38,55.25 v1(181.3,55.25)
PCH_POPIRCOMP: length 9.2
  TOP w0.381: v1(127.99,49.87) 127.99,49.51 131.96,45.53 v2(131.96,44.19) RC89.1
  BOTTOM w0.254: v1(127.99,49.87) 128.4,50.17 UC1.AU16
PCH_PRIM_EN: length 272
  TOP w0.102: UZ34.1 135.89,27.5 137.91,25.47 153.48,25.47 154.03,24.92 v2(161.17,24.92) 167.43,24.92 169.16,23.2 177.15,23.2 v1(177.43,23.47) ; v1(152.94,78.38) 153.65,77.68 153.65,74.15 162.76,65.04 164.76,65.04 173.21,56.59 173.21,48.38 179.28,42.31 179.28,38.42 179.71,37.99 184.35,37.99 185.68,36.66 185.68,33.93 185.36,33.61 RC442.2 RC441.2 184.8,32.29 184.41,31.9 184.41,31.01 v1(184.09,30.69) ; v1(196.05,9.9) 196.05,9.63 197.42,8.26 198.71,8.26 198.93,8.04 198.93,7.98 RZ64.1
  TOP w0.203: PR504.1 v1(119.07,107.64)
  TOP w0.254: v1(126.4,113.1) 126.64,112.87 PR406.1
  IN1 w0.089: v1(126.4,113.1) 127.37,112.14 128.74,112.14 130.01,110.86 136.02,110.86 138.85,113.68 144.79,113.68 145.29,113.18 147.43,113.18 152.53,108.07 152.53,98.77 v1(158.12,93.18) 168.86,93.18 175.7,100.02 184.68,100.02 185.23,99.46 185.23,98.13 v1(185.68,97.68) ; v1(177.43,23.47) 177.38,23.42 177.38,21.96 179.52,19.81 188.48,19.81 190.51,17.79 190.51,17.26 196.2,11.57 196.2,10.06 v1(196.05,9.9)
  IN2 w0.122: v1(152.94,78.38) 154.19,78.38 154.59,78.78 155.5,78.78 156.02,79.3 156.02,81.06 155.12,81.97 155.12,90.18 v1(158.12,93.18)
  IN4 w0.089: v1(126.4,113.1) 124.96,114.55 121.54,114.55 119.85,112.86 119.85,108.43 v1(119.07,107.64)
  BOTTOM w0.102: v1(184.09,30.69) 184.09,29 184.09,28.29 182.84,27.03 182.84,24.9 181.73,23.79 177.75,23.79 v1(177.43,23.47) ; PR312.1 v1(185.68,97.68)
PCH_PWROK: length 77.2
  TOP w0.102: v1(125.81,37.79) 125.16,37.14 RC411.1 124.16,36.42 v3(123.55,35.81)
  IN2 w0.122: v1(125.81,37.79) 125.81,37.4 122.36,33.95 93.95,33.95 87.23,40.67 v1(87.23,41.15)
  BOTTOM w0.076: 128.24,43.23 128.24,43.74 126.87,45.12 126.87,45.69 126.37,46.19 126.37,46.79 126.23,46.93 126.23,47.47 UC1.BA20
  BOTTOM w0.102: PR614.1 75.09,51.28 77.09,51.28 78.57,49.8 78.57,48.63 86.04,41.15 v1(87.23,41.15) ; v1(125.81,37.79) 126.78,37.79 128.24,39.26 128.24,43.23
PCH_RSMRST#: length 228.8
  TOP w0.102: UZ6.1 137.42,27.2 138.44,26.18 146.94,26.18 148.65,27.88 156.16,27.88 157.49,26.56 v2(164.11,26.56) 172.56,26.56 173.35,25.77 v1(178.4,25.77) ; v1(309,73.67) 308.63,74.03 307.94,74.03 RE342.1 307.12,74.85 305.49,74.85 305.34,74.69 304.79,74.69 UE1.M5
  IN1 w0.089: v1(301.82,66.31) 302.27,66.31 302.89,65.69 303.59,65.69 303.96,65.32 305.24,65.32 306.52,66.59 306.52,66.98 306.84,67.3 308.97,67.3 310.11,68.44 310.11,69.9 308.7,71.31 308.7,73.37 v1(309,73.67)
  IN2 w0.122: v1(178.4,25.77) 181.62,25.77 181.82,25.57 183.14,25.57 183.55,25.98 187.19,25.98 188.14,26.93 188.87,26.93 189.18,26.61 193.02,26.61 199.69,19.95 199.99,19.95 201.88,18.05 205.03,18.05 206.13,16.96 209.32,16.96 210.59,18.23 214.94,18.23 215.57,17.59 216.74,17.59 217.76,16.58 222.48,16.58 222.61,16.45 225.79,16.45 232.19,22.85 241.76,22.85 245.32,26.41 256.16,26.41 258.45,28.7 261.37,28.7 263.12,30.45 277.55,30.45 281.46,34.36 281.77,34.36 284.76,37.36 285.28,37.36 288.21,40.29 288.21,41.21 289.3,42.3 289.3,43.44 289.97,44.11 290.25,44.11 295.79,49.65 296.63,49.65 298.14,51.16 298.14,54.59 298.76,55.21 298.76,57.59 299.4,58.23 299.68,58.23 301.78,60.33 303.45,60.33 305.37,62.25 305.37,65.18 303.91,66.63 302.14,66.63 v1(301.82,66.31)
PCH_RSMRST#_AND: length 97.9
  TOP w0.102: RC124.1 68.97,39.77 v1(69.22,40.02) ; UZ6.4 139.07,29.95 139.07,31.04 136.33,33.77 132.49,33.77 v2(131.93,34.33) 131.58,34.69 131.58,37.44 132.34,38.2 132.34,39.26 RC75.1 132.82,39.79 RC215.2 131.33,40.29 129.74,40.29 v1(129.6,40.44)
  IN2 w0.122: v1(69.22,40.02) 69.99,39.25 86.55,39.25 92.84,32.96 123.36,32.96 123.82,33.42 125.99,33.42 128.79,36.22 128.79,39.49 129.6,40.3 v1(129.6,40.44)
  BOTTOM w0.076: 129.17,43.59 129.17,43.69 127.65,45.21 127.65,46.74 127.46,46.93 127.46,47.19 127.51,47.31 127.51,47.45 127.45,47.68 127.45,47.8 127.52,48.01 127.62,48.12 127.72,48.23 UC1.AY17
  BOTTOM w0.102: 129.17,43.59 129.17,40.87 v1(129.6,40.44)
PCH_RTCRST#: length 306.8
  TOP w0.102: v2(315.92,66.95) v1(315.92,66.25) ; v1(289.08,71.43) 288.74,71.77 RE94.2
  IN1 w0.089: v1(315.92,66.25) 315.36,66.25 313.98,64.87 312.29,64.87 v1(311.47,64.05) 311.18,63.76 310.31,63.76 309.28,62.73 309.28,60.67 308.23,59.62 308.23,52.87 304.46,49.09 303.56,49.09 303.27,48.81 303.27,46.97 303.01,46.7 301.7,46.7 300.89,45.9 300.46,45.9 298.39,43.83 298.39,43.13 297.93,42.67 296.53,42.67 293.5,39.64 293.5,38.96 291.35,36.81 289.99,36.81 288.87,35.68 288.87,35.21 283.21,29.55 281.66,29.55 281.32,29.21 259.16,29.21 255.69,25.74 253.81,25.74 251.56,23.48 243.78,23.48 242.43,22.14 233.14,22.14 227.68,16.68 222.97,16.68 222.89,16.76 217.37,16.76 216.57,17.56 215.14,17.56 214.5,16.92 211.02,16.92 210.61,17.33 204.41,17.33 203.53,18.22 201.32,18.22 200.58,18.96 197.62,18.96 195.74,20.84 195.74,23.28 193.58,25.44 188.2,25.44 187.32,24.55 179.85,24.55 179.3,25.11 178.5,25.11 177.75,25.86 170.79,25.86 167.85,28.8 163.92,28.8 160.82,31.89 157.77,31.89 157.64,32.03 153.95,32.03 152.73,33.25 146.09,33.25 145.24,34.1 145.24,34.69 145.05,34.88 144.09,34.88 143.74,35.23 143.74,39.75 141.07,42.42 139.15,42.42 135.69,45.88 131.55,45.88 128.47,48.95 128.47,51.63 128.81,51.97 128.97,51.97 129.34,52.34 129.34,52.61 v1(128.83,53.12)
  IN4 w0.089: v1(128.83,53.12) 129.18,52.77 129.18,51.97 129.52,51.63 129.92,51.63 130.04,51.51 130.83,51.51 131.32,51.02 131.88,51.02 132.14,51.28 132.14,51.86 132.41,52.14 133.63,52.14 133.92,51.84 133.92,50.3 134.11,50.11 134.5,50.11 135.8,51.41 138.18,51.41 138.81,50.78 145.25,50.78 146.16,51.69 151.62,51.69 152.79,52.86 v1(152.79,53.61)
  BOTTOM w0.076: v1(128.83,53.12) 128.83,53.12 128.45,53.45 UC1.AM16
  BOTTOM w0.102: v1(311.47,64.05) 309.59,64.05 307.92,62.38 307.92,62.16 307.05,61.3 305.57,61.3 305.2,61.66 299.29,61.66 299.06,61.89 299.06,62.07 295.15,65.99 295.15,67.04 294.81,67.38 294.81,67.76 293.65,68.92 292.3,68.92 292.13,69.08 290.14,69.08 289.41,69.81 289.41,71.1 v1(289.08,71.43) ; v1(152.79,53.61) 152.37,53.2 CMOS1.1 152.39,52.36 CC81.1 CC80.1 RC57.1 ; JAPS1.9 v1(315.92,66.25)
PCH_RTCX1: length 39.4
  IN4 w0.089: v1(140.88,56.31) 140.85,56.28 140.85,56.06 140.3,55.52 137.97,55.52 136.73,54.27 134.91,54.27 134.69,54.06 134.31,54.06 134.08,54.29 130.09,54.29 129.88,54.08 128.49,54.08 128.35,53.94 128.35,53.54 v1(127.93,53.12)
  BOTTOM w0.076: UC1.AM18 127.56,53.45 v1(127.93,53.12)
  BOTTOM w0.102: YC2.1 RC54.2 151.82,41.57 150.22,41.57 CC23.1 149.61,42.21 149.13,42.69 147.07,42.69 144.4,45.36 v2(144.4,49.01) 144.4,50.12 143.16,51.36 143.16,54.38 141.3,56.24 140.95,56.24 v1(140.88,56.31)
PCH_RTCX2: length 38.2
  IN4 w0.089: v1(127.03,53.12) 127.26,53.35 127.44,53.53 127.44,53.88 127.78,54.21 128.24,54.21 128.29,54.26 129.81,54.26 130.02,54.47 134.15,54.47 134.39,54.23 134.62,54.23 134.83,54.45 136.66,54.45 138.36,56.15 138.36,56.15 138.37,56.14 139.51,56.14 139.53,56.13 139.94,56.13 v1(140.28,56.47)
  BOTTOM w0.076: UC1.AM20 126.66,53.45 v1(127.03,53.12)
  BOTTOM w0.102: RC54.1 RC296.1 150.5,42.18 149.36,43.33 147.33,43.33 145.04,45.62 v2(145.04,51.02) 144.36,51.02 143.77,51.62 143.77,54.85 141.77,56.85 140.61,56.85 140.4,56.64 140.4,56.6 v1(140.28,56.47)
PCH_RTCX2_R: length 4
  BOTTOM w0.102: RC296.2 151.92,43.1 CC26.1 152.83,43.58 YC2.2
PCH_SMB_ALERT#: length 14.6
  TOP w0.102: v1(131.82,61.28) 131.82,61.47 132.25,61.9 v2(135.59,61.9) 139.16,61.9 141.36,64.1 143.06,64.1 143.44,63.72 RC23.1
  BOTTOM w0.076: v1(131.82,61.28) 132.13,61.59 UC1.R10
PCH_SPI_CLK: length 36.4
  TOP w0.102: v1(138.68,49.8) 138.68,50.03 139.41,50.77 143.97,50.77 145.95,52.75 151.7,52.75 154.57,49.88 156.19,49.88 157.36,51.05 161.07,51.05 162.1,50.02 162.1,47.9 162.26,47.75 163.57,47.75 164,48.18 v1(164,48.25)
  BOTTOM w0.076: v1(138.68,49.8) 138.62,49.86 137.22,49.86 136.96,49.6 UC1.AV2
  BOTTOM w0.102: v1(164,48.25) 164,48.71 163.82,48.89 RC35.2 163.59,48.66 163.59,47.98 163.85,47.71 JSPI1.8
PCH_SPI_CLK_0_R: length 13.4
  TOP w0.102: v3(153.12,64.92) 153.01,65.02 v1(152.53,65.02)
  BOTTOM w0.102: RPC1.6 153.67,62.12 152.53,63.26 152.53,63.78 152.02,64.29 RC29.1 152.02,64.51 v1(152.53,65.02) 152.78,65.27 154.27,65.27 154.92,65.92 154.92,67.03 155.04,67.15 155.52,67.15 155.66,67.01 155.66,65.81 154.54,64.69 UC5.6
PCH_SPI_CLK_1_R: length 15.4
  BOTTOM w0.102: RC28.1 151.34,54.94 151.94,55.54 v2(151.94,55.54) 151.94,55.54 152.45,56.05 UC6.6 153.89,56.05 155.53,54.41 155.9,54.41 156.16,54.67 156.16,54.96 155.96,55.16 155.96,55.36 156.53,55.92 156.53,56.12 156.39,56.27 156.19,56.27 155.62,55.7 155.42,55.7 155.17,55.95 155.17,56.96 155.91,57.71 155.91,58.42 157.61,60.12 RC408.2
PCH_SPI_CLK_2_R: length 13
  TOP w0.102: UZ12.19 163.42,38.17 163.25,37.99 162.56,37.99 162.46,38.09 162.46,39.1 162.36,39.2 162.15,39.2 162.05,39.1 162.05,38.09 161.95,37.99 161.75,37.99 161.65,38.09 161.65,39.29 161.54,39.39 161.34,39.39 161.24,39.29 161.24,38.12 161.11,37.99 v2(160.25,37.99) 159.36,37.99 159.26,38.09 159.26,38.33 159.36,38.44 160.28,38.44 160.67,38.83 RZ63.2 RZ60.2
PCH_SPI_CLK_R1: length 37.3
  TOP w0.102: v1(163.85,51.63) 164.44,52.22 v2(164.44,57.32) 164.44,58.23 162.41,60.27 159.34,60.27 v1(157.61,61.99) ; RZ60.1 159.76,40.24 160.05,40.53 v1(160.6,40.53)
  IN2 w0.122: v1(157.61,61.99) 157.27,61.99 156.4,61.12 154.76,61.12 153.67,60.04 v1(153.67,59.65)
  BOTTOM w0.102: v1(160.6,40.53) 160.6,43.82 162.36,45.59 164.01,45.59 164.35,45.93 JSPI1.7 164.35,47.72 164.49,47.86 164.49,49.51 164.2,49.8 RC35.1 163.81,51.59 v1(163.85,51.63) ; RPC1.3 v1(153.67,59.65) ; RC408.1 v1(157.61,61.99)
PCH_SPI_CS#0: length 39.5
  TOP w0.102: v1(162.62,48.25) 162.62,49.18 162.76,49.32 164.43,49.32 164.57,49.46 164.57,49.66 164.43,49.8 162.76,49.8 162.62,49.94 162.62,50.18 160.8,52 157.51,52 155.87,50.36 154.77,50.36 151.55,53.59 148.7,53.59 148.36,53.25 145.76,53.25 144.21,51.7 140.52,51.7 v1(140.01,51.18)
  BOTTOM w0.076: UC1.AU3 136.37,50.29 136.63,50.56 136.92,50.56 137.33,50.72 138.11,50.72 138.97,51.58 139.34,51.58 139.74,51.18 v1(140.01,51.18)
  BOTTOM w0.102: v1(162.62,48.25) 162.62,48.76 RC36.2 162.35,48.9 162.2,48.75 162.2,47.95 162.85,47.3 JSPI1.10
PCH_SPI_CS#0_R1: length 27.3
  TOP w0.102: v1(163.16,51.04) 163.67,50.54 166.93,50.54 167.72,51.33 v2(167.72,59.71) 167.72,60.49 v1(164.31,63.9)
  BOTTOM w0.102: RC37.1 164.37,64.68 164.37,63.96 v1(164.31,63.9) ; v1(163.16,51.04) 162.48,50.36 RC36.1 162.9,49.81 163.09,49.62 163.09,47.73 163.35,47.47 JSPI1.9
PCH_SPI_CS#0_R2: length 3.9
  TOP w0.102: v3(163.12,67.91) 163.76,67.28 v1(163.81,67.28)
  BOTTOM w0.102: v1(163.81,67.28) RC37.2 161.96,67.28 161.91,67.23 UC5.1
PCH_SPI_CS#1: length 39.6
  TOP w0.102: v1(167.47,48.2) 167.47,49.73 167.14,50.06 163.07,50.06 160.9,52.22 157.33,52.22 155.77,50.67 155.1,50.67 154.61,51.15 154.61,51.33 v2(154.4,51.55) 153.91,51.55 151.64,53.81 148.59,53.81 148.25,53.47 145.67,53.47 144.24,52.04 140.03,52.04 v1(139.19,51.2)
  BOTTOM w0.076: UC1.AU2 136.96,50.29 137.1,50.43 137.11,50.44 137.11,50.44 137.36,50.56 138.24,50.56 138.57,50.89 138.88,50.89 v1(139.19,51.2)
  BOTTOM w0.102: JSPI1.2 166.85,47.67 167.03,47.85 167.03,48.63 RC32.2 167.3,48.36 v1(167.47,48.2)
PCH_SPI_CS#1_R1: length 21.4
  TOP w0.102: v1(160.3,62.71) 161.49,62.71 166.41,57.79 v2(166.41,56.98) v1(166.41,51)
  BOTTOM w0.102: RC42.1 160.66,62.35 v1(160.3,62.71) ; JSPI1.1 167.35,47.43 168.01,48.09 168.01,49.06 167.3,49.78 RC32.1 167.3,49.9 166.41,50.79 v1(166.41,51)
PCH_SPI_CS#1_R2: length 5.9
  BOTTOM w0.102: UC6.1 159.22,58.59 159.12,58.69 159.12,59.13 160.44,60.45 RC42.2 161.53,60.45 v2(162.31,61.23)
PCH_SPI_CS#2: length 56.1
  TOP w0.102: RZ61.1 156.63,37.99 156.3,38.32 156.3,40.33 153.65,42.98 146.53,42.98 146.39,43.12 146.39,43.62 146.25,43.76 146.05,43.76 145.91,43.62 145.91,43.12 145.77,42.98 144.77,42.98 144.69,43.06 144.69,43.26 145.64,44.22 145.64,44.42 145.5,44.56 145.3,44.56 143.77,43.03 143.57,43.03 143.43,43.18 143.43,43.38 145.38,45.33 145.38,45.53 145.24,45.67 145.04,45.67 143.08,43.7 142.88,43.7 142.74,43.85 142.74,44.05 144.96,46.27 144.96,46.47 144.82,46.61 144.62,46.61 142.39,44.38 142.19,44.38 142.05,44.52 142.05,44.72 143.6,46.27 143.6,46.47 143.45,46.61 143.25,46.61 142.3,45.65 142.1,45.65 141.6,46.15 v1(141.6,46.2)
  BOTTOM w0.076: 140.36,50.2 140.17,50.4 138.31,50.4 138.2,50.29 UC1.AU1
  BOTTOM w0.102: 140.36,50.2 141.1,49.47 141.1,48.8 141.24,48.66 142.52,48.66 142.66,48.52 v2(142.66,48.43) 142.66,48.32 142.52,48.18 140.57,48.18 140.44,48.04 140.44,47.84 140.59,47.69 142.52,47.69 142.66,47.55 142.66,47.35 142.52,47.21 141.24,47.21 141.1,47.07 141.1,46.7 v1(141.6,46.2)
PCH_SPI_CS#2_R: length 6.3
  TOP w0.102: UZ12.20 163.63,37.67 163.47,37.51 v2(162.41,37.51) 159,37.51 RZ61.2
PCH_SPI_D0: length 40.5
  TOP w0.102: RC10.2 166.18,48.28 v1(166.14,48.24) v2(165.42,47.52) 164.49,46.59 156.21,46.59 151.26,51.54 146.65,51.54 141.79,46.68 139.63,46.68 v1(137.94,48.37)
  BOTTOM w0.076: v1(137.94,48.37) 137.81,48.5 137.22,48.5 136.97,48.75 136.01,48.75 135.84,48.92 UC1.AV3
  BOTTOM w0.102: v1(166.14,48.24) 166.14,48.77 166.27,48.9 RC33.2 166.57,48.61 166.57,48.04 165.85,47.32 JSPI1.4
PCH_SPI_D0_0_R: length 13.4
  TOP w0.102: v3(155.1,63.24) v1(155.73,63.24)
  BOTTOM w0.102: RPC1.7 154.17,61.72 154.78,62.32 154.78,62.52 154.58,62.72 154.58,62.92 154.72,63.06 154.92,63.06 155.12,62.87 155.36,62.87 v1(155.73,63.24) 156.01,63.52 156.32,63.52 157.25,64.45 157.25,66.21 157.11,66.35 156.79,66.35 156.66,66.22 156.66,64.67 155.92,63.93 155.01,63.93 154.5,63.42 UC5.5
PCH_SPI_D0_1_R: length 13.2
  BOTTOM w0.102: RC409.2 156.4,58.22 156.4,57.12 157.79,55.73 157.79,54.77 156.25,53.23 v2(155.15,53.23) 154.22,54.16 154.22,54.63 154.07,54.78 UC6.5
PCH_SPI_D0_2_R: length 13.3
  TOP w0.102: RZ59.2 161.05,36.25 160.95,36.15 159.64,36.15 159.58,36.21 159.58,36.47 159.45,36.59 159.2,36.59 159.05,36.44 159.05,35.92 159.39,35.58 v2(160.43,35.58) 161.19,35.58 161.3,35.48 161.3,34.85 161.4,34.75 161.7,34.75 161.8,34.85 161.8,35.05 161.9,35.15 162.46,35.15 162.57,35.25 162.57,35.46 162.46,35.56 161.9,35.56 161.8,35.66 161.8,36.85 161.98,37.03 163,37.03 163.14,37.17 UZ12.21
PCH_SPI_D0_R1: length 43
  TOP w0.102: v1(159.45,37.1) 159.77,36.78 RZ59.1 ; v1(165.98,51.44) 165.98,52.94 v2(165.97,52.95) 165.97,57.91 162.03,61.85 160.55,61.85 159.89,62.51 159.11,62.51 v1(158.63,62.03)
  IN2 w0.122: v1(158.63,62.03) 157.22,60.62 155.17,60.62 154.34,59.79 v1(154.34,59.66)
  BOTTOM w0.102: RC409.1 v1(158.63,62.03) ; v1(165.98,51.44) 165.72,51.18 165.72,50.38 RC33.1 166.59,49.81 166.8,49.6 166.8,47.94 166.35,47.49 JSPI1.3 166.35,46.22 165,44.87 162.66,44.87 161.31,43.53 161.31,40.3 160.13,39.12 160.13,37.78 v1(159.45,37.1) ; RPC1.2 154.17,59.83 v1(154.34,59.66)
PCH_SPI_D1: length 38.1
  TOP w0.102: v1(138.6,49.07) 138.56,49.03 138.56,48.02 139.51,47.07 141.81,47.07 146.52,51.78 151.34,51.78 156.02,47.1 v2(161.93,47.1) 163.89,47.1 v1(164.98,48.18)
  BOTTOM w0.076: UC1.AW3 136.46,49.31 137.65,49.31 137.89,49.07 v1(138.6,49.07)
  BOTTOM w0.102: v1(164.98,48.18) 164.98,48.77 165.1,48.89 RC34.2 165.46,48.76 165.46,48.03 164.85,47.42 JSPI1.6
PCH_SPI_D1_0_R: length 14.8
  TOP w0.102: v1(159.24,64.63) v3(159.24,66.69)
  BOTTOM w0.102: RPC1.8 155.67,62.53 155.67,62.59 156.23,63.15 157.31,63.15 157.8,62.66 158,62.66 158.14,62.8 158.14,63 157.65,63.49 157.65,63.69 157.8,63.83 157.99,63.83 158.4,63.43 158.61,63.43 158.75,63.57 158.75,63.76 158.34,64.17 158.34,64.37 158.48,64.51 158.68,64.51 159.17,64.02 159.37,64.02 159.51,64.16 159.51,64.36 v1(159.24,64.63) 159.02,64.85 159.02,65.05 159.93,65.96 UC5.2
PCH_SPI_D1_1_R: length 12.7
  BOTTOM w0.102: UC6.2 159.17,57.32 158.65,56.8 158.65,56.49 159.35,55.78 159.35,54.86 159.09,54.6 158.5,54.6 158.34,54.76 158.34,55.87 157.17,57.04 157.17,57.98 RC410.2
PCH_SPI_D1_2_R: length 13.2
  TOP w0.102: RZ58.2 163.21,33.84 163.11,33.74 161.52,33.74 161.42,33.64 161.42,33.44 161.52,33.33 163.11,33.33 163.21,33.23 163.21,32.97 163.11,32.87 161.46,32.87 161.36,32.77 161.36,32.57 161.46,32.47 v2(162.59,32.47) 163.94,32.47 164.04,32.57 164.04,35.45 164.26,35.67 UZ12.24
PCH_SPI_D1_R1: length 45.4
  TOP w0.102: v1(158.82,37.1) 158.82,35.83 160.21,34.44 RZ58.1 ; v1(165.49,51.87) v2(165.49,54.83) 165.49,57.93 162.42,61 160.73,61 v1(159.67,62.06)
  IN2 w0.122: v1(154.94,59.74) 155.24,60.04 157.65,60.04 v1(159.67,62.06)
  BOTTOM w0.102: v1(154.94,59.74) 154.67,60.01 RPC1.1 ; v1(158.82,37.1) 159.22,37.51 159.54,37.51 159.9,37.87 159.9,39.21 161.08,40.39 161.08,43.62 162.56,45.1 164.37,45.1 165.35,46.09 JSPI1.5 165.35,47.59 165.69,47.93 165.69,48.46 165.8,48.56 165.8,49.68 165.68,49.8 RC34.1 165.33,51.71 v1(165.49,51.87) ; RC410.1 159.64,62.03 v1(159.67,62.06)
PCH_SPI_D2: length 33.1
  TOP w0.102: RC11.2 161.46,48.33 v1(161.21,48.08) 160.64,47.52 v2(158.27,47.52) 155.93,47.52 151.41,52.04 146.39,52.04 141.89,47.54 v1(139.91,47.54)
  BOTTOM w0.076: 138.55,48.42 138.15,48.81 137.91,48.81 137.59,49.14 136.94,49.14 UC1.AW2
  BOTTOM w0.102: 138.55,48.42 139.43,47.54 v1(139.91,47.54) ; v1(161.21,48.08) 161.21,48.64 RC38.2 161.52,48.9 161.62,48.8 161.62,47.66 161.85,47.43 JSPI1.12
PCH_SPI_D2_0_R: length 12.7
  BOTTOM w0.102: UC5.3 161.35,64.69 162.44,65.78 162.89,65.78 163.9,64.77 163.9,62.81 v2(164.38,62.34) 165.03,61.69 165.03,61.36 164.8,61.14 164.47,61.14 163.33,62.28 163.33,64.1 RC39.2
PCH_SPI_D2_1_R: length 12.8
  BOTTOM w0.102: RC43.2 v2(165.08,56.2) 167.49,56.2 167.61,56.08 167.61,55.81 167.5,55.7 161.97,55.7 161.62,56.05 UC6.3
PCH_SPI_D2_R1: length 20
  TOP w0.102: v1(163.11,51.67) 163.11,52.4 163.76,53.05 163.76,56.16 v1(163.2,56.72)
  BOTTOM w0.102: JSPI1.11 162.35,47.34 161.92,47.77 161.92,49.68 161.79,49.81 RC38.1 161.46,50.02 v1(163.11,51.67) ; RC39.1 162.69,62.11 163.61,61.19 v2(163.61,59.99) 163.61,59.34 RC30.1 RC43.1 162.81,57.12 v1(163.2,56.72)
PCH_SPI_D3: length 30.8
  TOP w0.102: v1(139.92,49.81) 140.36,50.25 144.13,50.25 146.15,52.26 151.5,52.26 155.72,48.05 v2(156.61,48.05) 159.82,48.05 v1(159.85,48.07)
  BOTTOM w0.076: v1(139.92,49.81) 139.51,50.22 138.36,50.22 138.17,50.03 135.78,50.03 UC1.AU4
  BOTTOM w0.102: v1(159.85,48.07) 159.85,48.13 160.14,48.41 160.14,48.8 160.24,48.9 RC40.2 160.55,48.8 160.55,47.6 160.85,47.3 JSPI1.14
PCH_SPI_D3_0_R: length 12.9
  BOTTOM w0.102: UC5.7 152.55,65.96 152.36,65.77 151.71,65.77 151.52,65.96 150.78,65.96 150.59,65.77 150.59,65.42 150.45,65.28 150.31,65.28 150.17,65.14 v2(150.17,65.02) 150.17,64.94 150.31,64.8 150.45,64.8 150.59,64.66 150.59,63.68 151.36,62.91 152.18,62.91 152.49,62.59 152.49,62.23 152.68,62.04 152.68,61.71 152.36,61.39 152.36,60.21 152.49,60.09 152.69,60.09 152.82,60.21 152.82,60.75 153.17,61.1 RPC1.5
PCH_SPI_D3_1_R: length 12.8
  BOTTOM w0.102: RC407.2 156.33,60.45 156.11,60.67 156.11,61.89 155.99,62.02 v2(155.8,62.02) 155.73,62.02 155.61,61.9 155.61,61.3 155.47,61.16 155.1,61.16 154.96,61.02 154.96,60.82 155.1,60.68 155.47,60.68 155.61,60.53 155.61,60.19 155.72,60.08 156.1,60.08 156.27,59.9 156.27,59.49 155.53,58.74 155.33,58.74 154.8,59.27 154.6,59.27 154.45,59.13 154.45,58.93 155.27,58.11 155.27,57.97 155.03,57.73 154.87,57.73 154.57,58.03 154.26,58.03 153.55,57.32 UC6.7
PCH_SPI_D3_R1: length 30.3
  TOP w0.102: v1(156.56,61.99) 156.6,61.95 RC31.1 ; RC31.1 157.51,61.12 158.84,59.78 162.04,59.78 163.71,58.12 163.71,57.55 163.39,57.23 162.69,57.23 162.23,56.77 162.23,54.02 v2(162.15,53.93) 162.32,53.75 v1(162.32,51.72) ; RC31.1 RC316.1
  IN2 w0.122: v1(153.07,59.7) 153.07,60.14 154.55,61.62 156.19,61.62 v1(156.56,61.99)
  BOTTOM w0.102: RPC1.4 153.17,59.81 v1(153.07,59.7) ; JSPI1.13 161.35,47.3 160.77,47.88 160.77,48.34 160.9,48.47 160.9,49.63 160.73,49.81 RC40.1 160.44,50.25 161.92,51.72 v1(162.32,51.72) ; v1(156.56,61.99) 156.66,61.89 RC407.1
PCH_SPI_DO2_XDP: length 181.7
  TOP w0.102: RC11.1 v2(157.1,49.81) 156.14,48.85 v1(156.14,48.63) ; JXDP1.60 v1(60.95,31.66)
  IN4 w0.089: v1(156.14,48.63) 156.84,48.63 160.15,45.33 164.01,45.33 164.48,44.86 165.52,44.86 169,41.39 169,40.36 173.97,35.39 173.97,32.73 176.97,29.74 176.97,27.92 177.19,27.69 177.19,26.11 177.99,25.32 178.42,25.32 181.85,21.89 181.85,20.14 182.96,19.03 182.96,18.2 v1(183.42,17.75)
  BOTTOM w0.102: v1(60.95,31.66) 63.34,29.27 76.85,29.27 78.72,27.4 122.55,27.4 131.1,18.86 176.31,18.86 177.8,17.37 183.04,17.37 v1(183.42,17.75)
PCH_SPI_DO_XDP: length 169.5
  TOP w0.102: v1(165.23,44.4) 166.83,46 RC10.1 ; RC128.1 RC133.1 60.33,41.93 v1(60.71,42.31)
  IN4 w0.089: v1(181.3,20.72) 181.3,22.13 178.43,25.01 177.97,25.01 176.25,26.72 176.25,27.99 175.05,29.18 175.05,31.24 173.7,32.59 173.7,35.33 166.57,42.47 166.57,43.07 v1(165.23,44.4)
  BOTTOM w0.102: v1(60.71,42.31) 60.69,42.29 v2(60.69,41.75) 60.69,41.25 59.65,40.21 59.65,38.8 63.53,34.92 69.22,34.92 70.76,33.38 82.54,33.38 85.89,30.03 123.77,30.03 132.7,21.1 177.6,21.1 177.91,20.8 180.14,20.8 180.45,21.1 180.92,21.1 v1(181.3,20.72)
PCI_CLK_LPC1: length 17.7
  TOP w0.102: v2(142.96,37.79) 142.65,37.48 v1(142.5,37.48) RC22.1
  IN1 w0.089: v1(135.13,45.06) 135.58,45.06 139.23,41.42 139.32,41.42 139.45,41.29 139.45,40.85 140.4,39.9 140.72,39.9 142.5,38.12 v1(142.5,37.48)
  BOTTOM w0.076: UC1.AY9 132.33,48.16 132.33,47.92 132.3,47.84 132.3,47.63 132.35,47.52 132.35,47.3 132.3,47.19 132.3,46.92 133.01,46.21 133.73,46.21 134.88,45.06 v1(135.13,45.06)
PCIE_PRX_C_DTX_N1: length 2.9
  TOP w0.094: UR1.8 28.12,51.46 28.22,51.36 28.3,51.36 28.49,51.55 30.2,51.55 CR14.2
PCIE_PRX_C_DTX_N4: length 3.1
  TOP w0.094: UL1.39 276.86,82.23 276.74,82.11 276.74,81.45 276.52,81.23 276.04,81.23 275.82,81.02 275.82,80.77 CL2.2
PCIE_PRX_C_DTX_N11: length 23.6
  BOTTOM w0.094: RN82.1 283.94,43.05 284.1,43.05 284.3,42.85 284.3,41.43 285.33,40.4 286.57,40.4 286.83,40.66 288.99,40.66 289.7,39.95 292.33,39.95 292.61,39.68 v4(293.67,39.68) 295.22,39.68 295.8,39.1 295.8,38.5 297.52,36.78 298.27,36.78 298.28,36.79 298.91,36.79 298.92,36.78 299.93,36.78 300.82,35.89 300.82,34.86 300.95,34.72 JNGFF3.29
PCIE_PRX_C_DTX_N12: length 14.4
  BOTTOM w0.094: RN78.1 286.28,38.57 286.37,38.67 286.64,38.67 287.28,38.04 287.28,38.03 287.68,37.62 287.7,37.62 288.3,37.02 293.35,37.02 v4(293.96,36.4) 294.62,35.74 296.33,35.74 296.9,35.17 297.5,35.17 297.62,35.05 297.62,34.83 297.45,34.66 JNGFF3.43
PCIE_PRX_C_DTX_P1: length 2.9
  TOP w0.094: CR13.2 30.04,51.37 28.57,51.37 28.38,51.17 28.2,51.17 28.08,51.06 UR1.7
PCIE_PRX_C_DTX_P4: length 3.1
  TOP w0.094: CL1.2 275.64,80.78 275.64,81.09 275.98,81.44 v4(276.2,81.44) 276.46,81.44 276.55,81.53 276.55,82.09 276.46,82.18 UL1.38
PCIE_PRX_C_DTX_P11: length 23.6
  BOTTOM w0.094: JNGFF3.31 300.45,34.71 300.63,34.89 300.63,35.82 299.85,36.59 v4(298.59,36.59) 297.44,36.59 295.61,38.42 295.61,39.02 295.14,39.49 293.99,39.49 293.96,39.46 293.38,39.46 293.34,39.49 292.54,39.49 292.26,39.77 289.62,39.77 288.92,40.47 286.9,40.47 286.65,40.22 285.25,40.22 284.12,41.35 284.12,42.77 284.03,42.87 283.79,42.87 283.67,42.75 RN81.1
PCIE_PRX_C_DTX_P12: length 14.5
  BOTTOM w0.094: RN77.1 286.55,38.86 286.72,38.86 v4(287.62,37.96) 288.37,37.2 293.42,37.2 293.86,36.76 293.91,36.76 294.32,36.35 294.32,36.3 294.7,35.92 296.4,35.92 296.97,35.36 297.58,35.36 297.81,35.13 297.81,34.84 297.95,34.7 JNGFF3.41
PCIE_PRX_C_RD_DTX_N8: length 1.7
  TOP w0.094: UZ36.4 284.88,63.83 284.72,63.68 284.21,63.68 CZ142.2
PCIE_PRX_C_RD_DTX_N11: length 2.4
  TOP w0.094: UN4.4 260.95,46.76 260.79,46.6 260.58,46.6 260.3,46.33 260.3,46.17 260.19,46.06 259.99,46.06 CN27.2
PCIE_PRX_C_RD_DTX_N12: length 1.7
  TOP w0.094: v1(290.41,53.1) 290.58,53.27 290.58,53.49 290.39,53.68 UN5.4
  BOTTOM w0.094: CN37.2 290.41,52.9 v1(290.41,53.1)
PCIE_PRX_C_RD_DTX_P8: length 1.7
  TOP w0.094: UZ36.5 284.87,63.33 284.71,63.49 284.15,63.49 CZ141.2
PCIE_PRX_C_RD_DTX_P11: length 2.4
  TOP w0.094: UN4.5 261.03,46.26 260.88,46.42 260.65,46.42 260.49,46.25 260.49,46.09 260.27,45.87 259.93,45.87 CN26.2
PCIE_PRX_C_RD_DTX_P12: length 1.7
  TOP w0.094: v1(291,53.1) 290.76,53.34 290.76,53.52 290.89,53.64 UN5.5
  BOTTOM w0.094: CN36.2 290.76,52.63 290.76,52.86 v1(291,53.1)
PCIE_PRX_DTX_N1: length 157
  TOP w0.094: v1(35.88,52.06) 35.46,51.64 31.57,51.64 CR14.1
  IN4 w0.076: v1(129.79,65.3) 129.56,65.52 129.44,65.52 129.24,65.72 129.24,67.12 129.21,67.15 129.21,67.23
  IN4 w0.089: 129.21,67.23 129.21,67.76 128.04,68.94 128.04,73.09 126.77,74.35 126.77,75.08 124.67,77.19 124.67,78.65 121.84,81.47 119.51,81.47 119.04,81.95 119.04,84.25 117.65,85.64 116.77,85.64 114.77,87.63 114.07,87.63 112.35,89.35 112.35,91.65 111.02,92.98 111.02,93.83 110.06,94.79 110.06,99.39 107.96,101.48 97.44,101.48 96.35,100.39 94.97,100.39 93.81,99.24 89.81,99.24 85.85,95.28 85.09,95.28 81.84,92.02 72.71,92.02 71.9,91.21 68.28,91.21 67.45,90.39 65.55,90.39 64.26,89.1 64.26,85.9 55.47,77.12 52.59,77.12 50.94,75.47 46.56,75.47 46.29,75.19 46.29,70.32 43.98,68.01 43.98,65.81 35.21,57.05 35.21,51.55 35.34,51.43 35.43,51.43 35.65,51.65 35.98,51.65 36.07,51.73 36.07,51.87 v1(35.88,52.06)
  BOTTOM w0.094: v1(129.79,65.3) 129.85,65.31 130.22,65.1 UC1.H13
PCIE_PRX_DTX_N3: length 115.1
  IN1 w0.076: 128.49,67.92 128.49,67.91 128.48,67.9 128.48,67.09 128.34,66.95 128.34,66.36 128.48,66.21 128.48,65.77 128.28,65.58 128.03,65.58 127.95,65.5 v1(127.95,65.29)
  IN1 w0.089: v1(186.91,36.33) 187.24,36.33 187.39,36.48 187.39,36.73 187.3,36.82 182.85,36.82 182.3,37.37 176.39,37.37 166.44,47.33 163.97,47.33 163.29,48 163.29,48.55 160.53,51.31 160.53,53.33 159.07,54.79 159.07,62.75 157.31,64.5 157.31,66.84 155.44,68.71 129.02,68.71 128.49,68.17 128.49,67.92
  BOTTOM w0.094: UC1.H16 v1(127.95,65.29) ; v1(186.91,36.33) 187.17,36.07 187.17,33.04 194.01,26.19 194.01,17.27 196.87,14.42 200.31,14.42 200.48,14.25 JNGFF1.43
PCIE_PRX_DTX_N4: length 235.9
  TOP w0.094: v1(278.88,75.26) 278.88,74.91 278.78,74.82 278.6,74.82 278.46,74.96 278.46,75.94 278.03,76.37 277.45,76.37 277.05,76.77 v4(277.05,77.03) 277.05,77.45 277.04,77.47 276.18,78.32 276.18,78.57 275.82,78.94 275.82,79.16 CL2.1
  IN1 w0.089: v1(128.87,65.95) 128.87,66.08 128.98,66.2 129.21,66.2 129.4,66.39 129.4,67.44 129.62,67.66 129.87,67.66 130.33,68.11 149.43,68.11 150.47,67.07 156.27,67.07 156.74,66.6 156.74,64.14 158.03,62.84 158.03,54.83 159.9,52.96 159.9,49.96 163.59,46.27 166.45,46.27 175.93,36.8 181.92,36.8 183.83,34.89 188.99,34.89 189.82,35.72 192.75,35.72 200.95,27.52 207.32,27.52 208.02,28.22 209.99,28.22 210.31,27.9 213.95,27.9 214.43,27.42 220.17,27.42 220.72,26.87 226.78,26.87 229.89,29.98 236.94,29.98 237.96,31.01 247.22,31.01 251.89,35.68 255.36,35.68 263.47,43.78 263.47,44.02 264.56,45.11 265,45.11 265.5,45.61 265.5,46.51 266.44,47.46 270.17,47.46 271.45,46.17 271.45,45.61 272.62,44.45 274.89,44.45 275.35,44.9 280.31,44.9 285.47,50.07 285.47,51.79 285,52.26 285,55.16 285.68,55.85 285.68,57.65 284.82,58.52 284.82,60.42 284.26,60.98 284.26,63.68 282.45,65.49 280.68,65.49 279.98,66.18 279.98,71.93 279.35,72.56 278.99,72.56 278.66,72.89 278.66,73.34 279.64,74.32 279.64,74.82 279.41,75.04 279.1,75.04 v1(278.88,75.26)
  BOTTOM w0.076: UC1.G15 129.32,65.84 129.21,65.95 v1(128.87,65.95)
PCIE_PRX_DTX_N8: length 213.9
  TOP w0.094: v1(282.21,63.91) 282.39,63.72 282.6,63.72 282.88,64.01 CZ142.1
  IN1 w0.076: 126.64,68.29 126.63,68.28 126.62,68.28 126.58,68.25 126.57,68.25 125.75,67.42 125.75,66.32 125.58,66.15 125.38,66.15 v1(125.18,65.95)
  IN1 w0.089: v1(282.21,63.91) 282.21,63.91 283.02,63.91 283.22,63.71 283.22,60.98 284.08,60.11 284.08,58.44 285.04,57.48 285.04,56.02 284.37,55.35 284.37,51.53 282.33,49.49 282.33,48.13 280.47,46.27 275.39,46.27 274.94,46.73 271.84,46.73 270.42,48.15 266,48.15 265.38,47.53 264.37,47.53 264.09,47.25 264.09,45.6 262.77,44.28 262.77,43.96 255.2,36.39 251.79,36.39 247,31.59 237.54,31.59 236.52,30.57 229.61,30.57 226.65,27.61 222.75,27.61 222.04,28.32 215.57,28.32 215.14,28.75 211.24,28.75 210.36,29.63 199.68,29.63 192.21,37.1 187.84,37.1 187.51,37.43 183.32,37.43 182.57,38.18 178.81,38.18 170.31,46.68 170.31,48.38 162.5,56.19 162.5,60.79 161.48,61.81 161.48,65.36 157.56,69.28 140.37,69.28 139.78,69.87 136.97,69.87 136.49,69.38 127.73,69.38 126.64,68.29
  BOTTOM w0.094: UC1.G21 v1(125.18,65.95)
PCIE_PRX_DTX_N11: length 180.4
  TOP w0.094: CN27.1 258.3,46.18 257.97,46.18 257.61,45.82 257.61,45.09 v1(257.43,44.9)
  IN1 w0.076: 120.73,72.72 120.73,72.7 120.73,72.7 120.73,70.14 121.32,69.56 121.32,69.31 121.32,69.3 121.32,69.06 121.01,68.74 121.01,67.56 v1(120.63,67.21)
  IN1 w0.089: v1(257.43,44.9) 257.57,44.76 257.57,44.58 257.2,44.22 256.76,44.22 253.19,40.65 251.6,40.65 248.08,37.12 244.09,37.12 242,35.04 236.05,35.04 234.74,33.72 225.03,33.72 224.59,33.27 220.62,33.27 220.27,33.62 206.38,33.62 205.65,32.89 201.07,32.89 190.12,43.84 181.38,43.84 167.23,57.99 167.23,68.27 160.2,75.3 157.23,75.3 155.63,76.9 152.02,76.9 150.54,78.39 146.1,78.39 145.6,77.89 138.59,77.89 137.88,78.6 127.52,78.6 127.26,78.86 124.82,78.86 120.73,74.77 120.73,72.72
  BOTTOM w0.094: UC1.E28 v1(120.63,67.21)
PCIE_PRX_DTX_N12: length 220.9
  IN1 w0.076: v1(119.7,67.23) 119.7,67.08 119.78,67 119.99,67 120.1,67.1 120.1,67.65 120.21,67.77 120.21,68.78 119.94,69.05 119.94,72.7 119.93,72.7 119.93,72.72
  IN1 w0.089: 119.93,72.72 119.93,75.01 124.44,79.52 127.5,79.52 127.83,79.19 138.23,79.19 138.94,78.48 145.38,78.48 145.86,78.96 150.78,78.96 152.2,77.54 155.91,77.54 156.99,76.46 160.11,76.46 167.84,68.73 167.84,58.29 181.71,44.42 190.35,44.42 201.22,33.55 205.21,33.55 206.33,34.66 214.47,34.66 214.84,34.29 234.27,34.29 235.67,35.69 241.84,35.69 243.85,37.7 247.84,37.7 251.42,41.28 252.94,41.28 258.64,46.98 258.64,48.55 260.47,50.37 262.01,50.37 262.96,51.33 267.39,51.33 269.02,52.95 269.89,52.95 270.58,52.27 271.19,52.27 272.26,51.2 273.12,51.2 273.36,51.45 274.68,51.45 274.75,51.38 277.97,51.38 278.37,50.98 279.52,50.98 279.71,51.18 279.71,51.49 280.19,51.96 280.61,51.96 280.86,51.72 280.99,51.58 281.06,51.58 v1(281.08,51.55)
  BOTTOM w0.076: v1(119.7,67.23) 119.7,67.19 119.98,66.91 120.09,66.91 UC1.E30
  BOTTOM w0.094: v1(281.08,51.55) 280.9,51.55 280.8,51.46 280.8,51.23 280.9,51.14 282.17,51.14 282.18,51.15 282.83,51.15 282.84,51.14 285.72,51.14 286.06,50.8 287.48,50.8 288.11,51.43 289.36,51.43 289.98,50.81 290.29,50.81 290.41,50.94 290.41,51.44 290.28,51.58 CN37.1
PCIE_PRX_DTX_P1: length 157
  TOP w0.094: v1(35.82,51.25) 35.62,51.45 31.9,51.45 CR13.1
  IN4 w0.076: v1(129.78,65.94) 129.82,65.9 129.82,65.75 129.76,65.69 129.51,65.69 129.41,65.79 129.41,67.21 129.39,67.23
  IN4 w0.089: v1(35.82,51.25) 35.26,51.25 35.03,51.48 35.03,57.12 43.79,65.88 43.79,68.09 46.11,70.4 46.11,75.27 46.49,75.65 50.87,75.65 52.52,77.3 55.4,77.3 64.08,85.98 64.08,89.17 65.47,90.57 67.38,90.57 68.2,91.39 71.82,91.39 72.63,92.2 81.76,92.2 85.02,95.46 85.77,95.46 89.73,99.42 93.74,99.42 94.9,100.57 96.27,100.57 97.36,101.66 108.04,101.66 110.24,99.46 110.24,94.87 111.2,93.9 111.2,93.05 112.53,91.72 112.53,89.43 114.14,87.81 114.85,87.81 116.84,85.82 117.73,85.82 119.22,84.33 119.22,82.02 119.59,81.65 121.92,81.65 124.85,78.73 124.85,77.26 126.95,75.15 126.95,74.43 128.22,73.16 128.22,69.01 129.39,67.84 129.39,67.23
  BOTTOM w0.094: UC1.G13 129.81,65.88 129.79,65.94 v1(129.78,65.94)
PCIE_PRX_DTX_P3: length 115.1
  IN1 w0.076: v1(127.92,66) 127.92,65.88 128.06,65.74 128.22,65.74 128.32,65.84 128.32,66.14 128.17,66.29 128.17,67.02 128.32,67.16 128.32,67.9 128.31,67.91 128.31,67.92
  IN1 w0.089: 128.31,67.92 128.31,68.25 128.95,68.89 155.52,68.89 157.49,66.92 157.49,64.58 159.25,62.82 159.25,54.87 160.71,53.4 160.71,51.39 163.47,48.63 163.47,48.08 164.04,47.51 166.51,47.51 176.47,37.55 182.37,37.55 182.92,37 187.38,37 187.57,36.81 187.57,36.5 v1(187.76,36.31)
  BOTTOM w0.094: v1(127.92,66) UC1.G16 ; JNGFF1.41 200.44,14.75 200.29,14.6 196.95,14.6 194.2,17.35 194.2,26.27 187.35,33.11 187.35,36.26 187.46,36.37 187.71,36.37 v1(187.76,36.31)
PCIE_PRX_DTX_P4: length 235.9
  TOP w0.094: v1(278.85,74.42) 278.63,74.63 278.52,74.63 278.24,74.91 v4(278.24,75.51) 278.24,75.9 277.96,76.19 277.37,76.19 276.86,76.7 276.86,77.38 276,78.24 276,78.49 275.63,78.86 275.63,79.15 CL1.1
  IN1 w0.089: v1(128.78,66.63) 128.78,66.57 128.97,66.38 129.13,66.38 129.22,66.46 129.22,67.51 129.55,67.84 129.8,67.84 130.25,68.29 149.51,68.29 150.55,67.25 156.34,67.25 156.92,66.68 156.92,64.21 158.21,62.92 158.21,54.91 160.08,53.04 160.08,50.04 163.66,46.45 166.53,46.45 176,36.98 181.99,36.98 183.9,35.07 188.92,35.07 189.74,35.9 192.83,35.9 201.02,27.7 207.24,27.7 207.94,28.4 210.06,28.4 210.38,28.09 214.03,28.09 214.51,27.6 220.25,27.6 220.8,27.05 226.71,27.05 229.82,30.16 236.86,30.16 237.89,31.19 247.15,31.19 251.82,35.86 255.29,35.86 263.29,43.86 263.29,44.1 264.48,45.29 264.93,45.29 265.32,45.68 265.32,46.59 266.37,47.64 270.24,47.64 271.63,46.24 271.63,45.69 272.69,44.63 274.81,44.63 275.27,45.08 280.24,45.08 285.29,50.14 285.29,51.71 284.82,52.19 284.82,55.24 285.5,55.92 285.5,57.58 284.63,58.44 284.63,60.34 284.08,60.9 284.08,63.61 282.38,65.31 280.6,65.31 279.8,66.11 279.8,71.86 279.28,72.38 278.92,72.38 278.48,72.81 278.48,73.42 279.46,74.39 279.46,74.74 279.34,74.86 278.8,74.86 278.68,74.75 278.68,74.59 v1(278.85,74.42)
  BOTTOM w0.094: UC1.F15 129.14,66.34 128.85,66.63 v1(128.78,66.63)
PCIE_PRX_DTX_P8: length 214
  TOP w0.094: CZ141.1 282.88,63.21 282.56,63.54 282.43,63.54 v1(282.21,63.32)
  IN1 w0.076: 126.51,68.42 125.58,67.49 125.58,66.39 125.51,66.31 125.33,66.31 125.18,66.46 v1(125.18,66.58)
  IN1 w0.089: 126.51,68.42 127.65,69.56 136.41,69.56 136.9,70.05 139.85,70.05 140.44,69.46 157.64,69.46 161.66,65.44 161.66,61.88 162.68,60.86 162.68,56.26 170.49,48.45 170.49,46.75 178.88,38.36 182.64,38.36 183.39,37.61 187.59,37.61 187.91,37.28 192.28,37.28 199.75,29.81 210.43,29.81 211.32,28.93 215.22,28.93 215.64,28.5 222.11,28.5 222.82,27.79 226.58,27.79 229.53,30.75 236.44,30.75 237.47,31.77 246.92,31.77 251.72,36.57 255.12,36.57 262.59,44.04 262.59,44.35 263.91,45.68 263.91,47.33 264.29,47.71 265.31,47.71 265.93,48.33 270.49,48.33 271.91,46.91 275.01,46.91 275.47,46.45 280.39,46.45 282.15,48.2 282.15,49.56 284.19,51.61 284.19,55.43 284.86,56.09 284.86,57.4 283.9,58.36 283.9,60.04 283.03,60.9 283.03,63.64 282.95,63.73 282.73,63.73 282.64,63.64 282.64,63.29 282.51,63.15 282.38,63.15 v1(282.21,63.32)
  BOTTOM w0.094: v1(125.18,66.58) 125.66,66.34 UC1.F21
PCIE_PRX_DTX_P11: length 180.4
  TOP w0.094: v1(258.01,44.9) 257.8,45.12 257.8,45.74 258.05,45.99 258.4,45.99 258.63,45.77 CN26.1
  IN1 w0.076: v1(121.54,67.2) 121.17,67.57 121.17,68.67 121.49,68.99 121.49,69.63 120.9,70.21 120.9,72.7 120.91,72.7 120.91,72.72
  IN1 w0.089: v1(258.01,44.9) 257.75,44.64 257.75,44.51 257.28,44.04 256.84,44.04 253.27,40.47 251.68,40.47 248.15,36.94 244.16,36.94 242.07,34.85 236.13,34.85 234.81,33.54 225.11,33.54 224.66,33.09 220.55,33.09 220.2,33.44 206.45,33.44 205.72,32.71 200.99,32.71 190.04,43.66 181.3,43.66 167.05,57.91 167.05,68.2 160.13,75.12 157.16,75.12 155.56,76.72 151.95,76.72 150.47,78.21 146.17,78.21 145.68,77.71 138.51,77.71 137.81,78.42 127.44,78.42 127.18,78.68 124.9,78.68 120.91,74.69 120.91,72.72
  BOTTOM w0.094: UC1.E27 v1(121.54,67.2)
PCIE_PRX_DTX_P12: length 220.8
  IN1 w0.076: 120.11,72.72 120.11,72.7 120.11,72.7 120.11,69.12 120.38,68.84 120.38,67.7 120.26,67.58 120.26,67.03 120.02,66.79 119.91,66.79 v1(119.74,66.62)
  IN1 w0.089: 120.11,72.72 120.11,74.94 124.52,79.34 127.43,79.34 127.76,79.01 138.16,79.01 138.87,78.3 145.45,78.3 145.93,78.78 150.7,78.78 152.13,77.36 155.84,77.36 156.91,76.28 160.04,76.28 167.66,68.66 167.66,58.22 181.64,44.24 190.27,44.24 201.15,33.37 205.29,33.37 206.4,34.48 214.4,34.48 214.77,34.11 234.35,34.11 235.74,35.51 241.91,35.51 243.92,37.52 247.91,37.52 251.5,41.1 253.02,41.1 258.82,46.91 258.82,48.47 260.54,50.19 262.08,50.19 263.03,51.15 267.47,51.15 269.09,52.77 269.82,52.77 270.5,52.09 271.11,52.09 272.18,51.02 273.19,51.02 273.44,51.27 274.6,51.27 274.67,51.19 277.9,51.19 278.29,50.8 279.59,50.8 279.9,51.1 279.9,51.41 280.26,51.78 280.54,51.78 280.68,51.64 280.68,51.33 280.59,51.24 280.43,51.24 v1(280.37,51.3)
  BOTTOM w0.076: v1(119.74,66.62) 119.89,66.62 UC1.F30
  BOTTOM w0.094: CN36.1 290.6,51.28 290.6,50.86 290.36,50.63 289.9,50.63 289.28,51.24 288.19,51.24 287.56,50.61 285.99,50.61 285.64,50.95 v4(282.5,50.95) 280.81,50.95 280.46,51.3 v1(280.37,51.3)
PCIE_PRX_RD_DTX_N8: length 44.8
  TOP w0.094: UZ36.15 289.7,63.83 289.75,63.78 290.31,63.78 v1(290.41,63.89)
  IN1 w0.089: v1(284.06,44.17) 284.06,44.93 284.41,45.28 285.88,45.28 287.54,46.94 287.54,50.68 289.74,52.87 289.74,53.92 290.57,54.75 290.57,57.51 291.75,58.69 291.75,60.32 289.53,62.54 289.53,63.66 289.76,63.89 v1(290.41,63.89)
  BOTTOM w0.094: v1(284.06,44.17) 284.06,44.76 284.56,45.25 287.66,45.25 288.29,45.87 296.88,45.87 297.5,45.25 297.5,43.58 297.3,43.38 JNGFF2.43
PCIE_PRX_RD_DTX_N11: length 19.4
  TOP w0.094: v1(266.53,46.81) 266.32,46.6 265.89,46.6 265.74,46.76 UN4.15
  IN1 w0.089: v1(266.53,46.81) 266.73,46.61 267.8,46.61 268.1,46.31 270.1,46.31 272.39,44.01 279.28,44.01 279.55,43.74 280.85,43.74 281.61,42.97 281.88,42.97 v1(282.08,43.17)
  BOTTOM w0.094: v1(282.08,43.17) 282.29,42.97 282.4,42.97 RN82.2
PCIE_PRX_RD_DTX_N12: length 27.4
  TOP w0.094: v1(290.32,58.89) 290.53,58.68 290.53,58.5 290.39,58.36 UN5.15
  IN1 w0.089: v1(284.42,38.6) 284.27,38.75 283.8,38.75 283.49,39.06 283.49,39.87 284.38,40.76 284.38,41.22 283.26,42.34 283.26,46.43 286.95,50.12 286.95,52.67 288.12,53.84 288.8,53.84 289.55,54.59 289.55,57.45 290.47,58.38 290.47,58.74 v1(290.32,58.89)
  BOTTOM w0.094: v1(284.42,38.6) 284.69,38.6 284.72,38.62 285.11,38.62 285.36,38.37 RN78.2
PCIE_PRX_RD_DTX_P8: length 44.8
  TOP w0.094: UZ36.14 289.7,63.33 289.77,63.4 289.77,63.5 289.86,63.6 290.12,63.6 v1(290.41,63.3)
  IN1 w0.089: v1(290.41,63.3) 290.01,63.71 289.84,63.71 289.71,63.58 289.71,62.61 291.93,60.39 291.93,58.61 290.75,57.44 290.75,54.67 289.92,53.84 289.92,52.8 287.72,50.6 287.72,46.87 285.95,45.1 284.49,45.1 284.24,44.85 284.24,44.57 v1(284.65,44.17)
  BOTTOM w0.094: v1(284.65,44.17) 284.25,44.57 284.25,44.68 284.63,45.07 287.74,45.07 288.36,45.69 296.8,45.69 297.31,45.17 297.31,43.66 297.11,43.46 297.11,42.8 297.02,42.7 296.89,42.7 296.8,42.61 JNGFF2.41
PCIE_PRX_RD_DTX_P11: length 19.3
  TOP w0.094: UN4.14 265.75,46.26 265.91,46.42 266.34,46.42 v1(266.53,46.23)
  IN1 w0.089: v1(266.53,46.23) 266.73,46.43 267.73,46.43 268.02,46.13 270.02,46.13 272.32,43.83 279.2,43.83 279.48,43.55 280.78,43.55 281.54,42.79 281.88,42.79 v1(282.08,42.59)
  BOTTOM w0.094: v1(282.08,42.59) 282.28,42.78 282.41,42.78 RN81.2
PCIE_PRX_RD_DTX_P12: length 27.3
  TOP w0.094: UN5.14 290.89,58.34 290.72,58.51 290.72,58.7 v1(290.91,58.89)
  IN1 w0.089: v1(290.91,58.89) 290.65,58.64 290.65,58.3 289.73,57.38 289.73,54.51 288.88,53.66 288.19,53.66 287.13,52.6 287.13,50.05 283.44,46.35 283.44,42.42 284.56,41.29 284.56,40.69 283.67,39.79 283.67,39.13 283.87,38.93 284.17,38.93 v1(284.42,39.18)
  BOTTOM w0.094: RN77.2 285.36,39.06 285.11,38.81 284.79,38.81 v1(284.42,39.18)
PCIE_PTX_C_DRX_N1: length 2.9
  TOP w0.094: CR12.2 30.11,49.63 29.57,49.63 29.57,49.64 28.91,49.64 28.91,49.63 28.72,49.63 28.6,49.75 28.31,49.75 28.21,49.86 UR1.4
PCIE_PTX_C_DRX_N3: length 4
  BOTTOM w0.094: CZ13.2 198.05,16.19 v4(198.71,16.19) 199.3,16.19 199.58,15.91 200.35,15.91 200.51,15.75 JNGFF1.37
PCIE_PTX_C_DRX_N4: length 2.5
  TOP w0.094: CL6.2 277.83,80.79 277.83,81.01 277.95,81.13 v4(277.95,81.45) 277.95,81.87 278.06,81.97 UL1.42
PCIE_PTX_C_DRX_N8: length 35.1
  IN1 w0.089: v1(290.43,47.98) 290.68,48.24 290.68,48.76 294.01,52.09 294.01,52.65 294.4,53.03 294.4,55.27 294.77,55.65 294.77,59.66 294.24,60.18 294.24,60.64 294.44,60.84 294.59,60.84 v1(294.84,61.08)
  BOTTOM w0.094: v1(290.43,47.98) 290.69,47.72 290.69,47.59 290.89,47.38 291.49,47.38 292.51,46.37 297.24,46.37 298.4,45.21 298.4,42.81 298.3,42.71 JNGFF2.47 ; v1(294.84,61.08) 295.12,60.81 295.14,60.81 295.31,60.98 295.31,62.52 294.54,63.29 294.54,64.5 293.63,65.41 293.63,65.97 293.57,66.03 293.46,66.03 293.2,65.76 CZ10.2
PCIE_PTX_C_DRX_N11: length 19.6
  BOTTOM w0.094: CN69.1 283.48,39.52 283.64,39.36 283.74,39.36 284.2,39.82 286.95,39.82 287.09,39.96 288.23,39.96 289.02,39.17 v4(289.4,39.17) 290.05,39.17 291.04,38.18 292.47,38.18 292.5,38.21 293.1,38.21 293.14,38.18 293.62,38.18 293.76,38.33 295.05,38.33 297.42,35.95 298.42,35.95 299.38,35 299.38,34.74 299.45,34.67 JNGFF3.35
PCIE_PTX_C_DRX_N12: length 15.1
  BOTTOM w0.094: JNGFF3.47 296.45,34.64 296.32,34.77 296.32,35 295.98,35.34 293.42,35.34 292.15,36.61 v4(289.76,36.61) 286.02,36.61 286.01,36.61 285.37,36.61 285.37,36.61 284.99,36.61 284.26,37.33 283.76,37.33 CN71.1
PCIE_PTX_C_DRX_P1: length 2.9
  TOP w0.094: UR1.3 28.16,49.46 28.27,49.57 28.52,49.57 28.64,49.45 v4(29.24,49.45) 30.13,49.45 CR11.2
PCIE_PTX_C_DRX_P3: length 4
  BOTTOM w0.094: JNGFF1.35 200.46,16.25 200.3,16.09 199.65,16.09 199.37,16.37 199.03,16.37 199,16.4 198.42,16.4 198.38,16.37 198.04,16.37 CZ12.2
PCIE_PTX_C_DRX_P4: length 2.4
  TOP w0.094: CL5.2 277.65,80.82 277.65,81.09 277.74,81.18 277.74,81.75 277.77,81.78 277.77,81.87 277.67,81.97 277.66,81.97 UL1.41
PCIE_PTX_C_DRX_P8: length 35.2
  IN1 w0.089: v1(294.84,60.5) 294.68,60.66 294.51,60.66 294.43,60.57 294.43,60.26 294.95,59.73 294.95,55.57 294.58,55.2 294.58,52.96 294.19,52.57 294.19,52.01 290.86,48.69 290.86,48.13 v1(291.01,47.98)
  BOTTOM w0.094: v1(294.84,60.5) 294.96,60.62 295.22,60.62 295.5,60.9 295.5,62.6 294.73,63.37 294.73,64.57 293.81,65.49 293.81,66.05 293.65,66.21 293.46,66.21 293.2,66.48 CZ11.2 ; v1(291.01,47.98) 290.87,47.84 290.87,47.66 290.96,47.57 291.57,47.57 292.59,46.55 297.32,46.55 298.58,45.29 298.58,42.84 298.8,42.62 JNGFF2.49
PCIE_PTX_C_DRX_P11: length 19.6
  BOTTOM w0.094: JNGFF3.37 298.95,34.57 299.2,34.81 299.2,34.92 298.35,35.77 297.35,35.77 294.98,38.14 293.84,38.14 293.69,37.99 v4(292.8,37.99) 290.96,37.99 289.97,38.98 289.73,38.98 289.69,38.95 289.11,38.95 289.07,38.98 288.95,38.98 288.15,39.77 287.17,39.77 287.03,39.63 284.28,39.63 283.82,39.18 283.58,39.18 283.48,39.08 CN70.1
PCIE_PTX_C_DRX_P12: length 15
  BOTTOM w0.094: CN72.1 283.48,37.04 283.58,37.14 284.19,37.14 284.91,36.42 v4(285.69,36.42) 289.43,36.42 289.46,36.39 290.05,36.39 290.08,36.42 292.07,36.42 293.34,35.15 295.91,35.15 296.14,34.92 296.14,34.79 295.95,34.61 JNGFF3.49
PCIE_PTX_C_RD_DRX_N8: length 2
  TOP w0.094: CZ136.2 283.8,65.33 283.89,65.42 284.16,65.42 284.58,65.01 284.87,65.01 285.05,64.83 UZ36.2
PCIE_PTX_C_RD_DRX_N11: length 2.3
  TOP w0.094: UN4.2 260.92,47.76 260.76,47.92 259.69,47.92 CN23.2
PCIE_PTX_C_RD_DRX_N12: length 3.9
  TOP w0.094: v1(289.29,52.99) 289.22,53.06 289.22,53.46 289.39,53.62 UN5.2
  BOTTOM w0.094: v1(289.29,52.99) 289.16,52.86 289.16,52.37 288.68,51.89 v4(288.28,51.89) 287.51,51.89 CN33.2
PCIE_PTX_C_RD_DRX_P8: length 2
  TOP w0.094: CZ135.2 283.8,65.73 283.92,65.61 284.24,65.61 284.66,65.19 284.83,65.19 284.97,65.33 UZ36.1
PCIE_PTX_C_RD_DRX_P11: length 2.3
  TOP w0.094: UN4.1 260.92,48.26 260.76,48.1 259.71,48.1 259.29,48.52 CN22.2
PCIE_PTX_C_RD_DRX_P12: length 3.9
  TOP w0.094: v1(288.69,53) 288.68,53 288.68,52.99 288.71,52.99 289.04,53.32 289.04,53.47 288.89,53.62 UN5.1
  BOTTOM w0.094: CN32.2 287.78,52.08 288.61,52.08 288.97,52.44 288.97,52.72 288.71,52.99 288.68,52.99 288.68,53 v1(288.69,53)
PCIE_PTX_DRX_N1: length 152.6
  TOP w0.094: v1(34.07,49.82) 33.85,49.61 32.82,49.61 32.78,49.64 32.2,49.64 32.17,49.61 31.77,49.61 CR12.1
  IN4 w0.089: v1(34.07,49.82) 34.09,49.8 34.37,49.8 34.46,49.89 34.46,57.41 43.11,66.06 43.11,68.33 45.48,70.7 45.48,75.53 46.36,76.41 50.74,76.41 52.33,78 55.28,78 63.44,86.15 63.44,89.36 65.35,91.27 67.12,91.27 68.63,92.78 81.45,92.78 84.81,96.14 85.6,96.14 90.12,100.66 93.46,100.66 95.05,102.24 108.41,102.24 111.23,99.42 111.23,94.86 111.92,94.18 111.92,93.15 112.61,92.45 113.21,92.45 117.86,87.8 117.86,86.8 119.08,85.58 119.08,85.28 120.75,83.61 121.36,83.61 121.73,83.25 121.73,82.66 122.55,81.84 123.88,81.84 127.13,78.59 127.13,77.72 127.64,77.21 127.64,76.26 128.38,75.52 v1(128.38,74.48)
  BOTTOM w0.076: 128.18,72.54 128.18,72.52 128.18,72.52 128.18,72.39 128.17,72.38 128.17,69.65 UC1.B17
  BOTTOM w0.094: v1(128.38,74.48) 128.37,74.16 128.37,73.82 128.37,73.63 128.37,73.53 128.37,73.31 128.37,73.18 128.37,72.84 128.18,72.65 128.18,72.54
PCIE_PTX_DRX_N3: length 110.9
  IN1 w0.089: v1(186.9,38.15) 186.92,38.15 187.21,38.44 187.21,38.69 187.12,38.78 179.3,38.78 173.79,44.29 173.79,45.26 171.02,48.03 171.02,48.86 163.6,56.28 163.6,60.73 162.09,62.24 162.09,65.77 157.97,69.89 146.9,69.89 145.93,70.86 135.82,70.86 134.91,69.94 129.28,69.94 127.98,71.24 127.75,71.24 127.4,70.89 v1(127.4,70.84)
  BOTTOM w0.076: UC1.D17 127.86,68.02 127.57,68.31 127.57,68.51 127.42,68.97 127.42,69.17 127.45,69.29 127.45,69.49 127.42,69.56 127.42,70.35 127.28,70.48 127.28,70.72 v1(127.4,70.84)
  BOTTOM w0.094: v1(186.9,38.15) 187.07,37.97 187.07,37.33 187.27,37.13 187.6,37.13 187.93,36.8 188.44,36.3 188.44,32.87 188.44,32.87 188.44,32.71 193.92,27.23 193.92,27.19 194.34,26.76 194.39,26.76 194.63,26.52 194.63,17.51 196.08,16.05 196.43,16.05 CZ13.1
PCIE_PTX_DRX_N4: length 233.8
  TOP w0.094: v1(277.41,78.28) 277.26,78.43 277.26,78.57 277.45,78.76 277.55,78.76 277.75,78.96 277.75,79.06 CL6.1
  IN1 w0.089: v1(277.41,78.28) 277.31,78.18 277.31,77.85 277.13,77.67 277.13,77.31 276.1,76.28 276.1,71.84 277.99,69.96 277.99,63.36 281.82,59.53 281.82,58.11 282.89,57.04 282.89,51.68 280.1,48.9 276.69,48.9 275.82,48.03 273.15,48.03 271.76,49.42 271.48,49.42 270.23,50.67 268.86,50.67 267.62,49.42 263.21,49.42 262.53,48.73 262.21,48.73 261.63,48.15 261.63,46.12 255.33,39.83 254.83,39.83 254.21,39.21 252.17,39.21 246.65,33.69 236.86,33.69 235.56,32.39 227.68,32.39 227.17,31.88 220.1,31.88 219.03,30.8 215.93,30.8 215.29,31.44 200.54,31.44 189.53,42.45 180.87,42.45 165.81,57.51 165.81,65.89 158.93,72.76 146.64,72.76 146.51,72.63 145.04,72.63 143.67,74.01 129.93,74.01 128.76,75.17 126.97,75.17 126.16,75.98 v1(126.16,77.08)
  BOTTOM w0.094: v1(126.16,77.08) 126.16,75.93 126.67,75.43 126.67,70.63 126.24,70.21 126.24,69.33 UC1.B19
PCIE_PTX_DRX_N8: length 222.4
  TOP w0.094: CZ136.1 282.88,65.25 282.72,65.41 282.37,65.41 282.05,65.74 282.05,66.06 281.99,66.11 281.96,66.11 281.55,66.52 281.55,66.57 281.49,66.63 280.87,66.63 280,65.76 279.37,65.76 v1(279.13,65.52)
  IN1 w0.089: v1(124.46,70.84) 124.69,71.07 124.97,71.07 125.23,71.33 125.23,72.25 125.58,72.61 141.86,72.61 143.03,71.44 147.2,71.44 147.37,71.61 157.06,71.61 162.68,66 162.68,62.78 164.37,61.08 164.37,57.09 180.2,41.26 189.04,41.26 200.08,30.22 214.51,30.22 215.29,29.43 219.73,29.43 220.64,30.34 228.57,30.34 229.37,31.14 236.19,31.14 237.29,32.25 246.84,32.25 251.6,37.01 253.81,37.01 256.04,39.24 256.04,39.72 261.12,44.8 262.21,44.8 262.88,45.47 262.88,48.2 263.48,48.8 270.68,48.8 272.12,47.36 275.37,47.36 275.83,46.9 278.92,46.9 283.47,51.45 283.47,57.32 282.47,58.32 282.47,59.94 280.78,61.64 280.78,64.25 280.4,64.64 279.63,64.64 279.43,64.43 278.87,64.43 278.68,64.62 278.68,65.65 278.78,65.74 278.91,65.74 v1(279.13,65.52)
  BOTTOM w0.076: UC1.D21 125.16,68.09 125.09,68.36 125.09,68.47 124.95,68.95 124.95,69.2 124.98,69.29 124.98,69.48 124.95,69.58 124.95,71.08 124.86,71.18 124.64,71.18 124.46,71 v1(124.46,70.84)
PCIE_PTX_DRX_N11: length 176.2
  TOP w0.094: v1(254.24,38.62) 253.83,38.62 253.68,38.77 253.68,39 254.51,39.83 254.51,42.12 256.29,43.9 256.29,47.87 256.57,48.15 257.2,48.15 257.43,47.92 257.97,47.92 CN23.1
  IN1 w0.089: v1(123.9,72.94) 123.9,72.77 123.99,72.68 124.61,72.68 125.38,73.45 142.09,73.45 143.31,72.23 146.87,72.23 147.01,72.37 157.4,72.37 165.27,64.5 165.27,57.46 180.72,42.01 189.35,42.01 200.36,31.01 215.02,31.01 215.65,30.37 219.33,30.37 220.44,31.48 227.54,31.48 227.93,31.1 228.26,31.1 229.07,31.91 235.66,31.91 236.94,33.19 246.71,33.19 252.34,38.81 253.5,38.81 253.7,38.62 v1(254.24,38.62)
  BOTTOM w0.076: v1(123.9,72.94) 123.81,72.85 123.19,72.85 123.02,72.68 123.02,72.27 122.58,71.83 122.58,70.66 123.17,70.07 123.17,68.61 UC1.D24
PCIE_PTX_DRX_N12: length 212.7
  IN1 w0.089: v1(122.15,73.6) 122.15,73.35 122.27,73.22 122.63,73.22 122.71,73.3 122.71,75.76 125.15,78.2 126.93,78.2 127.6,77.54 129.31,77.54 129.6,77.82 131.09,77.82 132.11,76.8 138,76.8 138.51,77.31 145.9,77.31 146.26,77.67 150.38,77.67 151.77,76.27 154.32,76.27 155.91,74.68 158.26,74.68 166.6,66.34 166.6,57.81 181.16,43.25 189.84,43.25 200.82,32.28 206.06,32.28 206.81,33.03 218.07,33.03 218.57,32.53 219.27,32.53 219.44,32.7 224.82,32.7 225.27,33.15 235.07,33.15 236.37,34.44 246.23,34.44 251.81,40.01 253.87,40.01 254.63,40.78 255.21,40.78 259.28,44.85 259.28,48.37 260.52,49.61 262.13,49.61 263.27,50.74 267.87,50.74 268.71,51.58 270.97,51.58 271.97,50.58 273.44,50.58 273.71,50.86 274.34,50.86 274.45,50.75 276.53,50.75 277.62,49.67 279.8,49.67 281.99,51.86 281.99,51.97 281.84,52.13 281.29,52.13 v1(281.28,52.12)
  BOTTOM w0.076: UC1.A25 122.92,69.71 123,69.8 123,69.98 122.92,70.06 122.79,70.06 122.61,69.88 122.53,69.88 122.47,69.95 122.35,70.12 122.35,71.83 122.85,72.33 122.85,73.04 122.57,73.32 122.37,73.32 122.15,73.54 v1(122.15,73.6)
  BOTTOM w0.094: CN33.1 286.16,51.89 286.02,51.89 285.77,51.64 282.07,51.64 281.59,52.12 v1(281.28,52.12)
PCIE_PTX_DRX_P1: length 152.5
  TOP w0.094: v1(34.07,49.24) 33.89,49.42 v4(32.49,49.42) 31.64,49.42 31.39,49.17 CR11.1
  IN4 w0.089: v1(127.79,74.48) 128.2,74.89 128.2,75.45 127.46,76.18 127.46,77.13 126.95,77.64 126.95,78.51 123.81,81.66 122.48,81.66 121.55,82.59 121.55,83.17 121.29,83.43 120.67,83.43 118.9,85.21 118.9,85.51 117.68,86.72 117.68,87.73 113.14,92.27 112.54,92.27 111.74,93.07 111.74,94.1 111.05,94.79 111.05,99.35 108.34,102.06 95.12,102.06 93.54,100.48 90.2,100.48 85.68,95.96 84.89,95.96 81.52,92.6 68.71,92.6 67.2,91.09 65.42,91.09 63.62,89.29 63.62,86.08 55.36,77.82 52.4,77.82 50.82,76.23 46.44,76.23 45.66,75.45 45.66,70.63 43.29,68.26 43.29,65.98 34.64,57.34 34.64,49.82 34.44,49.61 34.44,49.61 v1(34.07,49.24)
  BOTTOM w0.076: UC1.A17 127.8,69.71 127.75,69.76 127.75,70.03 127.82,70.11 127.95,70.11 128.01,70.16 128.01,72.47
  BOTTOM w0.094: 128.01,72.47 127.99,72.48 127.99,72.65 127.99,72.73 128.18,72.92 128.19,73.53 128.19,73.63 128.19,73.82 128.19,73.97 128.09,74.06 127.8,74.06 127.7,74.15 127.7,74.4 v1(127.79,74.48)
