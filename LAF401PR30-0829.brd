# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P3: length 110.9
  IN1 w0.089: v1(187.48,38.15) 187.39,38.23 187.39,38.76 187.2,38.96 179.38,38.96 173.97,44.36 173.97,45.33 171.2,48.1 171.2,48.94 163.78,56.36 163.78,60.8 162.27,62.32 162.27,65.85 158.04,70.07 146.98,70.07 146.01,71.04 135.74,71.04 134.83,70.12 129.35,70.12 128.05,71.42 v1(127.4,71.42)
  BOTTOM w0.076: v1(127.4,71.42) 127.77,71.06 127.77,70.58 127.58,70.39 127.58,69.6 127.62,69.53 127.62,69.27 127.58,69.15 127.58,68.99 127.74,68.54 UC1.C17
  BOTTOM w0.094: CZ12.1 196.72,16.44 196.52,16.24 196.16,16.24 194.82,17.58 194.82,26.6 194.64,26.77 v4(194.28,27.13) 194.08,27.33 188.62,32.79 188.62,36.37 187.68,37.32 187.35,37.32 187.25,37.41 187.25,37.92 v1(187.48,38.15)
PCIE_PTX_DRX_P4: length 233.8
  TOP w0.094: CL5.1 277.56,79.32 277.56,79.04 277.47,78.94 277.37,78.94 277.07,78.64 277.07,78.53 v1(276.83,78.28)
  IN1 w0.089: v1(276.83,78.28) 276.85,78.28 277.13,78 277.13,77.93 276.95,77.74 276.95,77.38 275.92,76.36 275.92,71.76 277.81,69.88 277.81,63.29 281.64,59.46 281.64,58.04 282.71,56.96 282.71,51.76 280.03,49.08 276.61,49.08 275.74,48.21 273.23,48.21 271.83,49.6 271.55,49.6 270.31,50.85 268.79,50.85 267.54,49.6 263.14,49.6 262.45,48.91 262.13,48.91 261.44,48.22 261.44,46.2 255.25,40.01 254.75,40.01 254.13,39.39 252.1,39.39 246.58,33.87 236.78,33.87 235.49,32.57 227.61,32.57 227.09,32.06 220.03,32.06 218.95,30.98 216.01,30.98 215.37,31.62 200.61,31.62 189.6,42.63 180.94,42.63 165.99,57.58 165.99,65.96 159.01,72.94 146.56,72.94 146.44,72.81 145.12,72.81 143.74,74.19 130,74.19 128.83,75.35 127.04,75.35 126.34,76.06 126.34,76.57 126.43,76.66 126.84,76.66 126.93,76.75 126.93,76.96 v1(126.84,77.05)
  BOTTOM w0.094: v1(126.84,77.05) 126.97,77.05 127.07,76.96 127.07,76.73 126.94,76.6 126.44,76.6 126.35,76.51 126.35,76.01 126.85,75.51 126.85,70.55 126.43,70.13 126.43,69.79 126.51,69.71 UC1.A19
PCIE_PTX_DRX_P8: length 222.4
  TOP w0.094: v1(279.13,66.11) 279.29,65.95 279.92,65.95 280.79,66.82 281.56,66.82 v4(281.91,66.47) 282.23,66.15 282.23,65.82 282.45,65.6 282.72,65.6 282.88,65.76 CZ135.1
  IN1 w0.089: v1(279.13,66.11) 278.95,65.92 278.7,65.92 278.5,65.72 278.5,64.55 278.8,64.25 279.51,64.25 279.71,64.46 280.32,64.46 280.6,64.18 280.6,61.56 282.29,59.87 282.29,58.24 283.29,57.24 283.29,51.52 278.85,47.08 275.91,47.08 275.44,47.54 272.19,47.54 270.76,48.98 263.4,48.98 262.7,48.28 262.7,45.55 262.13,44.98 261.04,44.98 255.86,39.79 255.86,39.31 253.74,37.19 251.53,37.19 246.76,32.43 237.22,32.43 236.11,31.32 229.29,31.32 228.5,30.53 220.57,30.53 219.66,29.61 215.37,29.61 214.58,30.4 200.16,30.4 189.12,41.44 180.28,41.44 164.55,57.17 164.55,61.16 162.86,62.85 162.86,66.07 157.13,71.79 147.3,71.79 147.12,71.62 143.11,71.62 141.94,72.79 125.51,72.79 125.05,72.33 125.05,71.41 124.89,71.25 124.67,71.25 124.61,71.32 124.6,71.32 124.47,71.46 124.47,71.53 v1(124.46,71.53)
  BOTTOM w0.076: v1(124.46,71.53) 124.65,71.34 124.92,71.34 125.11,71.15 125.11,69.61 125.15,69.54 125.15,69.26 125.11,69.15 125.11,68.98 125.17,68.8 125.26,68.74 125.52,68.74 125.61,68.65 125.61,68.45 125.53,68.37 125.42,68.37 UC1.C21
PCIE_PTX_DRX_P11: length 176.2
  TOP w0.094: CN22.1 257.95,48.1 257.51,48.1 257.27,48.34 256.49,48.34 256.11,47.95 256.11,43.97 254.33,42.2 254.33,39.91 253.5,39.08 253.5,38.69 253.83,38.36 v1(253.83,38.21)
  IN1 w0.089: v1(123.9,72.25) 124.15,72.5 124.69,72.5 125.46,73.27 142.01,73.27 143.24,72.05 146.94,72.05 147.08,72.19 157.32,72.19 165.09,64.42 165.09,57.39 180.64,41.83 189.28,41.83 200.29,30.83 214.94,30.83 215.58,30.19 219.4,30.19 220.52,31.3 227.47,31.3 227.85,30.92 228.33,30.92 229.15,31.73 235.74,31.73 237.02,33.01 246.79,33.01 252.41,38.63 253.43,38.63 253.83,38.23 v1(253.83,38.21)
  BOTTOM w0.076: UC1.C24 123.47,68.7 123.56,68.61 123.7,68.61 123.79,68.7 123.79,68.89 123.58,69.09 123.41,69.09 123.34,69.16 123.34,70.14 122.74,70.73 122.74,71.76 123.18,72.2 123.18,72.61 123.26,72.69 123.62,72.69 123.9,72.41 v1(123.9,72.25)
PCIE_PTX_DRX_P12: length 212.6
  IN1 w0.089: v1(122.18,72.83) 122.4,73.04 122.7,73.04 122.89,73.23 122.89,75.69 125.22,78.02 126.86,78.02 127.52,77.36 129.39,77.36 129.67,77.64 131.02,77.64 132.04,76.62 138.08,76.62 138.59,77.13 145.98,77.13 146.33,77.49 150.3,77.49 151.7,76.09 154.25,76.09 155.83,74.5 158.18,74.5 166.42,66.27 166.42,57.73 181.08,43.07 189.77,43.07 200.74,32.1 206.14,32.1 206.89,32.85 218,32.85 218.5,32.35 219.35,32.35 219.51,32.52 224.9,32.52 225.35,32.97 235.15,32.97 236.44,34.26 246.31,34.26 251.88,39.83 253.94,39.83 254.71,40.6 255.28,40.6 259.46,44.77 259.46,48.29 260.59,49.43 262.21,49.43 263.34,50.56 267.95,50.56 268.79,51.4 270.9,51.4 271.9,50.4 273.51,50.4 273.79,50.68 274.27,50.68 274.37,50.57 276.46,50.57 277.54,49.49 279.88,49.49 282.17,51.78 282.17,52.05 v1(281.69,52.53)
  BOTTOM w0.076: v1(122.18,72.83) 122.18,73.05 122.28,73.16 122.5,73.16 122.69,72.97 122.69,72.4 122.18,71.89 122.18,70.06 122.51,69.61 UC1.B25
  BOTTOM w0.094: CN32.1 286.38,52.51 285.7,51.83 282.14,51.83 281.69,52.28 v1(281.69,52.53)
PCIE_PTX_RD_DRX_N8: length 4
  TOP w0.094: UZ36.17 289.71,64.83 289.87,65 290.23,65 v1(290.43,64.8)
  BOTTOM w0.094: v1(290.43,64.8) 290.63,65 290.94,65 291.22,65.27 291.22,65.66 291.56,66 291.9,66 CZ10.1
PCIE_PTX_RD_DRX_N11: length 25.9
  TOP w0.094: UN4.17 265.73,47.76 266.04,48.07 266.64,48.07 266.81,48.24 269.53,48.24 269.8,47.97 269.8,46.3 270.65,45.44 270.65,45.26 270.55,45.16 270.31,45.16 v1(270,45.46)
  IN1 w0.089: v1(270,45.46) 270.3,45.17 270.42,45.17 272.2,43.39 273.88,43.39 274.78,42.49 275.54,42.49 276.49,43.43 278.15,43.43 280.72,40.85 280.72,39.48 281.3,38.9 281.58,38.9 v1(281.92,39.24)
  BOTTOM w0.094: CN69.2 282.57,39.55 282.15,39.14 282.02,39.14 281.92,39.23 v1(281.92,39.24)
PCIE_PTX_RD_DRX_N12: length 31.2
  TOP w0.094: UN5.17 289.39,58.32 289.05,58.65 v1(289.05,58.98)
  IN1 w0.089: v1(281.93,37.48) 282.11,37.3 282.41,37.3 282.53,37.41 282.53,39.2 281.84,39.89 281.84,41.78 282.67,42.61 282.67,46.68 286.32,50.33 286.32,52.86 288.42,54.96 288.42,57.45 287.21,58.65 287.21,59.47 287.78,60.04 288.62,60.04 288.93,59.73 288.93,59.11 v1(289.05,58.98)
  BOTTOM w0.094: CN71.2 282.57,37.44 282.45,37.32 282.08,37.32 v1(281.93,37.48)
PCIE_PTX_RD_DRX_P8: length 4
  TOP w0.094: v1(290.43,65.38) 290.23,65.18 289.86,65.18 289.7,65.33 UZ36.18
  BOTTOM w0.094: v1(290.43,65.38) 290.63,65.18 290.86,65.18 291.03,65.35 291.03,65.75 v4(291.27,65.98) 291.47,66.18 291.9,66.18 CZ11.1
PCIE_PTX_RD_DRX_P11: length 25.9
  TOP w0.094: v1(270,44.88) 270.1,44.97 270.62,44.97 270.83,45.18 270.83,45.52 269.98,46.37 269.98,48.05 269.6,48.42 266.73,48.42 266.57,48.26 UN4.18
  IN1 w0.089: v1(281.92,38.66) 281.86,38.72 281.23,38.72 280.54,39.4 280.54,40.78 278.07,43.25 276.56,43.25 275.62,42.31 274.71,42.31 273.81,43.21 272.12,43.21 270.34,44.99 270.11,44.99 v1(270,44.88)
  BOTTOM w0.094: CN70.2 282.44,38.88 282.15,38.88 v1(281.92,38.66)
PCIE_PTX_RD_DRX_P12: length 31.2
  TOP w0.094: v1(288.47,58.98) 288.89,58.57 UN5.18
  IN1 w0.089: v1(288.47,58.98) 288.74,59.26 288.74,59.66 288.55,59.85 287.86,59.85 287.4,59.39 287.4,58.73 288.6,57.52 288.6,54.88 286.5,52.78 286.5,50.25 282.85,46.6 282.85,42.54 282.02,41.71 282.02,39.96 282.71,39.28 282.71,37.49 282.71,37.49 282.71,37.34 282.57,37.2 282.49,37.12 282.14,37.12 v1(281.91,36.89)
  BOTTOM w0.094: CN72.2 282.57,36.99 282.42,37.13 282.16,37.13 282.05,37.03 282.05,37.03 v1(281.91,36.89)
PCIE_RCOMPN: length 3.8
  TOP w0.305: v1(134.35,66.58) 134.2,66.58 133.68,67.1 133.12,67.1 v2(133,66.97) 132.65,67.32 132.35,67.32 131.75,67.91 RC45.1
  BOTTOM w0.254: v1(134.35,66.58) UC1.F5
PCIE_RCOMPP: length 2.8
  TOP w0.305: v1(134.35,67.21) 134.35,67.54 133.77,68.12 132.82,68.12 RC45.2
  BOTTOM w0.254: v1(134.35,67.21) UC1.E5
PCIE_WAKE#: length 205.4
  TOP w0.102: v1(307.13,66.76) 307.43,67.05 308.69,67.05 RE274.1 310.24,66.36 RE275.1
  IN2 w0.122: v1(225.32,11.42) 225.32,12.63 233.28,20.59 242.88,20.59 246.61,24.33 254.11,24.33 v1(254.73,23.71) 256,23.71 257.84,25.55 258.6,25.55 259.94,26.88 262.28,26.88 264.06,28.67 279.71,28.67 281.88,30.84 281.88,31.8 285.31,35.23 287.39,35.23 290.61,38.45 290.61,39.24 291.65,40.28 291.65,41.33 292.61,42.29 292.61,43.66 295.02,46.07 297.06,46.07 298,47.01 298,49.28 299.15,50.44 300.92,50.44 301.45,50.97 301.45,52.45 v1(302.36,53.36) 302.69,53.36 304.12,54.79 304.56,54.79 305.78,56.01 305.78,58.3 306.98,59.5 306.98,60.98 307.74,61.73 307.74,63.05 307.13,63.65 v1(307.13,66.76)
  BOTTOM w0.102: 205.76,7.5 205.36,7.11 205.36,4.59 205.85,4.1 208.88,4.1 209.13,3.86 221.53,3.86 225.32,7.64 v1(225.32,11.42) ; 205.76,7.5 JNGFF1.70 ; 205.76,7.5 203.74,9.51 203.74,10.85 203.34,11.25 201.28,11.25 JNGFF1.55 ; v1(302.36,53.36) 302.02,53.36 300.05,51.38 JNGFF2.54 ; v1(254.73,23.71) 254.87,23.56 266.6,23.56 267.92,24.88 v2(285.77,24.88) 294.01,24.88 294.7,25.57 JNGFF3.54
PCIE_WAKE#_R: length 23
  TOP w0.102: RE275.2 312.01,66.38 v2(312.16,66.53) 312.26,66.63 312.26,69.09 v1(311.86,69.49) ; UE1.N13 305.76,82.12 v1(306.01,82.12) 306.01,82.7 306.58,83.27 RE35.1
  IN2 w0.122: v1(311.86,69.49) 311.21,69.49 309.63,71.06 309.63,74.63 308.59,75.67 308.59,78.15 306.42,80.32 306.42,81.71 v1(306.01,82.12)
PD1_GPIO2: length 2.7
  TOP w0.102: v1(34.13,79.05) 34.08,79 34.07,79 33.64,78.57 UT5.D10
  BOTTOM w0.102: v2(34.65,79.29) 34.41,79.05 v1(34.13,79.05) 33.43,79.75 RT71.1
PD1_GPIO6: length 5.5
  TOP w0.076: 31.9,76.75 31.9,78.22 32.14,78.47 UT5.G10
  TOP w0.102: 31.9,76.75 31.75,76.6 31.49,76.6 RT75.1 30.49,75.6 30.49,74.19 v2(30.74,73.93)
PD1_GPIO7: length 5.3
  TOP w0.102: v1(34.15,79.72) 33.83,80.04 UT5.D7
  BOTTOM w0.102: v1(34.15,79.72) 34.88,79.72 35.59,79.01 RT339.1 37.39,80.08 v2(37.47,80.16)
PD1_GPIO8: length 5.6
  TOP w0.076: UT5.H6 v1(31.16,80.54)
  BOTTOM w0.102: v1(31.16,80.54) 30.5,80.54 RT377.1 29.05,80.4 28.91,80.54 RT76.1 27.79,79.9 v2(26.42,79.9)
PD#: length 8.3
  TOP w0.102: v2(297.05,43.48) 296.61,43.48 296.26,43.12 RA48.2 296.87,42.36 RA50.2 295.75,42.26 DA8.2 295.51,41.43 RA18.1 296.8,40.14 CA31.1 297.8,38.9 UA1.47
PDA_RESET#_R: length 2.5
  TOP w0.203: v1(32.66,77.49) 32.66,77.5 32.64,77.52 UT5.F11
  BOTTOM w0.102: v1(32.66,77.49) 32.09,78.06 v2(31.69,78.06)
  BOTTOM w0.254: RT110.2 32.63,77.46 v1(32.66,77.49)
PECI_EC: length 306.5
  TOP w0.102: v1(302.74,85.35) 302.71,85.31 RE60.2 ; v1(148.01,96.11) 147.84,96.11 145.7,93.97 144.69,93.97 v2(144.09,93.37) 143.98,93.26 141.58,93.26 140.87,93.98 130.89,93.98 125.63,88.73 122.28,88.73 121.83,89.17 117.45,89.17 115.96,87.67 113.16,87.67 112.78,87.29 112.78,86.33 111.89,85.44 111.89,83.41 109.86,81.37 108.53,81.37 107.69,80.54 v1(106.99,80.54)
  IN4 w0.089: v1(302.74,85.35) 301.11,83.71 293.82,83.71 292.87,84.66 291.33,84.66 290.48,83.81 287.58,83.81 286.77,84.63 284.47,84.63 283.83,85.26 281.25,85.26 279.86,83.87 276.84,83.87 275.32,82.34 274.96,82.34 272.88,80.26 272.88,78.17 272.16,77.45 272.16,76.68 272.43,76.42 272.43,75.85 272.98,75.31 272.98,64.16 273.21,63.92 274.16,63.92 274.72,63.36 274.72,62.22 275.1,61.84 275.1,56.42 274.92,56.24 274.23,56.24 273.48,55.5 273.48,54.41 270.09,51.02 269.15,51.02 267.31,49.18 267.31,48.26 266.09,47.04 266.09,46.72 265.47,46.1 265.47,45.46 264.86,44.85 264.58,44.85 252.97,33.24 252.97,32.7 248.68,28.42 240.11,28.42 236,32.53 227.65,32.53 227.14,32.02 219.55,32.02 217.96,30.43 211.05,30.43 208.51,32.97 199.54,32.97 197.06,35.46 197.06,37.14 186.1,48.1 181.39,48.1 173.75,55.73 173.75,57.71 172.54,58.92 172.54,77.73 155.88,94.39 149.73,94.39 v1(148.01,96.11)
  BOTTOM w0.076: v1(106.99,80.54) 106.99,74.34 105.75,73.1 105.75,71.3 105.91,71.14 106.42,71.14 106.75,70.81 106.75,70.12 106.68,70.06 UC1.A54
PECI_EC_R: length 3.2
  TOP w0.102: RE60.1 303.54,82.97 v2(303.54,82.9) 303.13,82.9 302.82,82.59 302.82,81.59 UE1.K13
PGOOD_3V: length 3.9
  TOP w0.102: PR107.2 152.43,115.13 v2(152.07,114.78)
  TOP w0.254: PU100.9 154.99,114.14 154.01,115.13 PR119.1 PR107.2
PGOOD_5V: length 5.1
  BOTTOM w0.102: v2(170.52,119.47) 170.52,117.95 PR113.2
  BOTTOM w0.254: PU102.9 168.14,116.6 168.39,116.86 168.94,116.86 169.19,117.11 PR120.1 170.06,117.51 PR113.2
PLTRST_LAN#: length 166.8
  TOP w0.102: UL1.36 274.92,83.42 274.83,83.33 274.83,82.95 273.03,81.15 271.75,81.15 271.37,80.77 v1(270.47,80.77)
  IN4 w0.089: v1(182.31,54.03) 182.33,54.03 183.16,53.21 190.09,53.21 202.39,40.91 205.16,40.91 212.53,33.55 217.05,33.55 218.38,34.88 236.27,34.88 240.4,30.75 247.12,30.75 251.59,35.22 251.72,35.22 256.95,40.45 256.95,40.86 260.28,44.18 260.28,44.54 262.16,46.42 262.47,46.42 262.79,46.75 262.79,46.98 263.38,47.57 263.61,47.57 263.81,47.77 263.81,48.12 269.23,53.55 269.23,54.07 272.3,57.13 272.3,61.63 269.77,64.16 269.77,70.63 270.13,70.99 270.13,73.81 269.33,74.61 269.33,79.64 v1(270.47,80.77)
  BOTTOM w0.102: v1(182.31,54.03) 179.78,54.03 178.04,52.29 v2(173.09,52.29) 164.77,52.29 164.76,52.29 162.09,52.29 161.41,52.96 RC62.2
PLTRST_TPM#: length 23.5
  TOP w0.102: v1(163.82,39.89) 163.82,39.4 164.05,39.17 UZ12.17
  BOTTOM w0.102: v1(163.82,39.89) 162.99,39.89 159.77,36.67 158.4,36.67 155.45,39.62 155.45,41.62 156.66,42.83 v2(156.66,48.02) RC325.2 RC60.2
PM_LANPHY_ENABLE: length 326.5
  TOP w0.102: RL7.1 v1(282.21,78.96)
  IN1 w0.089: v1(178.38,22.45) 178.92,22.99 189.5,22.99 190.48,22 192.73,22 198.46,16.27 205.68,16.27 208.13,13.82 213.07,13.82 214.16,14.9 219.14,14.9 219.5,14.54 227.82,14.54 233.42,20.14 244.78,20.14 246.51,21.87 252.32,21.87 254.56,24.11 257.22,24.11 260.13,27.02 263.76,27.02 264.23,26.55 264.56,26.55 265.54,27.53 285.62,27.53 288.74,30.65 288.74,32.72 290.59,34.57 291.46,34.57 293.97,37.09 294.77,37.09 295.45,37.77 295.45,38.22 297.57,40.33 297.57,40.84 297.79,41.06 299.06,41.06 300.56,42.56 300.56,43.63 300.93,43.99 303.34,43.99 303.71,44.37 303.71,45.03 304.25,45.56 306.99,45.56 307.78,46.35 308.11,46.68 308.11,50.11 309.47,51.47 309.47,56.83 312.21,59.58 316.59,59.58 319.92,62.91 319.92,82.63 v1(318.35,84.2)
  IN2 w0.122: v1(318.35,84.2) 317.98,84.2 317.86,84.32 317.86,91.38 317.74,91.5 313.6,91.5 312.74,90.64 309.03,90.64 308.32,91.34 302.66,91.34 302.29,91.72 300.23,91.72 298.6,93.35 292.67,93.35 291.83,92.5 287.56,92.5 286.77,91.71 286.77,89.1 286.91,88.95 286.91,86.68 285.47,85.24 285.47,83.67 283.74,81.94 283.74,80.84 282.33,79.42 282.33,79.08 v1(282.21,78.96)
  BOTTOM w0.076: UC1.AW17 127.72,48.94 127.55,48.76 127.55,48.76 127.33,48.06 127.33,47.98 127.28,47.82 127.28,47.68 127.34,47.46 127.34,47.34 127.29,47.23 127.29,46.86 127.49,46.67 127.49,45.15 128.84,43.79 128.84,43.45 128.84,43.45
  BOTTOM w0.102: v1(178.38,22.45) 178.23,22.29 135.64,22.29 130.43,27.5 130.43,29.22 130.05,29.6 130.05,36.39 130.79,37.13 130.79,38.65 128.84,40.6 v2(128.84,41.74) 128.84,43.45
PME#: length 1.2
  TOP w0.102: v1(130.62,49.88) 130.62,49.61 T115.1
  BOTTOM w0.102: v1(130.62,49.88) 130.95,50.2 UC1.AU11
POA_WAKE#: length 121.7
  TOP w0.102: v1(222.76,24.08) 223.22,24.54 RZ364.1 ; v1(292.49,69.36) 292.13,69 RE324.1
  TOP w0.107: v1(298.36,73.93) UE1.E4
  IN3 w0.122: v1(222.76,24.08) 223.33,23.51 227.45,23.51 228.16,24.23 238.64,24.23 243.79,29.38 247.86,29.38 249.73,31.25 257.81,31.25 259.04,32.48 277.18,32.48 280.22,35.51 280.22,36.39 280.84,37.01 280.84,37.47 281.41,38.04 281.41,40.22 283.17,41.97 283.17,44.79 283.68,45.31 286.69,45.31 288.57,47.18 288.57,48.87 291.32,51.62 291.94,51.62 292.95,52.63 292.95,52.84 293.86,53.74 293.86,55.35 294.81,56.3 294.81,58.43 295.06,58.68 295.06,60.12 295.26,60.32 295.26,62.2 297.42,64.36 297.42,64.95 297.82,65.35 297.82,68.55 296.95,69.42 296.95,71.49 297.96,72.5 297.96,73.53 v1(298.36,73.93)
  BOTTOM w0.102: v1(292.49,69.36) 293.59,70.47 295.64,70.47 v2(297.74,72.57) 297.96,72.79 297.96,73.53 v1(298.36,73.93)
POA_WAKE#_R: length 20.5
  TOP w0.102: v2(221.44,8.88) 221.67,8.65 JUSH1.4 224.29,8.65 226.88,11.23 226.88,17.54 223.33,21.09 RZ364.2
POWER_SW#_MB: length 109.8
  TOP w0.102: v3(284.93,93.81) 284.49,93.81 v1(284.1,94.19)
  TOP w0.254: v1(284.21,70.48) 284.62,70.9 CE102.1 CE101.1 285.21,70.24 285.53,69.92 RE33.2 ; SW3.2 320.06,96.55 320.05,96.54 v1(319.92,96.54) 319.91,96.55 SW3.4
  IN2 w0.254: v1(319.92,96.54) 317.73,96.54 316.18,94.99 308.25,94.99 307.02,96.21 304.31,96.21 303.47,97.05 286.78,97.05 284.1,94.38 v1(284.1,94.19)
  IN3 w0.254: v1(318.78,67.25) 319.08,67.25 319.92,68.09 v1(319.92,96.54) ; v1(284.21,70.48) 284.05,70.63 284.05,72.46 284.63,73.04 284.63,75.11 284.9,75.38 284.9,78.82 288.21,82.13 288.21,84.05 289.31,85.15 289.31,86.23 291.51,88.42 291.51,90.94 290.7,91.74 288.65,91.74 286.21,94.19 v1(284.1,94.19)
  BOTTOM w0.254: JAPS1.11 v1(318.78,67.25)
POWER_SW_IN#: length 17
  TOP w0.127: v2(288.88,70.83) CE12.1
  TOP w0.254: UE1.D5 297.96,75.1 v1(297.56,74.7) ; v1(285.98,71.5) 285.88,71.4 RE33.1 RE31.2 CE12.1
  IN4 w0.254: 297.25,72.3 296.73,71.79 295.6,71.79 294.26,73.13 287.61,73.13 v1(285.98,71.5)
PROCHOT#: length 486.3
  TOP w0.102: v1(95.99,80.66) 96.63,80.03 99,80.03 100.78,81.81 102.11,81.81 v1(103.38,80.54) 104.57,80.54 105.67,79.44 107.96,79.44 108.9,80.38 110.37,80.38 112.86,82.87 112.86,84.29 115.16,86.59 116.26,86.59 117.87,88.21 121.43,88.21 121.88,87.76 126.11,87.76 131.2,92.85 140.6,92.85 141.15,92.3 146.34,92.3 v2(148.68,94.63) 149.06,95.01 v1(149.74,95.01) ; v1(72.92,52.18) 73.41,51.69 PR678.1 PC605.2 74.65,51.92 v1(75.42,51.92) ; RE288.2 301.38,85 v1(301.38,85.44) ; PC918.2 11.08,14.62 v1(11.66,14.62) 11.83,14.79 PR926.1
  IN1 w0.089: v1(103.38,80.54) 103.38,80.31 106.35,77.34 106.35,71.43 106.8,70.99 106.8,69.14 106.3,68.65 97.21,68.65 96.78,68.22 92.14,68.22 90.28,66.35 90.28,63.37 88.21,61.3 86.81,61.3 85.86,60.34 85.86,58.31 85.29,57.74 84.51,57.74 78.69,51.92 v1(75.42,51.92)
  IN4 w0.089: v1(149.74,95.01) 156.85,95.01 173.11,78.76 173.11,59.59 183.98,48.71 186.27,48.71 197.6,37.37 197.6,35.69 199.75,33.55 208.73,33.55 211.27,31.01 217.75,31.01 219.71,32.97 224.16,32.97 224.67,33.48 235.82,33.48 240.34,28.96 248.45,28.96 252.23,32.73 252.23,33.27 264.35,45.4 264.63,45.4 264.93,45.69 264.93,46.32 265.55,46.94 265.55,47.26 266.77,48.49 266.77,49.41 269.02,51.66 269.96,51.66 272.92,54.62 272.92,55.76 273.76,56.6 273.76,59.69 274.16,60.1 274.16,61.36 274.05,61.47 274.05,61.61 272.42,63.23 272.42,72.66 271.31,73.77 271.31,78.7 272.33,79.72 272.33,80.69 274.53,82.89 275.09,82.89 276.59,84.39 276.59,84.73 276.76,84.9 279.96,84.9 280.88,85.82 284.17,85.82 284.52,85.46 287.08,85.46 288.12,84.42 290.17,84.42 290.99,85.24 293.63,85.24 294.33,84.54 300.47,84.54 v1(301.38,85.44) ; v1(11.66,14.62) 11.26,14.22 11.26,13.47 10.61,12.82 10.61,8.95 13.77,5.78 18.7,5.78 19.31,6.4 28.62,6.4 30.56,4.45 37,4.45 40.89,8.34 40.89,13.1 40.41,13.57 40.41,42.18 39.48,43.12 39.48,54.02 40.89,55.43 51.69,55.43 52.93,54.19 58.71,54.19 59.17,53.73 67.25,53.73 67.82,53.15 71.94,53.15 v1(72.92,52.18)
  BOTTOM w0.102: RC83.1 94.01,79.9 CC310.1 RC84.1 95.89,80.56 v1(95.99,80.66)
PROCHOT#_ISL9538: length 8.3
  TOP w0.203: PR926.2 13.21,15.09 12.97,15.32 9.66,15.32 PQ1216.1 ; PU901.23 15.49,15.96
  TOP w0.254: 15.49,15.96 v2(15.3,15.77) 15.08,15.55 14.46,15.55 13.7,14.79 PR926.2
PROCHOT#_R: length 15.4
  BOTTOM w0.076: UC1.C65 100.42,68.72 100.33,68.98 100.33,69.15 100.39,69.34 100.39,69.49 100.33,69.61 100.33,69.87 100.53,70.06 100.53,70.57 99.4,71.7 99.4,72.18 98.89,72.7 97.12,72.7
  BOTTOM w0.102: RC84.2 CC336.1 96.78,78.33 96.15,77.7 96.15,75.03 95.71,74.59 v2(95.71,74.34) 95.71,73.63 96.65,72.7 97.12,72.7
PROCHOT#_R1: length 2.5
  TOP w0.102: RE288.1 301.38,83.28 v2(301,82.9) 301,81.69 UE1.H13
PS_ID: length 344.3
  TOP w0.102: PR4.1 64.94,92.78 PR5.2 65.44,92.28 65.44,91.43 66.02,90.85 v2(66.02,90.16) 65.89,90.04 v1(65.89,89.67)
  TOP w0.107: v1(302.36,77.93) UE1.J8
  IN1 w0.089: v1(307.54,79.9) 306.52,79.9 304.92,78.3 304.14,78.3 303.32,77.49 302.8,77.49 v1(302.36,77.93)
  IN3 w0.122: v1(307.54,79.9) 308.69,78.75 308.69,75.2 308.06,74.57 308.06,67.5 308.64,66.92 308.64,65.96 307.02,64.34 307.02,63.72 306.08,62.77 306.08,62.02 303.4,59.34 303.4,53.73 301.07,51.4 301.07,50.73 300.55,50.22 298.62,50.22 297.29,48.89 295.99,48.89 295.26,48.15 295.26,46.79 292.32,43.85 292.32,42.6 291.49,41.77 291.49,40.34 291.32,40.16 290.69,40.16 290.4,39.88 289.63,39.88 285.88,36.13 285.88,35.63 282.9,32.64 282.9,31.68 279.51,28.29 261.02,28.29 258.78,26.05 250.06,26.05 249.07,25.06 245.77,25.06 240.93,20.21 233.11,20.21 229.5,16.59 221.34,16.59 221.19,16.44 217.71,16.44 216.66,17.49 215.21,17.49 214.82,17.88 210.63,17.88 207.62,20.89 206.59,20.89 203.81,23.68 200.2,23.68 191.83,32.05 188.13,32.05 185.36,34.82 184.35,34.82 177.09,42.07 177.09,43.36 172.79,47.67 172.79,48.8 163.15,58.44 160.51,58.44 157.15,61.79 157.15,63.52 156.77,63.9 156.77,72.89 154.26,75.4 154.26,78.55 153.37,79.44 153.37,84.04 150.78,86.63 149.08,86.63 147.33,88.38 133.64,88.38 133.35,88.1 129.33,88.1 128.96,87.74 121.67,87.74 120.61,88.79 109.07,88.79 108.63,89.22 101.49,89.22 100.27,90.44 98.25,90.44 98.13,90.56 98.13,90.57 97.64,91.05 95.64,91.05 92.24,87.65 88.46,87.65 86.58,89.53 72.23,89.53 71.32,90.44 68.46,90.44 67.29,89.28 66.28,89.28 v1(65.89,89.67)
PWM1_IA: length 29.5
  TOP w0.102: v1(64.9,52.28) 64.43,52.28 v2(64.22,52.49)
  TOP w0.203: v1(64.9,52.28) 65.09,52.28 65.79,51.58 PU602.12
  TOP w0.254: PR687.1 56.67,68.27 v1(56.55,68.14)
  IN2 w0.254: v1(64.9,52.28) 63.82,52.28 60.03,56.08 54.08,56.08 53.03,57.13 53.03,64.39 56.55,67.91 v1(56.55,68.14)
PWM2_IA: length 53.1
  TOP w0.203: PU602.13 65.6,51.18 65.03,51.76 64.29,51.76 63.48,52.57 63.48,54.91 62.11,56.28 v2(62.11,56.91) v1(62.11,57.59)
  IN3 w0.254: v1(62.11,57.59) 61.08,57.59 59.85,56.36 53.45,56.36 52.21,57.59 49.23,57.59 47.63,59.19 47.63,67.77 51.12,71.27 51.12,73.04 54.15,76.07 60.89,76.07 v1(61.57,75.38)
  BOTTOM w0.254: PR692.1 v1(61.57,75.38)
PWM_FAN1: length 79
  TOP w0.102: v1(291.06,40.63) 290.73,40.63 v3(290.33,41.04) 290.08,41.29 286.22,41.29 285.97,41.04 285.97,40.63 285.79,40.44 285.22,40.44 284.19,41.48 283.18,41.48 282.87,41.17 280.2,41.17 279.27,42.1 278.35,42.1 277.15,40.89 273.34,40.89 273.15,40.7 272.37,40.7 272.23,40.85 271.85,40.85 v1(271.47,40.47)
  TOP w0.107: v1(303.96,79.53) UE1.L10
  IN3 w0.122: v1(303.96,79.53) 304.11,79.67 306.72,79.67 308.21,78.18 308.21,75.58 307.62,74.99 307.62,68.03 306.68,67.1 306.68,66.36 306.79,66.26 306.79,65.31 306.57,65.1 306.57,63.9 305.63,62.96 305.63,62.2 302.32,58.89 302.32,54.73 298.72,51.13 298.72,50.64 297.19,49.11 295.9,49.11 295.03,48.25 295.03,46.88 292.1,43.94 292.1,42.69 291.06,41.66 v1(291.06,40.63)
  BOTTOM w0.102: JFAN1.2 269.84,40.58 RE48.2 270.5,40.47 v1(271.47,40.47)
PWM_GT: length 24.1
  TOP w0.203: v1(65.73,46.88) 65.78,46.83 67.03,46.83 67.36,47.16 PU602.22
  IN2 w0.254: v1(65.73,46.88) 65.47,46.88 65.22,47.14 65.22,47.77 65.41,47.96 65.41,51.39 65.47,51.45 65.47,52.72 65.22,52.98 63.76,52.98 60.13,56.61 55.1,56.61 v1(53.68,58.03)
  BOTTOM w0.102: v2(66.24,46.25) 65.73,46.75 v1(65.73,46.88)
  BOTTOM w0.254: PR664.1 v1(53.68,58.03)
PWM_SA: length 2.7
  BOTTOM w0.102: PR606.2 68.51,89.1 v2(68.92,89.5)
  BOTTOM w0.254: PU614.3 68.77,87.84 68.51,88.11 PR606.2
PWM_VSA: length 79.4
  TOP w0.203: PU602.30 70.56,46.95 v1(70.95,46.56)
  IN3 w0.254: v1(70.95,46.56) 70.95,45.37 69.86,44.28 63.7,44.28 59.82,48.15 57.85,48.15 57.16,48.85 57.16,50.82 51.63,56.34 48.65,56.34 46.49,58.5 46.49,68.28 49.79,71.58 49.79,73.36 58.23,81.81 59.09,81.81 62.13,84.85 65.98,84.85 69.42,88.3 v1(69.42,89.05)
  BOTTOM w0.102: v1(70.95,46.56) v2(70.95,45.03)
  BOTTOM w0.203: PR606.1 v1(69.42,89.05)
RD1_A_DE0: length 4.9
  TOP w0.102: UN4.6 260.83,45.76 RN38.1 258.83,43.76 RN25.2 257.96,43.15 v2(257.88,43.22)
RD1_A_DE1: length 4.5
  TOP w0.102: UN4.8 262.65,44.48 262.45,44.28 261.12,44.28 v2(260.74,43.9) RN26.2 RN39.1
RD1_A_EQ0: length 3.2
  TOP w0.102: RN42.2 RN179.1 262.19,50.55 v2(262.19,50.11) 262.23,50.11 262.65,49.69 UN4.23
RD1_A_EQ1: length 6.7
  TOP w0.102: UN4.22 263.15,52.96 v2(263.56,53.36) 263.56,53.56 263.05,54.07 RN176.1 RN43.2
RD1_A_EQ2: length 3.3
  TOP w0.102: RN174.1 RN44.2 v2(265.44,50.18) 264.65,49.4 UN4.19
RD1_B_DE0: length 3.5
  TOP w0.102: RN27.2 RN40.1 267.21,45.48 266.81,45.08 v2(266.54,45.08) 266.32,45.08 265.64,45.76 UN4.13
RD1_B_DE1: length 3.8
  TOP w0.102: RN41.1 RN28.2 261.69,43.45 v2(262.13,43.9) 262.63,43.9 263.15,44.42 UN4.9
RD1_B_EQ0: length 4.1
  TOP w0.102: v2(266.37,43.02) RN49.2 RN52.1 263.97,43.59 263.97,44.21 264.15,44.39 UN4.11
RD1_B_EQ1: length 3
  TOP w0.102: UN4.21 263.66,49.06 263.66,50.08 v2(263.58,50.16) 263.66,50.23 RN53.1 RN50.2
RD1_B_EQ2: length 3.2
  TOP w0.102: UN4.16 266.3,47.26 v2(266.55,47.52) RN51.2 RN54.1
RD1_REXT: length 2
  TOP w0.102: UN4.10 263.65,44.4 263.53,44.28 v2(263.53,43.9) 263.53,43.08 RN30.1
RD2_A_DE0: length 4.1
  TOP w0.102: v1(291.96,53.67) 291.9,53.61 291.5,53.61 291.39,53.72 UN5.6
  BOTTOM w0.102: RN55.2 RN59.1 292.28,51.97 292.28,52.95 292.18,53.05 292.18,53.45 v1(291.96,53.67)
RD2_A_DE1: length 4.9
  TOP w0.102: UN5.8 292.61,55.21 292.92,54.91 292.92,53.87 v2(293.35,53.43) 293.35,53.23 RN56.2 294.24,51.48 RN60.1
RD2_A_EQ0: length 77.5
  TOP w0.102: RN225.2 227.03,34.82 228.09,33.76 v2(228.09,32.12) v1(228.09,31.5) ; UN5.23 287.66,55.21 287.51,55.36 284.36,55.36 v1(283.9,55.82)
  IN3 w0.122: v1(283.9,55.82) 283.11,55.04 280.53,55.04 279.87,54.38 279.87,53.8 279.28,53.21 279.28,52.74 278.36,51.82 278.36,51.11 277.66,50.41 277.66,49.57 277.3,49.21 277.3,47.48 275.16,45.33 274.54,45.33 270.36,41.16 268.32,41.16 266.17,39.01 258.01,39.01 255.73,36.72 240.75,36.72 237.37,33.34 229.94,33.34 v1(228.09,31.5)
RD2_A_EQ0_R: length 3.5
  TOP w0.102: v2(225.23,36.81) RN63.2 ; RN63.2 RN225.1 ; RN63.2 224.21,35.83 QN5.3
RD2_A_EQ1: length 83
  TOP w0.102: v1(218.91,33.04) 219.17,33.29 RN224.2 ; UN5.22 v2(286.97,55.71) 286.32,55.71 286.15,55.89 284.51,55.89 284.26,56.14 v1(284.26,56.3)
  IN3 w0.122: v1(218.91,33.04) 219.27,32.68 225.2,32.68 226.17,33.65 237.29,33.65 240.59,36.95 255.64,36.95 257.95,39.26 266.1,39.26 268.24,41.4 269.25,41.4 271.94,44.09 272.92,44.09 274.32,45.48 274.32,46.07 274.85,46.61 275.82,46.61 277.08,47.87 277.08,49.31 277.44,49.67 277.44,50.5 278.14,51.21 278.14,51.91 279.06,52.83 279.06,53.3 279.65,53.89 279.65,54.48 280.43,55.26 282.55,55.26 283.59,56.3 v1(284.26,56.3)
RD2_A_EQ1_R: length 3.8
  TOP w0.102: v2(221.54,32.28) RN64.2 RN224.1 221.43,34.17 QN5.6
RD2_A_EQ2: length 96.6
  TOP w0.102: v1(284.1,57.5) 284.1,57.52 284.2,57.63 v2(286.77,57.63) 287.67,57.63 UN5.19 ; RN223.2 v1(208.09,32.39)
  IN3 w0.122: v1(284.1,57.5) 282.33,55.73 280.25,55.73 279.13,54.61 278.69,54.61 278.26,54.18 278.26,52.66 277.69,52.1 277.69,51.39 276.99,50.69 276.99,49.85 276.58,49.44 276.58,48 275.64,47.06 274.68,47.06 273.87,46.26 273.87,45.67 272.84,44.63 271.8,44.63 269.02,41.85 268,41.85 265.89,39.74 258.15,39.74 257.66,40.23 256.57,40.23 255.96,39.62 255.96,38.94 254.44,37.42 252.89,37.42 252.08,38.23 240.79,38.23 236.48,33.93 225.94,33.93 225.05,33.04 220.71,33.04 220.12,33.62 217.19,33.62 215.46,31.9 208.59,31.9 v1(208.09,32.39)
RD2_A_EQ2_R: length 3.7
  TOP w0.102: RN65.2 RN223.1 207.99,33.3 207.73,33.57 v2(207.73,34.04) 208.1,34.42 QN4.3
RD2_B_DE0: length 3.9
  TOP w0.102: UN5.13 291.39,58.35 291.98,58.95 v1(292.36,58.95) 292.75,59.34 v2(292.8,59.34)
  BOTTOM w0.102: RN61.1 RN57.2 292.28,59.02 v1(292.36,58.95)
RD2_B_DE1: length 3.9
  TOP w0.102: RN58.2 RN62.1 293.83,54.73 v2(293.35,54.73) 293.35,55.21 292.85,55.71 UN5.9
RD2_B_EQ0: length 3.3
  TOP w0.102: RN72.1 RN69.2 293.39,57.23 v2(293.35,57.27) 292.79,56.71 UN5.11
RD2_B_EQ1: length 4.2
  TOP w0.102: v2(285.83,56.29) 285.91,56.21 v1(286.53,56.21) UN5.21
  BOTTOM w0.102: v1(286.53,56.21) 286.91,56.6 RN70.2 RN73.1
RD2_B_EQ2: length 3.3
  TOP w0.102: v2(289.72,59.38) v1(289.72,58.82) 289.89,58.65 UN5.16
  BOTTOM w0.102: v1(289.72,58.82) 290.05,58.49 RN71.2 RN74.1
RD2_REXT: length 2.4
  TOP w0.102: UN5.10 293.14,56.21 v2(293.35,56) 293.81,55.54 294.04,55.54 RN31.1
RD5_A_DE0: length 3.6
  TOP w0.102: UZ36.6 284.66,62.25 RZ155.1 RZ154.2 v2(283.8,60.32)
RD5_A_DE1: length 4.1
  TOP w0.102: UZ36.8 286.55,61.52 286.26,61.23 v1(285.59,61.23) 285.59,60.99 285.3,60.7 v2(285.25,60.7)
  BOTTOM w0.102: v1(285.59,61.23) 285.15,60.78 RZ157.1 RZ156.2
RD5_A_EQ0: length 3.9
  TOP w0.102: v2(285.31,67.37) v1(285.31,66.82) 286.17,66.82 286.55,66.44 UZ36.23
  BOTTOM w0.102: RZ354.2 RZ355.1 285.31,67.38 v1(285.31,66.82)
RD5_A_EQ1: length 3.2
  TOP w0.102: UZ36.22 287.05,66.49 286.69,66.85 v1(286.69,66.93) v2(286.69,67.54)
  BOTTOM w0.102: RZ357.1 RZ356.2 286.69,67.28 v1(286.69,66.93)
RD5_A_EQ2: length 4.4
  TOP w0.102: UZ36.19 288.55,66.34 288.65,66.44 288.83,66.44 v1(289.13,66.13)
  BOTTOM w0.102: RZ359.1 RZ358.2 290.76,67.05 290.1,66.39 289.39,66.39 v1(289.13,66.13)
RD5_B_DE0: length 4.9
  TOP w0.102: UZ36.13 289.8,62.83 290.35,62.29 v1(291.45,62.29)
  BOTTOM w0.102: v2(290.91,62.07) 291.23,62.07 v1(291.45,62.29) 291.92,62.76 RZ158.2 RZ159.1
RD5_B_DE1: length 3.2
  TOP w0.102: UZ36.9 287.05,61.38 v1(286.91,61.24) 286.91,60.99 286.59,60.67 v2(286.54,60.67)
  BOTTOM w0.102: v1(286.91,61.24) 287.03,61.13 RZ160.2 RZ161.1
RD5_B_EQ0: length 3.7
  TOP w0.102: UZ36.11 288.05,61.61 288.65,61 v2(288.84,61) 289.13,61 v1(289.34,61.21)
  BOTTOM w0.102: v1(289.34,61.21) 289.72,60.83 RZ163.1 RZ162.2
RD5_B_EQ1: length 3.6
  TOP w0.102: UZ36.21 287.55,66.41 v1(288.07,66.93) v2(288.07,67.48)
  BOTTOM w0.102: RZ164.2 RZ165.1 288.25,66.93 v1(288.07,66.93)
RD5_B_EQ2: length 4.2
  TOP w0.102: v1(291.57,64.46) 291.49,64.53 291.09,64.53 290.89,64.33 UZ36.16
  BOTTOM w0.102: v1(291.57,64.46) 291.78,64.66 RZ167.1 RZ166.2
RD5_REXT: length 3.2
  TOP w0.102: UZ36.10 287.55,61.47 v1(287.79,61.23) 287.79,60.32 v2(287.76,60.29)
  BOTTOM w0.102: RZ348.1 288.18,61.23 v1(287.79,61.23)
RED: length 10.2
  BOTTOM w0.102: LV16.2 317.43,88.68 CV129.1 317.43,87.57 316.39,86.53 DV5.2 316.39,85.93 v2(318.27,85.93) 319.4,85.93 JCRT1.1
RED_CRT: length 87.9
  TOP w0.102: RV116.1 280.98,57.8 v2(280.8,57.8) 280.57,57.8 v1(280.12,57.35) 280.12,57.01 280.42,56.71 280.42,56.41 280.09,56.07 UV6.23
  IN2 w0.122: v1(316.74,90.43) 316.95,90.22 316.95,88.93 316.74,88.73 316.45,88.73 316.26,88.92 316.26,89.57 315.41,90.43 314.77,90.43 313.65,89.3 313.65,88.93 313.78,88.8 314.48,88.8 314.71,88.57 314.71,88.23 314.5,88.02 313.2,88.02 313.02,88.2 313.02,89.3 312.83,89.49 309.04,89.49 308.86,89.3 308.86,88.65 308.67,88.47 308.41,88.47 308.23,88.65 308.23,89.3 308.04,89.49 307.78,89.49 307.6,89.3 307.6,88.65 307.41,88.47 307.15,88.47 306.97,88.65 306.97,89.3 306.78,89.49 302.09,89.49 301.9,89.3 301.9,88.86 301.72,88.67 301.46,88.67 301.27,88.86 301.27,89.3 301.09,89.49 300.64,89.49 299.54,90.59 299.54,91 298.11,92.43 293,92.43 291.34,90.77 291.34,87.9 290.17,86.73 290.17,85.73 286.53,82.09 286.53,81.56 286.17,81.2 285.36,81.2 284.93,80.76 284.93,80.35 282.26,77.68 281.04,77.68 280.17,76.8 280.17,74.59 279.25,73.68 279.02,73.68 278.64,73.3 278.64,72.79 277.63,71.77 277.63,70.86 278.14,70.35 278.14,67.08 277.94,66.88 277.94,63.35 279.15,62.14 279.69,62.14 280.93,60.9 280.93,59.63 280.55,59.25 280.55,57.78 v1(280.12,57.35)
  BOTTOM w0.102: LV16.1 317.4,89.51 CV126.1 v1(316.74,90.43)
REM_DIODE1_N: length 256.8
  TOP w0.254: QE3.3 123.11,57.44 123.53,57.66 CE35.1 124.12,57.3 123.92,57.11 v1(123.49,57.11) ; v1(291.84,77.39) 291.92,77.31 292.61,77.31 CE24.1 v2(294.15,77.63) 295.46,77.63 UE1.A8
  IN1 w0.254: v1(284.73,42.94) 284.89,43.1 285.5,43.1 288.81,46.4 288.81,49.08 293.25,53.52 293.25,55.97 293.58,56.3 293.58,59.18 293.07,59.69 293.07,61.61 292.68,62.01 292.68,65.58 290.41,67.85 286.05,67.85 285.45,68.45 285.45,73.86 284.91,74.4 284.91,77.71 286.86,79.67 288.84,79.67 290.42,78.08 291.59,78.08 291.84,77.83 v1(291.84,77.39)
  IN2 w0.254: v1(123.49,57.11) 123.53,57.14 123.58,57.14 124.06,57.63 125.31,57.63 126.3,58.62 127.51,58.62 128.27,59.37 130.21,59.37 130.24,59.4 130.27,59.4 130.42,59.56 131.98,59.56 132.9,60.47 134.01,60.47 134.09,60.39 136.56,60.39 136.89,60.06 149.77,60.06 151.53,58.3 156.27,58.3 159.97,54.6 159.97,50.26 160.34,49.89 160.34,47.72 163.02,45.04 167.21,45.04 169.22,43.04 169.62,43.04 180.33,32.33 185.09,32.33 186.79,30.63 192.97,30.63 199.75,23.84 202.31,23.84 204.02,22.13 205.5,22.13 205.92,21.71 208.54,21.71 210.14,23.31 212.86,23.31 213.29,23.74 215.07,23.74 216.59,22.22 219.84,22.22 219.85,22.21 225.61,22.21 227.1,23.7 229.41,23.7 231.15,25.44 235.19,25.44 236.05,26.31 242.05,26.31 244.31,28.57 252.33,28.57 254.01,30.24 256.98,30.24 257.87,31.13 260.69,31.13 262.23,32.68 270.35,32.68 271.47,33.8 277.26,33.8 279.03,35.57 279.03,36.07 280,37.04 280,38.15 280.5,38.65 280.5,39.75 281.41,40.66 282.64,40.66 283.98,42 283.98,42.89 284.28,43.19 284.39,43.19 284.64,42.94 v1(284.73,42.94)
REM_DIODE1_P: length 260
  TOP w0.254: QE3.2 121.73,58.09 QE3.1 123.63,58.09 CE35.2 123.95,58.74 v1(123.37,58.74) ; UE1.A7 295.45,76.84 293.06,76.84 CE24.2 292.71,76.93 291.96,76.93 v1(291.84,76.8)
  IN1 w0.254: v1(284.72,43.57) 284.81,43.48 285.34,43.48 288.43,46.56 288.43,49.24 292.87,53.68 292.87,56.13 293.2,56.46 293.2,59.02 292.69,59.53 292.69,61.46 292.29,61.85 292.29,65.42 290.25,67.46 285.89,67.46 285.07,68.29 285.07,73.7 284.53,74.25 284.53,77.87 286.7,80.05 288.99,80.05 290.58,78.46 291.74,78.46 292.38,77.83 292.38,77.11 292.07,76.8 v1(291.84,76.8)
  IN2 w0.254: v1(123.37,58.74) 124.06,59.43 124.06,60.5 124.77,61.21 126.52,61.21 127.13,60.6 127.54,60.6 128.38,59.75 130.05,59.75 130.85,60.55 132.44,60.55 132.74,60.85 134.17,60.85 134.24,60.77 136.71,60.77 137.04,60.44 149.93,60.44 151.68,58.69 156.42,58.69 160.36,54.76 160.36,50.42 160.72,50.05 160.72,47.88 163.18,45.42 167.37,45.42 169.38,43.42 169.78,43.42 180.49,32.71 185.25,32.71 186.95,31.01 193.13,31.01 199.91,24.22 202.47,24.22 204.18,22.51 205.65,22.51 206.08,22.09 208.38,22.09 209.98,23.69 212.7,23.69 213.13,24.12 215.22,24.12 216.75,22.6 220,22.6 220.01,22.59 225.45,22.59 226.95,24.08 229.25,24.08 230.99,25.82 235.03,25.82 235.89,26.69 241.89,26.69 244.15,28.95 252.18,28.95 253.85,30.63 256.82,30.63 257.71,31.51 260.53,31.51 262.08,33.06 270.2,33.06 271.32,34.18 277.1,34.18 278.64,35.73 278.64,36.23 279.61,37.2 279.61,38.31 280.12,38.81 280.12,39.91 281.25,41.04 282.48,41.04 283.6,42.16 283.6,43.05 284.13,43.57 v1(284.72,43.57)
REM_DIODE2_N: length 264
  TOP w0.254: v1(289.76,82.1) 289.72,82.06 289.72,80.16 290.81,79.07 291.89,79.07 CE26.1 292.22,78.9 295.34,78.9 UE1.A10
  IN1 w0.254: v1(185.74,15.46) 185.78,15.46 185.91,15.59 185.91,16.02 186.39,16.5 187.89,16.5 189.24,15.15 189.24,13.97 194.03,9.19 198.92,9.19 199.31,8.79 205.77,8.79 206.07,8.49 209.32,8.49 210.1,7.72 211.79,7.72 213.22,9.14 217.91,9.14 218.39,8.67 220.77,8.67 221.17,9.08 228.92,9.08 229.73,9.88 236.6,9.88 238.42,11.7 238.42,15.64 238.78,16 v1(239.57,16)
  IN4 w0.254: v1(252.33,30.34) 252.35,30.32 252.96,30.32 254.59,31.95 254.59,33.9 263.64,42.94 264.98,42.94 265.46,43.43 265.46,44.04 267.04,45.61 267.04,46.82 270.19,49.98 271.54,49.98 272.51,50.95 273.1,50.95 273.45,51.3 275.45,51.3 276.07,51.92 276.07,52.86 275.52,53.41 275.52,54.37 277.51,56.37 277.51,58.19 278.03,58.7 278.03,60.1 275.66,62.46 275.66,65.4 275.11,65.95 275.11,68.06 273.71,69.46 273.71,79.53 274.94,80.75 275.35,80.75 276.27,81.67 276.27,82.34 277,83.06 281.55,83.06 282.2,82.41 284.55,82.41 285.31,83.18 287.07,83.18 287.15,83.1 289.09,83.1 289.68,82.51 289.68,82.18 v1(289.76,82.1)
  BOTTOM w0.254: QE7.1 112.39,8.92 112.39,10.17 ; QE5.3 239.8,11.76 CE37.2 239.6,15.96 v1(239.57,16) 239.57,16.89 252.25,29.58 252.25,30.26 v1(252.33,30.34) ; 112.39,10.17 112.39,10.95 CE46.2 112.96,11.52 112.96,13.36 115.82,16.22 150.47,16.22 151.11,16.87 170.98,16.87 172.03,15.82 176.38,15.82 177.24,14.96 185.61,14.96 185.74,15.09 v1(185.74,15.46) ; 112.39,10.17 QE7.2
REM_DIODE2_P: length 263.4
  TOP w0.254: UE1.A9 295.49,78.4 292.14,78.4 CE26.2 291.66,78.56 290.59,78.56 289.21,79.94 289.21,82.06 v1(289.17,82.1)
  IN1 w0.254: v1(186.52,15.45) 186.42,15.55 186.42,15.81 186.6,15.99 187.68,15.99 188.74,14.94 188.74,13.76 188.96,13.54 193.81,8.68 198.7,8.68 199.1,8.28 205.56,8.28 205.86,7.99 209.11,7.99 209.88,7.21 212,7.21 213.43,8.64 217.7,8.64 218.18,8.16 220.98,8.16 221.38,8.57 229.13,8.57 229.94,9.37 236.82,9.37 238.93,11.49 v1(238.93,15.41)
  IN4 w0.254: v1(289.17,82.1) 289.17,82.3 288.88,82.59 286.94,82.59 286.86,82.67 285.52,82.67 284.76,81.91 281.99,81.91 281.34,82.56 277.21,82.56 276.78,82.13 276.78,81.46 275.56,80.24 275.15,80.24 274.22,79.31 274.22,69.67 275.62,68.27 275.62,66.16 276.17,65.61 276.17,62.67 278.53,60.31 278.53,58.49 278.02,57.97 278.02,56.16 276.02,54.16 276.02,53.62 276.57,53.08 276.57,51.71 275.66,50.79 273.66,50.79 273.31,50.44 272.72,50.44 271.75,49.47 270.4,49.47 267.54,46.61 267.54,45.4 265.97,43.83 265.97,43.22 265.19,42.44 263.85,42.44 255.1,33.69 255.1,31.74 253.17,29.81 252.14,29.81 251.75,30.21 v1(251.75,30.34)
  BOTTOM w0.254: QE7.3 113.67,10.19 CE46.1 113.47,11.52 113.47,13.15 116.03,15.72 150.68,15.72 151.32,16.36 170.77,16.36 171.82,15.32 176.17,15.32 177.03,14.46 185.82,14.46 186.25,14.88 186.25,15.18 v1(186.52,15.45) ; v1(251.75,30.34) 251.75,29.79 238.93,16.97 v1(238.93,15.41) 238.89,15.37 238.89,12.16 CE37.1 238.5,11.76 QE5.2 238.5,9.62 QE5.1
REM_DIODE4_N: length 306.3
  TOP w0.254: v1(81.07,31.12) 81.03,31.16 81.03,33.42 79.63,34.82 79.63,42.65 78.94,43.35 78.94,45.41 CE39.1 79.4,45.87 QE6.3 ; v1(291.13,80.58) 291.27,80.44 292.82,80.44 CE27.1 294.76,80.55 295.38,79.93 UE1.A11
  IN1 w0.254: v1(241.01,15.56) 241.01,14.84 240.66,14.49 240.66,11.12 235.93,6.39 224.8,6.39 223.37,4.95 210.24,4.95 208.48,6.71 205.81,6.71 205.37,6.27 202.37,6.27 201.92,6.71 196.97,6.71 196.37,7.31 192.02,7.31 188.55,10.78 188.55,11.06 187.12,12.49 186.31,12.49 181.87,16.93 v1(181.87,19.07)
  IN4 w0.254: v1(291.13,80.58) 290.35,81.35 287.03,81.35 285.98,80.3 284.1,80.3 283.76,80.65 277.04,80.65 275.84,79.44 275.84,77.81 275.54,77.51 275.54,76.12 275.44,76.01 275.44,73.6 275.03,73.18 275.03,70.31 278.01,67.33 278.01,63.25 280.28,60.98 280.28,60.71 281.24,59.75 281.24,57.75 281.9,57.09 281.9,56.28 281.25,55.63 279.81,55.63 279.33,55.16 278.46,55.16 277.58,54.28 277.58,51.15 274.55,48.12 270.86,48.12 268.33,45.59 268.33,45.02 266.73,43.42 266.73,42.9 265.48,41.65 264.14,41.65 257.94,35.46 257.94,33.43 253.52,29.01 253.52,28.8 v1(253.45,28.72)
  BOTTOM w0.254: v1(253.45,28.72) 253.45,28.27 251.7,26.52 251.04,26.52 241.05,16.53 241.05,15.8 241.01,15.77 v1(241.01,15.56) ; v1(181.87,19.07) 177.84,19.07 176.86,20.05 132.12,20.05 123.13,29.04 83.08,29.04 81.07,31.05 v1(81.07,31.12)
REM_DIODE4_P: length 309.4
  TOP w0.127: 295.09,79.48 296.01,79.48 UE1.B10
  TOP w0.254: QE6.1 78.09,48.01 QE6.2 78.09,45.74 CE39.2 78.43,45.41 78.43,43.13 79.13,42.44 79.13,34.61 80.52,33.21 80.52,31.43 80.48,31.39 v1(80.48,31.12) ; 295.09,79.48 294.82,79.76 293.05,79.76 CE27.2 292.65,79.92 291.05,79.92 290.59,80.38 v1(290.46,80.38)
  IN1 w0.254: v1(241.6,15.77) 241.24,16.13 240.69,16.13 240.44,15.87 240.44,14.98 240.16,14.7 240.16,11.33 235.72,6.9 224.59,6.9 223.16,5.46 210.45,5.46 208.7,7.22 205.6,7.22 205.16,6.77 202.58,6.77 202.13,7.22 197.18,7.22 196.58,7.82 192.23,7.82 189.06,10.99 189.06,11.27 187.33,13 186.52,13 182.38,17.14 182.38,18.43 v1(182.5,18.56)
  IN4 w0.254: v1(254.03,28.72) 254.03,28.8 258.45,33.22 258.45,35.24 264.35,41.14 265.69,41.14 267.24,42.69 267.24,43.2 268.84,44.81 268.84,45.38 271.07,47.61 274.76,47.61 278.09,50.94 278.09,54.07 278.67,54.65 279.54,54.65 280.02,55.12 281.46,55.12 282.41,56.07 282.41,57.3 281.75,57.96 281.75,59.96 280.79,60.92 280.79,61.19 278.52,63.46 278.52,67.54 275.54,70.52 275.54,72.97 275.95,73.39 275.95,75.8 276.05,75.91 276.05,77.3 276.34,77.6 276.34,79.23 277.25,80.14 283.55,80.14 283.89,79.79 286.19,79.79 287.24,80.84 290.14,80.84 290.46,80.52 v1(290.46,80.38)
  BOTTOM w0.254: v1(182.5,18.56) 177.63,18.56 176.65,19.54 131.91,19.54 122.92,28.53 82.87,28.53 80.48,30.92 v1(80.48,31.12) ; v1(254.03,28.72) 254.03,28.13 251.91,26.02 251.25,26.02 241.56,16.32 241.56,15.8 v1(241.6,15.77)
RES_BIAS: length 2.7
  TOP w0.102: RL13.1 283.01,89.35 v2(282.35,88.68) 281.48,87.82 UL1.12
RESET_IN#: length 5.5
  TOP w0.102: UE1.C1 297.16,71.6 296.96,71.39 v2(296.96,70.53) 296.96,69.82 297.13,69.64 RE362.1 RE361.1
RESET_OUT: length 6.9
  TOP w0.102: RE548.2 301.95,69.27 v1(302.09,69.41) ; v1(299.96,73.93) UE1.G4
  IN1 w0.089: v1(302.09,69.41) 302.09,69.57 302.31,69.79 302.31,70.79 300.88,72.22 300.88,73.12 300.08,73.93 v1(299.96,73.93)
RESET_OUT#_R: length 9.5
  TOP w0.102: v2(61.68,42.49) 61.85,42.31 61.85,41.15 RC129.2 RC128.2 61.35,40.16 61.86,39.65 61.86,38.86 CC33.1 62.36,37.71 62.91,37.16 63.68,37.16 63.95,36.89 JXDP1.47
RING2: length 9.3
  IN1 w1.27: 302.27,32.21 303.75,33.7 306.27,33.7 307.28,34.71 307.28,37.1 307.92,37.74
  vias: v1(298.14,30.94) v1(298.58,30.56) v1(298.71,31.2) v1(308.07,39.45) v1(308.55,38.82) v1(308.65,39.45) v2(308.32,38.19)
RING2_R:
  vias: v1(311.54,41.04) v1(311.85,41.55) v1(312.17,41.04) v3(317.89,40.15)
RJ45_MDIN0: length 8
  IN4 w0.241: v1(291.49,103.2) 291.37,103.33 291.37,103.61 290.85,104.12 290.85,104.94 291.52,105.61 292.43,105.61 293.09,106.27 293.81,106.27 JLOM1.2
  BOTTOM w0.229: v1(291.49,103.2) 291.39,103.1 291.39,102.49 291.71,102.17 TL1.14
RJ45_MDIN1: length 7.1
  IN1 w0.241: JLOM1.6 297.4,106.08 296.51,105.18 296.51,104.84 297.43,103.92 297.43,103.73 v1(297.79,103.36)
  BOTTOM w0.229: v1(297.79,103.36) 297.5,103.36 297.24,103.11 297.24,102.71 297.71,102.25 TL1.20
RJ45_MDIN2: length 8.3
  IN4 w0.241: JLOM1.5 297.06,106.02 297.19,105.88 297.19,105.09 296.63,104.52 295.12,104.52 294.68,104.09 v1(294.68,103.36)
  BOTTOM w0.229: v1(294.68,103.36) 294.38,103.06 294.38,102.66 294.71,102.34 TL1.17
RJ45_MDIN3: length 6.6
  IN4 w0.241: JLOM1.8 300.05,106.15 299.6,106.15 299.37,105.92 299.37,104.94 300.05,104.27 300.05,103.6 300.35,103.3 v1(300.63,103.3)
  BOTTOM w0.229: TL1.23 300.71,102.27 300.31,102.66 300.31,102.98 v1(300.63,103.3)
RJ45_MDIP0: length 8.1
  IN4 w0.241: v1(290.9,103.2) 290.97,103.27 290.97,103.44 290.46,103.96 290.46,105.11 291.36,106.01 292.27,106.01 292.98,106.72 JLOM1.1
  BOTTOM w0.229: TL1.13 290.71,102.23 291.03,102.55 291.03,103.08 v1(290.9,103.2)
RJ45_MDIP1: length 7.1
  IN1 w0.241: v1(296.68,103.36) 296.96,103.64 296.96,103.83 295.02,105.77 JLOM1.3
  BOTTOM w0.229: v1(296.68,103.36) 296.9,103.14 296.9,102.38 296.71,102.19 TL1.19
RJ45_MDIP2: length 8.3
  IN4 w0.241: v1(293.6,103.52) 294,103.52 294.29,103.81 294.29,104.26 294.95,104.92 296.47,104.92 296.8,105.25 296.8,105.72 296.44,106.08 JLOM1.4
  BOTTOM w0.229: TL1.16 293.71,102.42 294.04,102.76 294.04,103.07 v1(293.6,103.52)
RJ45_MDIP3: length 6.6
  IN4 w0.241: JLOM1.7 299.1,106.21 298.98,106.08 298.98,104.78 299.65,104.1 299.65,103.31 v1(299.67,103.29)
  BOTTOM w0.229: v1(299.67,103.29) 299.97,103 299.97,102.57 299.71,102.31 TL1.22
RTCRST_ON: length 29.3
  TOP w0.102: v1(291.34,83.27) 289.12,83.27 286.69,80.84 284.28,80.84 283.82,80.38 283.82,78.22 284.23,77.82 286.09,77.82 286.47,78.2 287.25,78.2 RE565.2 287.76,77.26 287.71,77.21 RE93.1 287.93,76.94 288.17,76.7 288.17,76.22 v2(288.65,75.74) 288.35,75.43 287.96,75.43 287.8,75.27 QE12.2 ; UE1.F11 299.15,80.33 299.15,81.13 v1(299.14,81.15)
  IN4 w0.089: v1(291.34,83.27) 291.97,82.64 294.97,82.64 296.47,81.15 v1(299.14,81.15)
RTCRST_ON_R: length 4.8
  TOP w0.102: DE2.2 317.47,62.82 CE65.1 ; RE543.1 316.68,62.81 CE65.1 ; CE65.1 316.6,62.91 QE17.2 316.16,64.41 v2(315.27,64.41)
RTD3_CIO_PWR_EN: length 6.6
  TOP w0.102: T18.1 134.37,56.48 137.65,56.48 v1(137.97,56.8)
  BOTTOM w0.076: v1(137.97,56.8) 137.83,56.66 136.62,56.66 136.49,56.79 UC1.AC2
RUN_ON: length 436.9
  TOP w0.102: RE280.2 RE292.1 303.1,96.54 302.32,96.54 302.21,96.43 302.21,95.35 302.46,95.11 302.46,93.79 302.72,93.52 302.72,93.21 302.71,93.19 302.71,92.54 303.21,92.04 303.35,92.04 303.52,92.21 UE5.4 303.52,93.44 303.09,93.87 303.09,94.44 v1(302.95,94.58) ; v1(185.68,30.37) 188.47,33.17 188.47,37.15 187.97,37.66 187.97,37.8 188.03,37.87 v1(188.03,37.94) ; RZ345.1 268.25,53.36 v1(268.13,53.49) ; v1(157.92,87.24) v2(157.92,85.36) v1(157.92,79.22) ; UZ3.5 201.14,7.21 200.86,6.92 198.36,6.92 197.69,7.59 196.97,7.59 195.13,9.44 195.13,10.48 v1(195.52,10.87) ; UZ4.3 190.03,16.93 v1(189.82,17.14) ; v1(297.69,61.27) 297.57,61.39 QE2.2
  TOP w0.254: v1(136.29,109.85) 136.29,109.85 136.56,110.12 PR402.1
  IN1 w0.089: v1(189.82,17.14) 190.36,17.14 195.74,11.75 195.74,11.09 v1(195.52,10.87) ; v1(157.92,87.24) 157.92,90.29 148.02,100.19 142.03,100.19 140.76,101.47 138.85,101.47 136.24,104.07 136.24,106.56 135.88,106.92 135.88,109.45 v1(136.29,109.85) ; v1(157.92,79.22) 157.31,79.82 155.12,79.82 155,79.7 153.44,79.7 147.97,85.17 142.71,85.17 138.59,81.04 136.09,81.04 135.7,80.66 133.23,80.66 v1(132.72,80.16)
  IN3 w0.102: v1(134.43,83.58) 132.72,81.87 v1(132.72,80.16)
  IN3 w0.122: v1(157.92,79.22) 157.92,76.93 159.67,75.18 159.67,69.11 162.03,66.74 162.03,61.91 181.65,42.28 184.88,42.28 187.91,39.25 187.91,38.05 v1(188.03,37.94) 188.21,37.94 188.84,37.31 191.78,37.31 199.7,29.39 199.87,29.39 200.06,29.2 202.6,29.2 205,26.8 207.02,26.8 208.99,24.83 209.82,24.83 211.23,23.43 212.9,23.43 213.37,23.89 215.59,23.89 215.91,23.58 221.13,23.58 222.8,21.91 224.42,21.91 225.33,21 229.8,21 231.91,23.11 239.36,23.11 244.23,27.98 248.04,27.98 249.54,29.48 252.69,29.48 253.12,29.9 258.32,29.9 v1(259.06,30.65) 259.73,31.31 277.86,31.31 281.26,34.71 281.65,34.71 283.3,36.37 283.3,39.19 284.01,39.9 285.64,39.9 286.75,41.01 286.75,43.27 289.5,46.02 291.32,46.02 292.03,46.72 292.03,47.42 291.8,47.66 291.8,48.41 294.82,51.43 294.82,51.92 295.14,52.24 295.14,53.13 295.63,53.62 296.31,53.62 297.69,54.99 v1(297.69,61.27)
  IN4 w0.089: v1(302.95,94.58) 309.04,94.58 314.18,89.45 314.18,86.52 319.58,81.12 319.58,65.77 316.56,62.76 315.73,62.76 313.96,60.99 311.92,60.99 309.52,58.58 308.17,58.58 307.75,59 307.75,60.2 306.96,60.98 305.86,60.98 304.93,60.05 303.99,60.05 303.74,59.8 v1(300.6,59.8)
  BOTTOM w0.102: 136.28,83.05 136.12,82.89 135.13,82.89 v1(134.43,83.58) ; v1(259.06,30.65) 255.91,33.8 255.91,39.69 258.64,42.42 258.64,48.47 259.9,49.73 261.82,49.73 262.58,48.98 264.69,48.98 266.39,50.68 266.39,52.66 267.34,53.61 268,53.61 v1(268.13,53.49) ; v1(132.72,80.16) 132.59,80.03 RZ320.1 ; v1(189.82,17.14) 189.82,23.46 189.46,23.82 188.9,23.82 187.53,25.2 187.53,28.52 v1(185.68,30.37) ; v1(300.6,59.8) 300.19,60.22 298.74,60.22 v1(297.69,61.27)
RUN_ON#: length 34.9
  TOP w0.102: v1(316.26,68.8) 316.26,68.96 QZ4.2 317.12,69.16 317.12,68.8 317.35,68.57 v2(317.35,68.34) ; v1(299.76,58.9) 299.72,58.95 RE68.1 297.64,59.06 298.22,59.63 QE2.6 298.22,60.29 298.11,60.39 297.75,60.39 297.57,60.21 QE2.5
  IN4 w0.089: v1(299.76,58.9) 299.69,58.9 299.37,59.23 299.37,59.92 300.19,60.74 303.31,60.74 303.56,60.99 304.28,60.99 306.68,63.39 306.68,64.62 307.6,65.53 307.6,67 307.09,67.51 306.91,67.51 306.56,67.86 306.56,68.8 308.86,71.1 312.22,71.1 314.52,68.8 v1(316.26,68.8)
RUN_ON_1.8V: length 3.6
  TOP w0.102: v2(269.15,52.41) 269.7,52.95 RZ345.2 CZ197.1 270.65,53.31 UZ8.3
RUN_ON_EC: length 32
  TOP w0.102: RPE10.4 308.48,88.07 v1(308.58,87.97) 308.98,87.97 v2(309.4,87.55) ; v1(304.17,93.8) UE5.2 304.17,95.17 303.87,95.47 303.26,95.47 RE292.2
  TOP w0.112: v1(298.38,77.9) UE1.E8
  IN4 w0.089: v1(304.17,93.8) 304.37,94 305.27,94 308.58,90.7 v1(308.58,87.97) 307.22,86.61 307.22,83.96 305.29,82.03 305.29,80.16 304.42,79.29 304.42,78.51 304.23,78.33 301.25,78.33 300.41,77.49 298.8,77.49 v1(298.38,77.9)
RUNPWROK: length 330.7
  TOP w0.102: UC8.4 v1(53.22,34.65) ; UC8.1 55.68,32.79 56.01,33.12 v2(56.52,33.12) 57.1,33.12 57.48,32.74 57.48,31.36 57.1,30.98 55.09,30.98 v1(54.65,30.54) 54.22,30.97 UC8.13 ; RE67.1 297.06,62.07 QE2.3 296.92,61.47 297.79,60.6 298.73,60.6 v1(299.81,59.51) ; UC8.10 v1(52.72,30.42)
  TOP w0.107: v1(299.96,73.13) UE1.G3
  IN1 w0.089: v1(187.03,26.93) 187.72,27.62 193.93,27.62 200.58,20.97 202.68,20.97 204.09,19.56 210.75,19.56 211.34,18.97 214.34,18.97 215.03,19.66 218.29,19.66 218.65,19.3 220.22,19.3 221.07,20.15 228.63,20.15 232.99,24.51 238.3,24.51 240.5,26.71 250.12,26.71 254.56,31.15 257.95,31.15 258.68,31.87 283.24,31.87 285.64,34.26 285.64,35.2 288.16,37.73 288.16,38.34 289.06,39.24 289.06,40.1 289.78,40.82 290.66,40.82 292.4,42.56 292.4,43.43 296.32,47.35 296.85,47.35 297.37,47.88 297.37,48.54 298.91,50.08 300.41,50.08 301.2,50.88 301.2,54.27 300.89,54.59 300.89,55.44 300.46,55.87 300.14,55.87 300.14,59.19 v1(299.81,59.51) 299.81,60.05 300.99,61.22 300.99,63.01 300.24,63.76 300.24,67.03 299.33,67.94 299.33,68.73 299.15,68.91 299.15,72.31 v1(299.96,73.13)
  BOTTOM w0.102: v1(53.22,34.65) 53.22,34.22 50.81,31.81 50.81,30.18 51.15,29.83 52.13,29.83 v1(52.72,30.42) 52.83,30.54 v1(54.65,30.54) 56.56,30.54 60.52,26.59 65.64,26.59 66.07,26.15 79.25,26.15 79.58,26.48 123.14,26.48 131,18.63 176.22,18.63 177.91,16.93 183.66,16.93 184.03,17.3 184.03,23.77 187.03,26.77 v1(187.03,26.93)
SA_LGATE: length 3.3
  TOP w0.102: v2(69.5,83.63) 69.66,83.8 v1(69.66,84.35)
  IN1 w0.508: v1(69.66,84.35) 70.24,84.35 70.68,84.79 71.76,84.79 v1(71.95,84.6)
SA_SNUB: length 3.4
  TOP w0.102: v2(74.71,87.78) 74.3,87.37 PR627.2
  TOP w0.508: PR627.2 73.54,86.06 PC622.1
SA_SW: length 12
  TOP w0.102: PR627.1 v2(76.97,87.8)
  TOP w0.508: PR627.1 v1(75.51,86.06)
  IN1 w0.508: v1(67.32,84.47) 68.08,84.47 69.16,85.55 70.05,85.55 70.55,86.06 v1(75.51,86.06)
SA_UGATE: length 6.4
  TOP w0.102: v1(71.93,87.9) v2(73.08,87.9)
  IN4 w0.508: v1(67.19,87.08) 69.03,87.08 70.05,88.09 71.73,88.09 v1(71.93,87.9)
SATA_PRX_C_DTX_N0: length 3.1
  BOTTOM w0.094: CN6.1 272.68,36.9 273.14,36.44 273.14,36.31 273.35,36.1 273.65,36.1 274.06,35.69 274.06,35.5 273.9,35.34 JSATA1.5
SATA_PRX_C_DTX_P0: length 3.1
  BOTTOM w0.094: CN7.1 273.32,36.53 273.32,36.39 273.43,36.28 273.73,36.28 274.24,35.77 274.24,35.5 274.4,35.34 JSATA1.6
SATA_PRX_C_RD_DTX_N0: length 3.6
  TOP w0.094: UN7.4 276.63,65.84 276.51,65.97 276.51,66.15 276.9,66.54 276.9,66.55 276.97,66.62 277.93,66.62 278.19,66.87 278.19,66.92 CN14.2
SATA_PRX_C_RD_DTX_P0: length 3.6
  TOP w0.094: UN7.5 276.14,65.79 276.32,65.97 276.32,66.23 v4(276.54,66.46) 276.89,66.8 277.86,66.8 277.98,66.93 277.98,67.17 277.78,67.38 CN15.2
SATA_PRX_DTX_N0: length 227.9
  TOP w0.094: CN14.1 278.36,68.57 278.36,68.98 279.01,69.63 v4(281.81,69.63) 283.33,69.63 283.45,69.51 283.45,69.18 283.36,69.08 v1(283.26,69.08)
  IN2 w0.122: v1(283.26,69.08) 283.44,69.26 283.44,69.47 283.7,69.73 284.2,69.73 285.04,68.89 285.04,68.32 286.09,67.27 286.09,66.87 286.9,66.05 288.52,66.05 289.11,65.47 289.11,62.45 288.63,61.97 288.63,60.85 287.15,59.38 287.15,57.67 287.36,57.47 287.36,56.08 284.13,52.86 284.13,52.65 280.84,49.35 279.54,49.35 279,48.82 277.82,48.82 277.43,48.43 277.43,47.93 275.7,46.2 274.78,46.2 273.39,44.82 271.75,44.82 270.69,43.76 269.32,43.76 268.56,42.99 268.56,41.9 267.7,41.04 264.95,41.04 263.89,39.97 260.28,39.97 259.06,38.75 258.55,38.75 257.15,37.35 254.94,37.35 254,36.41 245.82,36.41 244.81,35.4 243.92,35.4 243.31,34.79 240.87,34.79 238.94,32.86 226.34,32.86 225.73,32.25 220.75,32.25 218.1,29.6 214.85,29.6 213.6,30.85 200.44,30.85 189.14,42.15 180.04,42.15 169.54,52.66 169.54,58.57 166.69,61.42 166.69,65.07 160.11,71.65 147.6,71.65 147.05,71.1 142.4,71.1 140.92,72.59 128.45,72.59 128.2,72.34 128.2,70.11 126.62,68.54 126.62,67.13 126.3,66.81 v1(126.12,66.58)
  BOTTOM w0.076: UC1.F20 v1(126.12,66.58)
