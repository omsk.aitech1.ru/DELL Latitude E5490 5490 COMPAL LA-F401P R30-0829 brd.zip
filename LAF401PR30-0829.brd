# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW2_DP1_CADET: length 4.5
  TOP w0.102: UV7.43 100.8,98.54 100.64,98.7 100.64,99.1 100.8,99.26 100.8,100.27 v1(100.64,100.42)
  BOTTOM w0.102: RV73.1 99.7,101.36 v1(100.64,100.42)
SW2_DP1_HPD: length 120.6
  TOP w0.102: RT380.1 17.96,92.16 v1(18.32,92.16) 18.67,92.51 v2(18.67,92.6) ; v1(98.53,99.33) 98.53,98.9 98.8,98.64 UV7.48 ; RT73.2 v1(35.5,74.44)
  IN2 w0.122: v1(35.5,74.44) 36.38,74.44 36.89,74.95 36.89,77.74 35.18,79.44 35.18,82.63 36.38,83.83 36.38,84.63 37.24,85.49 41.05,85.49 44.48,88.92 47.5,88.92 48.74,90.16 53.35,90.16 54.51,91.31 59.58,91.31 60.6,92.34 64,92.34 64.76,93.1 66.92,93.1 68.08,94.25 73.03,94.25 73.92,93.36 81.16,93.36 87.31,99.51 94.06,99.51 95.32,98.25 98.01,98.25 98.53,98.77 v1(98.53,99.33)
  IN4 w0.089: v1(18.32,92.16) 18.05,91.89 18.05,86.67 18.88,85.84 21.18,85.84 21.66,85.36 21.66,83.57 23.9,81.32 26.47,81.32 27.36,82.21 30.08,82.21 30.56,81.73 30.56,79.74 30.08,79.25 30.08,75.76 30.84,75 34.94,75 v1(35.5,74.44)
SW2_DP1_HPD_R: length 5.5
  TOP w0.076: 33.9,77.09 33.9,77.22 34.02,77.34 34.02,77.76 33.9,77.89 33.9,78.32 34.11,78.54 UT5.C10
  TOP w0.102: 33.9,77.09 33.9,76.94 34.36,76.47 35.07,76.47 RT73.1 35.72,76.04 35.86,75.9 35.86,75.69 35.91,75.63 36.37,75.18 36.38,75.18 v2(36.63,74.92)
SW2_DP1_N0: length 96.9
  TOP w0.094: v1(97.29,99.25) 97.49,99.05 97.98,99.05 98.29,98.75 98.29,98.46 98.4,98.35 UV7.49
  IN1 w0.089: v1(27.23,97.57) 27.23,97.59 26.84,97.97 26.4,97.97 25.97,97.55 25.97,92.21 26.75,91.43 29.34,91.43 29.75,91.03 35.01,91.03 46.58,79.46 54.23,79.46 57.35,82.57 57.35,83.27 64.46,90.38 66.87,90.38 69.28,92.79 69.96,92.79 77.32,100.16 86.49,100.16 87.15,99.5 94.25,99.5 94.72,99.97 95.81,99.97 96.77,99 97.04,99 v1(97.29,99.25)
  BOTTOM w0.094: CT104.1 26.24,97.63 26.6,97.99 26.68,97.99 26.87,97.8 26.99,97.8 v1(27.23,97.57)
SW2_DP1_N0_C: length 3.2
  BOTTOM w0.094: UT9.10 23.61,96.56 23.72,96.67 23.89,96.67 24.26,97.04 v4(24.26,97.4) 24.26,97.62 24.62,97.98 24.9,97.98 CT104.2
SW2_DP1_N1: length 98.7
  TOP w0.094: v1(99.69,99.03) 99.49,98.83 99.49,98.48 99.6,98.37 UV7.46
  IN1 w0.089: v1(99.69,99.03) 99.49,99.23 99.49,99.47 98.94,100.02 96.88,100.02 94.75,102.15 76.3,102.15 73.16,99.01 73.16,96.8 69.84,93.49 69.16,93.49 66.62,90.96 64.17,90.96 53.3,80.09 46.75,80.09 35.23,91.61 30.08,91.61 29.54,92.15 27.12,92.15 26.71,92.55 26.71,95.53 27.13,95.95 28.15,95.95 v1(28.36,95.74)
  BOTTOM w0.094: CT106.1 26.24,95.85 26.37,95.98 28.12,95.98 v1(28.36,95.74)
SW2_DP1_N1_C: length 2.5
  BOTTOM w0.094: CT106.2 24.91,95.94 24.84,95.94 24.37,95.47 23.84,95.47 23.73,95.36 UT9.13
SW2_DP1_N2: length 95.4
  TOP w0.094: v1(100.38,99.79) 100.18,99.59 100.18,99.43 100.29,99.33 100.29,98.46 100.4,98.36 UV7.44
  IN1 w0.089: v1(100.38,99.79) 100.18,99.99 100.18,100.4 97.82,102.76 76.08,102.76 72.46,99.14 72.46,96.95 69.63,94.13 68.97,94.13 66.37,91.53 63.74,91.53 52.94,80.73 46.93,80.73 35.47,92.19 30.61,92.19 29.95,92.85 28.31,92.85 27.83,93.32 27.83,93.83 27.93,93.93 28.13,93.93 v1(28.35,93.71)
  BOTTOM w0.094: CT108.1 26.24,93.81 26.38,93.94 26.85,93.94 26.86,93.94 27.58,93.94 27.59,93.94 28.11,93.94 v1(28.35,93.71)
SW2_DP1_N2_C: length 2.4
  BOTTOM w0.094: CT108.2 24.92,93.9 24.58,93.9 v4(24.42,94.06) 24.23,94.25 23.76,94.25 23.68,94.16 UT9.16
SW2_DP1_N3: length 94
  TOP w0.094: v1(101.68,98.85) 101.49,98.66 101.49,98.48 101.6,98.38 UV7.41
  IN1 w0.089: v1(27.61,89.67) 27.77,89.83 29.5,89.83 29.85,90.19 34.73,90.19 37.7,87.22 37.7,86.1 38.46,85.34 39.58,85.34 39.94,84.97 46.27,78.64 54.75,78.64 64.71,88.6 67,88.6 77.74,99.34 86.23,99.34 86.83,98.74 94.35,98.74 95.15,97.93 101.22,97.93 101.61,98.32 101.61,98.77 v1(101.68,98.85)
  BOTTOM w0.094: v1(27.61,89.67) 27.43,89.85 27.18,89.85 26.93,90.1 26.93,90.88 26.92,90.89 26.92,91.47 26.93,91.48 26.93,91.78 26.84,91.87 26.66,91.87 CT110.1
SW2_DP1_N3_C: length 3.2
  BOTTOM w0.094: UT9.19 23.69,92.96 23.81,93.08 24.17,93.08 24.47,92.78 v4(24.47,92.47) 24.47,92.08 24.67,91.87 24.91,91.87 CT110.2
SW2_DP1_P0: length 97
  TOP w0.094: UV7.50 98,98.34 98.1,98.45 98.1,98.67 97.9,98.87 97.49,98.87 v1(97.29,98.67)
  IN1 w0.089: v1(97.29,98.67) 97.13,98.82 96.7,98.82 95.73,99.79 94.8,99.79 94.33,99.32 87.07,99.32 86.42,99.98 77.4,99.98 70.03,92.61 69.36,92.61 66.95,90.2 64.53,90.2 57.53,83.19 57.53,82.49 54.31,79.28 46.5,79.28 34.93,90.85 29.67,90.85 29.27,91.25 26.68,91.25 25.79,92.14 25.79,97.63 26.32,98.15 v1(27.23,98.15)
  BOTTOM w0.094: CT103.1 26.24,98.49 26.56,98.18 26.76,98.18 26.95,97.99 27.06,97.99 v1(27.23,98.15)
SW2_DP1_P0_C: length 3.2
  BOTTOM w0.094: UT9.9 23.63,96.96 23.74,96.85 23.81,96.85 24.07,97.11 24.07,97.69 24.55,98.17 24.93,98.17 CT103.2
SW2_DP1_P1: length 98.7
  TOP w0.094: UV7.47 99.2,98.37 99.3,98.48 99.3,98.83 v1(99.1,99.03)
  IN1 w0.089: v1(99.1,99.03) 99.31,99.23 99.31,99.4 98.86,99.84 96.8,99.84 94.67,101.97 76.37,101.97 73.34,98.94 73.34,96.73 69.92,93.31 69.23,93.31 66.7,90.77 64.24,90.77 53.38,79.91 46.68,79.91 35.16,91.43 30,91.43 29.47,91.97 27.04,91.97 26.53,92.48 26.53,95.61 27.05,96.13 28.17,96.13 v1(28.36,96.32)
  BOTTOM w0.094: v1(28.36,96.32) 28.2,96.16 26.62,96.16 CT105.1
SW2_DP1_P1_C: length 2.5
  BOTTOM w0.094: UT9.12 23.7,95.76 23.8,95.66 24.3,95.66 24.77,96.13 24.92,96.13 CT105.2
SW2_DP1_P2: length 95.4
  TOP w0.094: v1(99.8,99.79) 100,99.59 100,99.36 100.1,99.25 100.1,98.46 100,98.36 UV7.45
  IN1 w0.089: v1(99.8,99.79) 100,99.99 100,100.33 97.75,102.58 76.15,102.58 72.64,99.07 72.64,96.88 69.71,93.94 69.04,93.94 66.45,91.35 63.82,91.35 53.01,80.55 46.86,80.55 35.39,92.01 30.54,92.01 29.88,92.67 28.23,92.67 27.65,93.25 27.65,93.91 27.85,94.11 28.17,94.11 v1(28.35,94.29)
  BOTTOM w0.094: CT107.1 26.62,94.13 v4(27.21,94.13) 28.19,94.13 v1(28.35,94.29)
SW2_DP1_P2_C: length 2.4
  BOTTOM w0.094: CT107.2 24.91,94.09 24.67,94.09 24.32,94.43 23.76,94.43 23.63,94.56 UT9.15
SW2_DP1_P3: length 94
  TOP w0.094: v1(101.1,98.85) 101.3,98.64 101.3,98.47 101.2,98.36 UV7.42
  IN1 w0.089: v1(101.1,98.85) 101.42,98.52 101.42,98.39 101.15,98.11 95.23,98.11 94.43,98.92 86.91,98.92 86.3,99.52 77.67,99.52 66.92,88.78 64.64,88.78 54.68,78.82 46.35,78.82 40.12,85.05 39.65,85.52 38.53,85.52 37.88,86.17 37.88,87.29 34.8,90.37 29.77,90.37 29.42,90.01 27.85,90.01 v1(27.61,90.25)
  BOTTOM w0.094: CT109.1 26.24,92.16 26.34,92.06 26.91,92.06 27.12,91.85 v4(27.12,91.18) 27.12,90.18 27.26,90.04 27.39,90.04 v1(27.61,90.25)
SW2_DP1_P3_C: length 3.2
  BOTTOM w0.094: UT9.18 23.68,93.36 23.78,93.26 24.25,93.26 24.66,92.85 24.66,92.15 24.75,92.06 24.92,92.06 CT109.2
SW2_DP3_AUXN: length 214
  TOP w0.094: UV7.29 106.75,96.86 106.83,96.77 107.19,96.77 RV72.1 107.99,97 108.15,97 108.72,97.56 111.32,97.56 113.12,99.37 v4(113.37,99.37) 114.3,99.37 v1(114.5,99.56)
  IN1 w0.089: v1(114.5,99.56) 114.7,99.36 115.86,99.36 116.09,99.59 128.98,99.59 130.2,98.37 149.13,98.37 157.45,90.05 157.45,87.02 158.37,86.1 162.13,86.1 173.68,74.55 173.68,64.47 184.03,54.12 189.47,54.12 200.37,43.22 203.43,43.22 208.49,38.17 216.91,38.17 218.26,36.82 220.73,36.82 221.44,36.12 233.28,36.12 234.74,37.57 240.31,37.57 242.57,39.83 246.64,39.83 249.37,42.56 249.81,42.56 250.44,43.19 252.24,43.19 256.25,47.2 256.25,48.72 261.75,54.23 263.23,54.23 263.32,54.31 263.32,54.44 v1(263.12,54.64)
  BOTTOM w0.094: v1(263.12,54.64) 263.32,54.44 263.32,54.14 263.55,53.91 264.51,53.91 264.73,54.13 269.61,54.13 272.29,56.81 272.29,57.73 272.42,57.85 272.55,57.85 CV112.1
SW2_DP3_AUXN_C: length 3.8
  TOP w0.094: UV6.3 275.29,55.67 274.83,56.13 274.83,57.71 274.74,57.8 274.53,57.8 v1(274.43,57.7)
  BOTTOM w0.094: v1(274.43,57.7) 273.92,57.7 CV112.2
SW2_DP3_AUXP: length 214
  TOP w0.094: v1(114.5,98.98) 114.3,99.18 113.75,99.18 113.71,99.14 113.16,99.14 111.4,97.38 108.79,97.38 108.23,96.81 108.02,96.81 107.69,96.47 RV78.1 107.51,96.59 106.84,96.59 106.71,96.46 UV7.28
  IN1 w0.089: v1(114.5,98.98) 114.7,99.18 115.93,99.18 116.16,99.41 128.91,99.41 130.13,98.19 149.05,98.19 157.27,89.97 157.27,86.95 158.3,85.92 162.06,85.92 173.5,74.47 173.5,64.39 183.95,53.94 189.4,53.94 200.3,43.04 203.36,43.04 208.41,37.99 216.83,37.99 218.18,36.64 220.66,36.64 221.36,35.94 233.36,35.94 234.81,37.39 240.39,37.39 242.65,39.65 246.71,39.65 249.44,42.38 249.89,42.38 250.51,43.01 252.32,43.01 256.43,47.12 256.43,48.65 261.83,54.05 263.31,54.05 263.5,54.24 263.5,54.44 v1(263.7,54.64)
  BOTTOM w0.094: v1(263.7,54.64) 263.5,54.44 263.5,54.22 263.63,54.09 264.44,54.09 264.65,54.31 269.53,54.31 272.11,56.89 272.11,57.81 272.34,58.04 272.45,58.04 CV111.1
SW2_DP3_AUXP_C: length 3.8
  TOP w0.094: v1(274.43,58.29) 274.72,57.99 274.82,57.99 275.02,57.79 275.02,56.2 275.15,56.07 UV6.2
  BOTTOM w0.094: CV111.2 273.92,58.29 v1(274.43,58.29)
SW2_DP3_CADET: length 1.7
  TOP w0.102: RV75.1 104.6,99.27 104.6,98.52 104.8,98.33 UV7.33
SW2_DP3_HPD: length 242.5
  TOP w0.102: v1(274.32,59.18) 274.85,59.18 275.34,58.69 275.34,58.28 276.29,57.33 UV6.32 ; UV7.38 v1(102.8,98.8)
  IN3 w0.122: v1(102.8,98.8) 104.04,98.8 104.32,99.08 104.32,100.53 104.63,100.83 116.39,100.83 116.69,101.14 141.51,101.14 144.89,104.51 148.06,104.51 148.74,103.84 148.74,98.04 152.25,94.53 158.09,94.53 166.12,86.5 166.12,76.22 167.1,75.24 167.1,60.5 174.76,52.84 180.09,52.84 181,51.94 181.59,51.94 200.95,32.58 205.43,32.58 205.95,33.1 216.03,33.1 217,34.07 219.35,34.07 219.99,34.71 236.57,34.71 240.58,38.72 248.06,38.72 256.1,46.76 259.22,46.76 259.77,46.21 260.8,46.21 262.01,47.43 263.59,47.43 264.1,47.94 264.1,48.53 265.51,49.93 267.78,49.93 269.05,51.2 269.82,51.2 271.01,52.39 271.59,52.39 273.29,54.1 273.29,54.86 273.6,55.17 273.6,55.79 273.87,56.05 273.87,57.07 273.94,57.14 273.94,58.81 v1(274.32,59.18)
  BOTTOM w0.102: v1(274.32,59.18) 274.52,59.38 RV102.1 v2(273.58,59.82)
SW2_DP3_N0: length 217.5
  TOP w0.094: UV7.39 102.4,98.41 102.29,98.52 102.29,99.24 v1(102.48,99.43)
  IN1 w0.089: v1(271.59,54.47) 271.18,54.87 270.73,54.87 270.68,54.92 265.45,54.92 263.76,53.23 261.83,53.23 257.49,48.89 257.49,47.36 252.51,42.38 251.03,42.38 247.44,38.79 243.36,38.79 241.37,36.8 235.13,36.8 233.69,35.36 221.02,35.36 220.32,36.07 217.82,36.07 216.48,37.41 208.11,37.41 203.1,42.41 200.05,42.41 189.25,53.21 182.22,53.21 172.57,62.86 172.57,72.61 166.76,78.43 164.78,78.43 156.7,86.51 156.7,89.66 148.76,97.59 127.41,97.59 126.61,98.39 114.05,98.39 112.71,99.74 111.08,99.74 109.4,101.41 104.22,101.41 102.65,99.84 102.32,99.84 102.23,99.76 102.23,99.66 102.46,99.43 v1(102.48,99.43)
  BOTTOM w0.094: v1(271.59,54.47) 271.88,54.76 272.08,54.76 272.18,54.85 272.31,54.85 CV108.1
SW2_DP3_N0_C: length 2.7
  TOP w0.094: v1(274.27,54.9) 274.5,55.13 274.58,55.13 275.23,54.47 UV6.6
  BOTTOM w0.094: v1(274.27,54.9) 274.22,54.95 273.91,54.95 CV108.2
SW2_DP3_N1: length 215.4
  TOP w0.094: UV7.36 103.6,98.42 103.5,98.51 103.5,98.82 103.63,98.95 103.63,99.22 v1(103.84,99.43)
  IN1 w0.089: v1(103.84,99.43) 103.64,99.63 103.64,99.76 103.73,99.85 104.36,99.85 105.26,100.75 109.15,100.75 110.76,99.14 112.44,99.14 113.8,97.78 125.73,97.78 126.56,96.95 148.59,96.95 156.12,89.42 156.12,86.19 164.88,77.43 166.86,77.43 171.94,72.36 171.94,62.5 183.83,50.61 190.3,50.61 199.14,41.78 202.85,41.78 207.89,36.73 216.08,36.73 217.32,35.49 220.03,35.49 220.76,34.76 234.03,34.76 235.48,36.22 241.68,36.22 243.67,38.2 247.68,38.2 251.26,41.79 252.76,41.79 258.12,47.15 258.12,48.71 260.3,50.89 261.83,50.89 262.77,51.83 265.46,51.83 266.13,52.5 266.74,52.5 v1(267.14,52.1)
  BOTTOM w0.094: CV110.1 272.25,53.14 269.25,53.14 268.62,52.5 267.54,52.5 v1(267.14,52.1)
SW2_DP3_N1_C: length 2.7
  TOP w0.094: v1(274.2,53.72) 274.71,53.72 274.76,53.67 UV6.8
  BOTTOM w0.094: CV110.2 274.2,53.47 v1(274.2,53.72)
SW2_DP3_P0: length 217.5
  TOP w0.094: UV7.40 102,98.43 102.1,98.53 102.1,99.23 v1(101.9,99.43)
  IN1 w0.089: v1(101.9,99.43) 102.05,99.58 102.05,99.83 102.24,100.03 102.58,100.03 104.15,101.6 109.48,101.6 111.16,99.92 112.78,99.92 114.13,98.57 126.69,98.57 127.48,97.77 148.83,97.77 156.88,89.73 156.88,86.58 164.85,78.61 166.83,78.61 172.75,72.69 172.75,62.93 182.3,53.39 189.32,53.39 200.12,42.59 203.18,42.59 208.18,37.59 216.55,37.59 217.89,36.25 220.39,36.25 221.1,35.54 233.61,35.54 235.05,36.98 241.3,36.98 243.29,38.97 247.37,38.97 250.95,42.56 252.43,42.56 257.31,47.43 257.31,48.97 261.75,53.41 263.68,53.41 265.38,55.1 270.75,55.1 270.81,55.05 v1(271.59,55.05)
  BOTTOM w0.094: v1(271.59,55.05) 271.69,54.95 272.01,54.95 272.13,55.07 272.22,55.07 CV107.1
SW2_DP3_P0_C: length 2.6
  TOP w0.094: UV6.5 275.1,54.87 274.66,55.31 274.44,55.31 v1(274.27,55.48)
  BOTTOM w0.094: CV107.2 273.8,55.17 273.96,55.17 v1(274.27,55.48)
SW2_DP3_P1: length 215.4
  TOP w0.094: UV7.37 103.2,98.38 103.32,98.51 103.32,98.9 103.45,99.02 103.45,99.24 v1(103.26,99.43)
  IN1 w0.089: v1(103.26,99.43) 103.46,99.63 103.46,99.83 103.65,100.03 104.28,100.03 105.19,100.93 109.22,100.93 110.84,99.32 112.51,99.32 113.87,97.96 125.8,97.96 126.63,97.13 148.66,97.13 156.3,89.49 156.3,86.27 164.95,77.62 166.93,77.62 172.12,72.43 172.12,62.58 183.9,50.8 190.38,50.8 199.21,41.96 202.92,41.96 207.97,36.91 216.16,36.91 217.4,35.67 220.1,35.67 220.83,34.94 233.95,34.94 235.41,36.4 241.61,36.4 243.59,38.38 247.6,38.38 251.19,41.97 252.69,41.97 257.94,47.22 257.94,48.79 260.23,51.07 261.75,51.07 262.69,52.01 265.39,52.01 266.05,52.68 v1(267.14,52.68)
  BOTTOM w0.094: CV109.1 272.25,53.32 269.18,53.32 268.54,52.68 v1(267.14,52.68)
SW2_DP3_P1_C: length 2.7
  TOP w0.094: UV6.7 275.28,54.07 275.06,53.86 274.83,53.86 274.79,53.91 274.6,53.91 v1(274.2,54.3)
  BOTTOM w0.094: v1(274.2,54.3) 273.57,53.67 CV109.2
SW2_PS8338_CFG0: length 3.8
  TOP w0.102: RV88.1 RV87.1 95.6,93.76 v2(95.83,93.76) 96.13,94.06 UV7.59
SW2_PS8338_P0: length 5
  TOP w0.102: RV96.1 RV95.1 95.76,92.17 v2(95.76,92.35) 95.76,93.19 96.24,93.66 UV7.60
SW2_PS8338_P1: length 3.3
  TOP w0.102: UV7.1 98,92.42 96.79,91.22 RV94.1 RV93.1
SW2_PS8338_PC10: length 3.6
  TOP w0.102: RV85.1 RV86.1 95.15,95.09 v2(95.84,95.09) 96.63,95.09 96.8,95.26 UV7.56
SW2_PS8338_PC11: length 3.4
  TOP w0.102: UV7.55 94.83,95.66 RV84.1 RV83.1
SW2_PS8338_PC20: length 3.9
  TOP w0.102: UV7.54 96.19,96.06 v2(95.78,96.47) RV81.1 RV82.1
SW2_PS8338_PC21: length 6.4
  TOP w0.102: v2(92.82,99.19) RV80.1 RV79.1 95.32,98.68 95.32,97.41 96.27,96.46 UV7.53
SW2_PS8338_PEQ: length 8.9
  TOP w0.102: UV7.8 100.8,92.19 100.82,92.17 100.82,90.87 v1(101.1,90.59) ; v1(97.21,90.49) 97.62,90.49 v2(97.73,90.38) 97.87,90.24 RV90.1 97.85,89.4 RV89.1
  IN2 w0.122: v1(101.1,90.59) 101,90.49 v1(97.21,90.49)
SW2_PS8338_SW: length 6.9
  TOP w0.102: UV7.18 104.8,92.46 105.01,92.25 107.41,92.25 RV92.1 RV91.1 108.15,91.53 v2(109.94,91.53)
SW_+1VALWP: length 0.6
  TOP w0.102: v3(179.77,92.17) v1(179.77,91.59)
  vias: v1(179.71,96.22) v1(180.03,96.73) v1(180.41,91.59)
SW_USB20_N9: length 22.8
  TOP w0.094: UI3.11 308.99,58.12 308.93,58.06 308.64,58.06 308.19,57.61 v4(307.42,57.61) 306.78,57.61 306.63,57.46 306.63,57.01 306.82,56.81 307.95,56.81 307.96,56.82 308.61,56.82 308.62,56.81 308.69,56.81 308.98,56.52 308.98,55.81 308.69,55.51 307.35,55.51 306.76,54.92 306.76,54.68 305.68,53.6 305.68,52.65 306.25,52.08 306.74,52.08 307.42,51.4 307.42,45.88 308.35,44.95 308.75,44.95 308.86,45.05 308.86,45.16 308.72,45.3 308.55,45.3 308.44,45.41 LI7.1
SW_USB20_P9: length 22.8
  TOP w0.094: LI7.4 309.04,45.24 309.04,44.98 308.83,44.76 308.28,44.76 307.24,45.8 307.24,51.32 306.66,51.89 306.17,51.89 305.49,52.57 305.49,53.67 306.57,54.75 306.57,55 307.27,55.7 308.61,55.7 308.8,55.89 308.8,56.44 308.61,56.63 v4(308.28,56.63) 306.74,56.63 306.44,56.93 306.44,57.53 306.7,57.79 307.1,57.79 307.1,57.8 307.74,57.8 307.75,57.79 308.12,57.79 308.49,58.17 UI3.10
SYS_PWROK: length 453.2
  TOP w0.102: v1(60.71,42.94) 61.92,42.94 62.36,42.5 RC129.1 ; RE56.1 302.32,68.36 302.32,68.01 302.19,67.89 RE548.1 301.95,67.39 v1(301.82,67.26) ; v1(165.48,74.88) v3(165.48,75.7)
  IN2 w0.122: v1(40.96,66.19) 38.93,64.15 38.93,57.74 38.23,57.04 38.23,47.2 38.87,46.56 38.87,44.91 41.72,42.06 41.72,41.48 47.19,36.02 55.89,36.02 60.2,40.34 60.2,42.44 v1(60.71,42.94)
  IN3 w0.122: v1(40.96,66.19) 40.96,68.15 42.68,69.87 42.68,71.99 47.01,76.32 47.71,76.32 53.55,82.16 53.55,83.22 55.84,85.51 56.98,85.51 59.51,88.05 61.34,88.05 64.61,91.31 67.04,91.31 68.04,92.31 72.12,92.31 72.97,91.46 87.58,91.46 87.91,91.13 91.09,91.13 92.81,92.86 93.58,92.86 95.86,95.14 97.19,95.14 97.62,94.71 106.15,94.71 106.58,95.14 107.7,95.14 108.21,94.63 119.7,94.63 122.51,97.44 125.41,97.44 128,94.85 147.21,94.85 148.44,93.62 154.76,93.62 158.82,89.55 161.99,89.55 165.48,86.07 v1(165.48,74.88)
  IN4 w0.089: v1(165.48,74.88) 166.16,74.88 169.66,71.38 169.66,56.79 181.51,44.95 187.06,44.95 195.51,36.5 195.51,34.71 199.42,30.8 208.36,30.8 210.75,28.42 213.44,28.42 213.62,28.59 218.83,28.59 220.54,30.31 235.88,30.31 239.44,26.74 256.19,26.74 269.57,40.12 269.57,41.59 272.01,44.04 274.07,44.04 274.84,44.81 275.27,44.81 276.37,45.91 276.37,46.51 277.79,47.93 278.29,47.93 280.06,49.7 280.76,49.7 284.97,53.91 284.97,54.86 285.88,55.77 286.83,55.77 288.76,57.7 292,57.7 294.09,59.78 294.7,59.78 296.07,61.16 296.07,61.6 298.54,64.08 299.24,64.08 300.74,65.58 300.74,66.82 301.19,67.26 v1(301.82,67.26)
  BOTTOM w0.076: 136.05,71.82 135.26,71.04 135.26,70.73 134.36,69.83 134.36,68.99 UC1.B6
  BOTTOM w0.102: 136.05,71.82 140.14,75.91 140.14,83.41 142.58,85.84 146.33,85.84 148.95,83.23 148.95,80.23 154.3,74.88 v1(165.48,74.88)
SYS_RESET#: length 276.6
  IN4 w0.089: v1(316.83,68.47) 316.83,68.81 316.37,69.27 314.72,69.27 311.79,72.2 310.32,72.2 310.11,71.99 305.93,71.99 305.16,71.23 305.16,70.48 304.45,69.77 304.45,68.35 303.35,67.26 303.35,66.62 303.47,66.5 303.47,65.68 303.09,65.3 302.02,65.3 301.05,64.33 301.05,64.06 299.75,62.76 299.5,62.76 298.56,61.82 298.56,61.54 297.41,60.39 297.41,59.58 296.35,58.51 295.43,58.51 292.45,55.53 289.12,55.53 288.61,55.02 288.61,54.71 286.64,52.74 286.64,52.04 286.14,51.54 283.53,51.54 281.03,49.04 280.34,49.04 277.67,46.37 277.21,46.37 276.84,46 276.84,45.64 275.54,44.34 275.03,44.34 274.26,43.57 272.78,43.57 270.06,40.84 270.06,39.85 256.48,26.27 239.25,26.27 237.66,27.86 226.32,27.86 225.07,29.1 223.88,29.1 223.42,28.64 222.76,28.64 222.59,28.47 219.52,28.47 219.09,28.03 213.77,28.03 213.64,27.91 210.56,27.91 208.15,30.32 199.19,30.32 195.04,34.47 195.04,36.31 186.87,44.47 181.21,44.47 169.18,56.5 169.18,70.96 165.95,74.2 v1(165.95,74.28)
  BOTTOM w0.102: UC1.B5 135.2,69.19 134.9,69.49 134.9,69.83 134.91,69.84 135.08,70.01 135.08,70.01 135.86,70.78 136.1,70.78 142.51,77.2 145.25,77.2 146.63,77.77 149.81,77.77 150.96,76.62 150.96,73.65 151.31,73.3 158.65,73.3 159.64,74.28 v1(165.95,74.28) 165.88,74.34 165.88,75.05 165.55,75.38 160.81,75.38 158.78,77.41 158.78,81.06 154.18,85.67 v2(152.87,85.67) 148.2,85.67 147.25,86.62 CC302.1 RC224.2 146.31,89.41 RC291.1 ; v1(316.83,68.47) 317.05,68.25 JAPS1.13
SYS_RESET#_R: length 3.7
  BOTTOM w0.102: UC12.4 147.95,88.68 RC224.1 RC290.2 149.28,87.83 149.59,87.52 v2(149.59,87.27)
SYSTEM_ID: length 12.9
  TOP w0.102: v1(302.33,88.98) 302.32,88.97 CE47.1 RE300.1
  TOP w0.107: v1(302.36,79.53) UE1.J10
  BOTTOM w0.102: v1(302.33,88.98) 302.33,88.13 v2(302.22,88.02) 302.22,87.35 302.63,86.94 302.63,85.82 301.4,84.59 301.4,81.07 301.62,80.85 301.62,80.85 301.73,80.74 301.75,80.74 301.97,80.51 301.97,80.2 301.96,80.19 301.96,79.93 v1(302.36,79.53)
TACH_FAN1: length 62.5
  TOP w0.102: v1(283.94,40.95) 283.61,41.27 283.27,41.27 282.95,40.96 280.08,40.96 279.15,41.9 278.44,41.9 277.23,40.69 274.48,40.69 274.22,40.43 273.64,40.43 v3(273.64,40.43) 272.06,40.43 v1(272.06,40.43) ; v1(267.52,42.03) RE51.2
  TOP w0.107: v1(298.36,73.13) UE1.E3
  IN3 w0.122: v1(298.36,73.13) 299.19,72.29 299.19,64.39 298.25,63.45 298.25,62.98 296.42,61.16 296.42,58.77 296.17,58.51 295.84,58.51 295.48,58.15 295.48,56.02 294.61,55.15 294.61,53.55 294.47,53.41 294.47,52.51 294.15,52.19 294.15,51.71 292.93,50.5 291.57,49.14 290.6,49.14 289.34,47.88 289.34,46.8 286.08,43.54 286.08,42.22 284.81,40.95 v1(283.94,40.95)
  BOTTOM w0.102: v1(272.06,40.43) 271.68,40.05 269.57,40.05 267.6,42.03 v1(267.52,42.03) 266.63,42.03 JFAN1.3
TBT_FORCE_PWR: length 12.7
  BOTTOM w0.102: T19.1 139.2,78.95 139.2,76.24 133.64,70.69 133.64,69.44 133.94,69.14 UC1.B7
TBT_RESET_N_EC_R: length 8.2
  TOP w0.102: v1(309.31,78.12) 310.06,78.12 RE95.2
  TOP w0.107: UE1.L8 303.9,77.87 306.08,77.87 v1(306.2,78)
  IN1 w0.089: v1(309.31,78.12) 309.19,78.25 307.6,78.25 307.32,78.53 306.44,78.53 306.2,78.29 v1(306.2,78)
  BOTTOM w0.102: v1(306.2,78) 306.2,78.21 v2(305.94,78.47)
TBTA_AUXN_C: length 6
  TOP w0.076: 29.32,84.32 29.43,84.21 30.1,84.21 30.89,83.42 30.89,82.9 UT5.J2
  TOP w0.094: CT81.2 28.52,86.59 28.52,86.24 RT95.1 28.39,85.88 28.39,85.24 28.99,84.65 28.99,84.65 29.32,84.32
TBTA_AUXP_C: length 6
  TOP w0.076: 29.48,84.47 29.55,84.39 30.18,84.39 31.07,83.49 31.07,83.11 UT5.J1
  TOP w0.094: CT80.2 28.82,86.78 28.73,86.69 28.73,86.41 RT96.1 29.14,85.62 29.04,85.53 28.73,85.53 28.64,85.44 28.64,85.31 v4(28.92,85.02) 29.48,84.47
TBTA_BOT_N: length 24.6
  TOP w0.094: UT5.L7 28.7,80.04 v1(28.27,79.6) ; v1(15.24,91.23) 15.05,91.41 14.9,91.41 RT122.2
  IN1 w0.089: v1(28.27,79.6) 28.66,80 28.66,80.22 28.47,80.41 27.33,80.41 26.91,80.83 26.91,83.37 24.36,85.91 23.31,85.91 22.6,86.62 18.61,86.62 16.64,88.59 16.64,90.62 15.77,91.5 15.5,91.5 v1(15.24,91.23)
TBTA_BOT_N_R: length 11.4
  TOP w0.094: RT122.1 13.36,91.36 12.99,91.36 12.85,91.22 DT40.1 DT40.9 11.48,91.22 11.34,91.36 10.8,91.36 7.63,94.53 7.63,96.3 7.08,96.84 6.99,96.84 6.73,96.59 v1(6.73,96.57)
  BOTTOM w0.094: JUSBC1.B7 6.63,96.67 v1(6.73,96.57)
TBTA_BOT_P: length 24.6
  TOP w0.076: v1(28.88,79.6) 29.06,79.79 30.36,79.79 30.61,80.04 UT5.K7
  TOP w0.094: v1(15.24,91.81) 15.05,91.63 14.9,91.63 RT123.2
  IN1 w0.089: v1(15.24,91.81) 15.34,91.71 15.85,91.71 16.86,90.71 16.86,88.68 18.7,86.83 22.69,86.83 23.4,86.12 24.45,86.12 27.12,83.46 27.12,80.92 27.41,80.62 28.56,80.62 28.88,80.3 v1(28.88,79.6)
TBTA_BOT_P_R: length 11.3
  TOP w0.094: v1(6.73,97.15) 6.83,97.06 7.17,97.06 7.84,96.39 7.84,94.62 10.88,91.58 11.36,91.58 11.51,91.72 DT40.8 DT40.2 12.89,91.72 13.03,91.58 13.26,91.58 RT123.1
  BOTTOM w0.094: v1(6.73,97.15) 6.71,97.18 JUSBC1.B6
TBTA_CC1: length 40.3
  TOP w0.127: v2(14.46,93.26) 13.92,92.73 v1(13.4,92.73)
  TOP w0.203: 29.84,79.07 29.88,79.07 29.92,79.04 UT5.L9 ; v1(10.93,93.17) 11.38,92.72 DT40.7 DT40.4 13.4,92.72 v1(13.4,92.73)
  TOP w0.254: 29.84,79.07 29.62,79.07 29.05,78.5 28.55,78.5 28.4,78.35
  TOP w0.381: v1(25.34,78.19) 25.86,77.67 CT86.1 26.12,77.3 RT104.2 26.73,77.59 27.11,77.97 28.01,77.97 28.4,78.35
  IN1 w0.381: v1(13.4,92.73) 13.4,90.03 18.08,85.36 22.06,85.36 23.6,83.82 23.6,81.91 24.2,81.31 24.2,79.33 v1(25.34,78.19)
  IN4 w0.381: v1(10.93,93.17) 11.56,93.17 12.01,93.62 12.01,95.84 11.69,96.16 v1(11.31,96.16)
  BOTTOM w0.254: 8.46,96.69 8.23,96.69 7.97,96.43 JUSBC1.A5
  BOTTOM w0.381: 8.46,96.69 10.78,96.69 v1(11.31,96.16)
TBTA_CC2: length 41.4
  TOP w0.203: UT5.L10 29.87,78.54 29.78,78.45
  TOP w0.254: 28.74,77.63 28.97,77.63 29.78,78.45
  TOP w0.381: 28.74,77.63 28.28,77.17 CT85.1 ; CT85.1 28.52,75.47 28.86,75.13 RT105.2 ; CT85.1 28.15,75.6 27.64,75.6 v1(27.63,75.58) ; 11.63,93.62 11.89,93.88 11.89,96.33 11.26,96.97 v2(10.37,96.97) 7.77,96.97 6.99,97.75 v1(6.73,97.75)
  IN1 w0.381: v1(13.4,93.36) 13.72,93.36 13.98,93.11 13.98,90.18 18.29,85.87 22.27,85.87 24.69,83.44 24.69,79.62 27.63,76.69 v1(27.63,75.58)
  BOTTOM w0.254: JUSBC1.B5 6.65,97.67 v1(6.73,97.75)
TBTA_DBG_CTL1: length 2.2
  TOP w0.076: v1(32.89,82.01) 32.89,81.8 UT5.E4
  BOTTOM w0.102: RT106.1 33.36,82.48 v1(32.89,82.01) 32.89,81.89 v2(33.23,81.55)
TBTA_DBG_CTL2: length 3
  TOP w0.102: v1(34.18,80.89) 34.04,81.04 UT5.D5
  BOTTOM w0.102: v2(35.84,81.17) 35.23,81.17 RT107.1 34.69,81.4 v1(34.18,80.89)
TBTA_DEBUG1: length 3.9
  TOP w0.102: RT92.2 27.06,83.84 v2(27.69,83.2) 27.72,83.18 29.11,83.18 29.75,82.54 UT5.L2
TBTA_DEBUG2: length 7
  TOP w0.076: v2(28.87,83.74) 29.05,83.56 29.14,83.56 29.91,82.79 30.39,82.79 UT5.K2
  TOP w0.102: RT93.2 25.16,84.35 27.21,84.35 27.51,84.04 28.57,84.04 v2(28.87,83.74)
TBTA_DEBUG3: length 4.4
  TOP w0.102: RT89.2 RT406.2 27.03,82.11 27.34,82.42 v2(28.78,82.42) 29.3,82.42 29.68,82.04 UT5.L3
TBTA_DEBUG4: length 10
  TOP w0.076: 29.62,82.39 29.72,82.29 30.39,82.29 UT5.K3
  TOP w0.102: 29.62,82.39 29.18,82.82 27.54,82.82 27.34,83.02 27.34,83.18 27.16,83.36 25.06,83.36 RT90.1 RT418.1 RT407.2 v2(24.59,79.72)
TBTA_LSRX_R: length 4.5
  TOP w0.076: UT5.K4 30.39,81.79 29.9,81.79
  TOP w0.094: 29.9,81.79 29.63,81.79 29.36,82.06
  TOP w0.102: 29.36,82.06 27.56,82.06 26.83,81.32 RT88.2
TBTA_LSTX_R: length 4.4
  TOP w0.094: 27.01,80.71 27.08,80.79 27.08,81.17 27.77,81.86 29.28,81.86 29.56,81.58 30.1,81.58 UT5.L4
  TOP w0.102: RT87.2 26.8,80.51 27.01,80.71
TBTA_MRESET: length 2.9
  TOP w0.076: v2(33.53,76.73) 33.25,77.01 33.25,77.82 33.14,77.92 UT5.E11
  TOP w0.102: RT86.1 33.8,76.6 33.66,76.6 v2(33.53,76.73)
TBTA_ROM_CLK_PD: length 14.8
  TOP w0.076: UT5.A3 35.35,82.04 35.54,82.23 v1(36.01,82.23)
  TOP w0.102: RT54.2 32.9,91.74 v2(33.16,91.47) 33.53,91.1 v1(33.53,88.92)
  IN1 w0.089: v1(33.53,88.92) 33.98,88.47 33.98,87.27 36.64,84.6 36.64,82.57 36.3,82.23 v1(36.01,82.23)
TBTA_ROM_CLK_PD_R: length 9
  TOP w0.102: JDB1.2 31.87,96.2 32.42,95.65 32.42,95.45 RT54.1 v1(32.9,95.65) v2(33.3,96.06)
  BOTTOM w0.102: v1(32.9,95.65) 29.98,98.57 UT6.6
TBTA_ROM_CS#_PD: length 17.7
  TOP w0.076: v1(36.14,82.82) 35.83,82.82 35.29,82.29 34.84,82.29 34.64,82.09 UT5.B3
  TOP w0.102: RT57.2 v2(29.85,91.03) 29.85,89.89 29.72,89.77 v1(29.72,88.22)
  IN1 w0.089: v1(29.72,88.22) 30.17,88.66 31.12,88.66 31.69,88.09 32.45,88.09 36.14,84.41 v1(36.14,82.82)
TBTA_ROM_CS#_PD_R: length 11.2
  TOP w0.102: JDB1.5 30.37,96.42 v2(29.91,95.97) 29.74,95.8 29.74,95.4 29.85,95.29 RT57.1 29.57,94.96 29.27,95.26 v1(29.27,95.64)
  BOTTOM w0.102: v1(29.27,95.64) 29.68,96.05 30.51,96.05 30.66,95.9 30.66,95.27 32.52,93.41 UT6.1 32.52,90.77 RT51.2
TBTA_ROM_DI_PD: length 16.3
  TOP w0.102: UT5.B4 v1(34.01,81.54) ; v1(30.74,88.22) 30.74,90.8 v2(31.5,91.56) 31.5,93.67 RT55.2
  IN1 w0.089: v1(30.74,88.22) 30.29,87.78 30.29,87.27 31.06,86.51 31.06,83.77 32.01,82.82 33.56,82.82 34.01,82.38 v1(34.01,81.54)
TBTA_ROM_DI_PD_R: length 8.4
  TOP w0.102: JDB1.3 31.37,96.11 v2(31.52,95.96) 31.88,95.6 RT55.1 31.73,94.96 v1(31.08,95.61)
  BOTTOM w0.102: v1(31.08,95.61) 31.08,96.19 28.71,98.57 UT6.5
TBTA_ROM_DO_PD: length 16.6
  TOP w0.076: UT5.A4 35.29,81.54 35.44,81.68 v1(35.62,81.68)
  TOP w0.102: RT56.2 v2(30.87,92.73) 30.33,92.19 30.33,87.99 v1(30.74,87.58)
  IN1 w0.089: v1(30.74,87.58) 32.45,87.58 35.88,84.16 35.88,83.33 35.57,83.01 35.57,81.74 v1(35.62,81.68)
TBTA_ROM_DO_PD_R: length 13.1
  TOP w0.102: v2(27.56,98.89) 27.96,98.49 29.96,98.49 30.87,97.58 JDB1.4 30.87,96.1 30.67,95.89 30.67,95.4 30.87,95.2 RT56.1 30.46,94.96 30.36,95.06 30.36,95.46 v1(30.24,95.58)
  BOTTOM w0.102: v1(30.24,95.58) 30.24,95.16 31.25,94.15 UT6.2 31.25,90.77 RT52.2
TBTA_ROM_HOLD#_PD: length 10.4
  BOTTOM w0.102: RT50.2 33.98,91.22 v2(33.98,92.35) 33.98,95.25 31.25,97.98 UT6.7
TBTA_ROM_WP#_PD: length 3.2
  BOTTOM w0.102: UT6.3 30.1,92.28 RT53.2 29.42,90.65 v2(28.9,90.12)
TBTA_ROSC: length 2.8
  TOP w0.076: UT5.G2 31.89,82.79 31.89,84.03
  TOP w0.102: 31.89,84.03 31.89,84.83 RT100.1
TBTA_RX1N: length 15.7
  BOTTOM w0.094: UT9.31 18.7,93.36 18.63,93.3 15.31,93.3 13.96,91.95 11.71,91.95 DT14.1 11.09,91.94 10.55,91.94 9.81,92.68 9.23,92.68 7.98,93.93 7.05,93.93 6.83,94.16 6.83,94.67 6.47,95.03 6.31,95.03 6.17,95.18 JUSBC1.B10
TBTA_RX1P: length 15.7
  BOTTOM w0.094: JUSBC1.B11 6.12,94.67 6.12,94.67 6.26,94.82 6.38,94.82 6.61,94.58 6.61,94.07 6.96,93.72 7.89,93.72 9.15,92.47 9.72,92.47 10.47,91.73 11.09,91.73 DT13.1 11.73,91.74 14.05,91.74 15.39,93.08 18.57,93.08 18.7,92.96 UT9.30
TBTA_RX2N: length 15.7
  BOTTOM w0.094: JUSBC1.A10 8.14,98.93 8.14,98.92 8.28,99.07 8.63,99.07 9.93,100.36 11.52,100.36 DT9.1 12.14,100.37 12.59,100.37 13.65,101.43 14.83,101.43 15.98,100.27 15.98,99.56 17.89,97.66 17.89,97.03 18.26,96.65 18.48,96.65 18.57,96.56 UT9.39
TBTA_RX2P: length 15.7
  BOTTOM w0.094: UT9.40 18.57,96.96 18.48,96.87 18.35,96.87 18.1,97.11 18.1,97.75 16.2,99.65 16.2,100.36 14.91,101.64 13.56,101.64 12.5,100.58 12.14,100.58 DT10.1 11.51,100.58 9.84,100.58 8.54,99.28 8.28,99.28 8.14,99.42 JUSBC1.A11
TBTA_SBU1: length 40
  TOP w0.089: RT108.1 26.44,78.98 22.93,78.98 22.39,79.52 21.8,80.11 21.8,86.21 v4(21.19,86.81) 20.73,87.27 20.25,87.27 19.92,87.6 19.92,87.99 v1(19.78,88.13)
  IN1 w0.076: v1(19.78,88.13) 19.93,88.28 19.93,89.33 19.32,89.94 19.32,92.72 19.12,92.92 19.12,96.32 16.92,98.53 14.46,98.53 14.33,98.39 14.33,98.24 v1(14.51,98.06)
  BOTTOM w0.089: v1(14.51,98.06) 14.92,98.06 14.99,98.13 14.99,98.38 14.82,98.55 DT39.6 DT39.5 11.52,98.55 10.55,97.58 9.02,97.58 8.93,97.67 8.93,97.94 8.83,98.04 8.64,98.04 8.55,97.94 8.55,97.67 8.46,97.58 8.23,97.58 8.16,97.66 8.16,97.86 8.09,97.92 7.63,97.92 7.62,97.93 JUSBC1.A8 ; v1(19.78,88.13) 19.97,88.33 19.97,88.49 19.64,88.83 RT132.2
TBTA_SBU1_R: length 3.4
  TOP w0.076: 28.93,78.92 29.09,78.92 29.53,79.36 29.94,79.36 30.01,79.28 30.39,79.28 UT5.K8
  TOP w0.094: RT108.2 27.87,78.92 28.93,78.92
TBTA_SBU2: length 39.5
  TOP w0.089: v1(20.36,88.13) 20.22,87.99 20.22,87.73 20.38,87.57 20.86,87.57 21.4,87.03 21.42,87.01 22.1,86.33 22.1,80.24 v4(22.6,79.74) 23.06,79.28 26.42,79.28 RT109.1
  IN1 w0.076: v1(13.91,98.05) 14.09,98.23 14.09,98.49 14.36,98.77 17.02,98.77 19.36,96.42 19.36,93.02 19.56,92.82 19.56,90.04 20.17,89.43 20.17,88.32 v1(20.36,88.13)
  IN4 w0.076: v1(6.69,95.98) 7.14,95.98 8.46,97.3 10.85,97.3 v1(11.61,98.05)
  BOTTOM w0.089: v1(11.61,98.05) DT39.4 DT39.7 v1(13.91,98.05) ; v1(20.36,88.13) 20.27,88.22 20.27,88.6 20.5,88.83 RT133.2 ; JUSBC1.B8 6.49,96.18 v1(6.69,95.98)
TBTA_SBU2_R: length 2.9
  TOP w0.076: 29.04,79.14 29.44,79.54 UT5.L8
  TOP w0.094: RT109.2 28.08,79.14 v4(28.63,79.14) 29.04,79.14
TBTA_TOP_N: length 29
  TOP w0.094: UT5.L6 28.01,80.54 27.92,80.63 27.92,80.76 28.01,80.85 28.2,80.85 28.29,80.95 v1(28.29,81.19)
  IN1 w0.089: v1(28.29,81.19) 28.29,81.22 27.94,81.57 27.94,85.16 26.15,86.95 23.74,86.95 23.03,87.66 19.07,87.66 17.68,89.04 17.68,94.35 16.7,95.33 16.7,96.54 16.51,96.73 16.25,96.73 15.9,97.09 v1(15.9,97.1)
  BOTTOM w0.094: v1(15.9,97.1) 15.71,96.92 15.45,96.92 RT121.1
TBTA_TOP_N_R: length 7.2
  BOTTOM w0.094: JUSBC1.A7 7.93,97.43 8.02,97.34 11.09,97.34 11.62,96.81 11.84,96.81 12.08,97.05 DT39.2 DT39.8 13.46,97.05 13.6,96.91 13.89,96.91 RT121.2
TBTA_TOP_P: length 29.1
  TOP w0.076: UT5.K6 30.4,80.29 29.96,80.29
  TOP w0.094: v1(27.71,81.2) 27.71,80.54 27.93,80.32 29.93,80.32 29.96,80.29
  IN1 w0.089: v1(27.71,81.2) 27.73,81.22 27.73,85.07 26.06,86.74 23.65,86.74 22.94,87.44 18.98,87.44 17.47,88.95 17.47,94.27 16.49,95.25 16.49,96.45 16.42,96.52 v1(15.9,96.52)
  BOTTOM w0.094: v1(15.9,96.52) 15.71,96.71 15.49,96.71 RT120.1
TBTA_TOP_P_R: length 7.2
  BOTTOM w0.094: JUSBC1.A6 7.84,96.93 8.03,97.12 11.01,97.12 11.53,96.6 11.94,96.6 11.99,96.55 DT39.1 DT39.9 13.46,96.55 13.6,96.7 13.87,96.7 RT120.2
TBTA_TX1N: length 6.2
  BOTTOM w0.094: UT9.34 18.57,94.56 18.48,94.47 15.75,94.47 15.5,94.72 13.51,94.72 CT96.1
TBTA_TX1N_C: length 5.8
  BOTTOM w0.094: CT96.2 12.36,94.73 12.17,94.73 DT6.1 11.55,94.73 9.53,94.73 8.97,95.28 8.28,95.28 8.14,95.43 JUSBC1.A3
TBTA_TX1P: length 6.2
  BOTTOM w0.094: UT9.33 18.57,94.16 18.48,94.25 15.66,94.25 15.41,94.5 13.49,94.5 CT95.1
TBTA_TX1P_C: length 5.8
  BOTTOM w0.094: CT95.2 12.36,94.51 12.17,94.51 DT5.1 11.55,94.51 9.44,94.51 8.89,95.07 8.28,95.07 8.14,94.92 8.14,94.93 JUSBC1.A2
TBTA_TX2N: length 9.5
  TOP w0.094: CT98.1 13.53,100.34 13.89,100.34 v1(14.07,100.17)
  BOTTOM w0.094: UT9.36 18.57,95.36 18.48,95.45 17.45,95.45 16.87,96.03 16.87,97.5 15.1,99.28 15.1,99.94 14.67,100.37 14.26,100.37 v1(14.07,100.17)
TBTA_TX2N_C: length 7.8
  TOP w0.094: CT98.2 12.28,100.39 12.16,100.39 DT18.1 11.51,100.37 8.77,100.37 7.48,99.08 6.87,99.08 v1(6.73,98.94)
  BOTTOM w0.094: v1(6.73,98.94) 6.72,98.96 6.5,98.96 6.22,98.67 JUSBC1.B3
TBTA_TX2P: length 9.5
  TOP w0.094: v1(14.07,100.76) 13.87,100.56 13.51,100.56 CT97.1
  BOTTOM w0.094: v1(14.07,100.76) 14.24,100.58 14.76,100.58 15.31,100.03 15.31,99.37 17.09,97.59 17.09,96.11 17.53,95.67 18.48,95.67 18.57,95.76 UT9.37
TBTA_TX2P_C: length 7.8
  TOP w0.094: CT97.2 12.4,100.6 12.12,100.6 DT17.1 11.51,100.58 8.68,100.58 7.39,99.29 6.95,99.29 v1(6.71,99.53)
  BOTTOM w0.094: JUSBC1.B2 6.35,99.18 v1(6.71,99.53)
TDI_XDP: length 15.1
  TOP w0.102: v1(53.21,35.27) 53.21,35.41 52.8,35.82 RC229.1 52.25,35.36 v2(52.25,34.94) 52.26,34.94 52.72,34.48 UC8.5 ; JXDP1.56 v1(61.95,31.8)
  BOTTOM w0.102: v1(53.21,35.27) 58.48,35.27 v1(61.95,31.8)
TDO_XDP: length 102.5
  TOP w0.102: CC306.1 55.2,36.28 55.2,37.6 54.05,38.75 v2(54.05,39.31) v1(54.05,39.82) ; CC306.1 54.74,34.69 54.22,34.17 UC8.2 ; CC306.1 55.49,35.82 58.9,32.4 62.36,32.4 62.95,31.81 JXDP1.52
  IN1 w0.089: v1(54.05,39.82) 54.46,39.82 56.29,41.65 56.29,53.31 58.18,55.2 61.43,55.2 62.82,56.6 70.3,56.6 70.87,57.17 71.89,57.17 72.14,56.91 73.09,56.91 73.67,57.49 73.67,61.36 76.38,64.08 81.16,64.08 82.33,65.24 82.33,69.87 83.89,71.43 83.89,75.08 86.74,77.93 91.83,77.93 93.16,76.6 103.01,76.6 v1(104.56,78.15)
  BOTTOM w0.102: RC230.1 104.39,79.91 104.27,79.79 104.27,78.44 v1(104.56,78.15)
THERMTRIP1#: length 5.8
  TOP w0.102: UE1.B12 295.92,81.16 295.92,81.7 294.93,82.7 294.93,83.56 v2(294.23,84.25) 294.23,84.26 293.86,84.26 293.45,83.85 293.45,83.66 RE301.1
THERMTRIP2#: length 28.2
  TOP w0.102: v2(283.26,71.17) v1(283.26,72.2) 283.97,72.92 QE4.1 285.17,72.92 CE36.1 285.37,73.81 285.32,73.86 RE69.2
  TOP w0.107: v1(301.56,73.13) UE1.H3
  IN4 w0.089: v1(301.56,73.13) 299.09,70.65 295.28,70.65 293.6,68.98 292.23,68.98 291.48,68.22 285.54,68.22 283.26,70.51 v1(283.26,72.2)
TOUCH_SCREEN_DET#: length 123.6
  IN2 w0.122: v1(99.87,88.18) 99.93,88.18 100.45,88.71 104.09,88.71 104.6,88.2 107.61,88.2 108.15,87.66 113.17,87.66 113.32,87.8 117.77,87.8 118.79,86.79 128.43,86.79 129.29,87.65 132.51,87.65 133.15,88.29 138.37,88.29 138.59,88.51 146.51,88.51 148.2,86.82 149.87,86.82 152.9,83.79 152.9,80.78 154.23,79.44 v1(155.38,79.44)
  IN4 w0.089: v1(155.38,79.44) 154.78,78.85 154.78,77.58 152.15,74.95 152.15,69.22 150.78,67.85 150.78,64.85 150.94,64.69 150.94,58.56 151.66,57.85 152.42,57.85 153.21,57.06 153.21,56.54 155.19,54.56 155.19,52.76 153.14,50.72 146.92,50.72 145.82,49.62 143.02,49.62 139.41,46 v1(138.44,46)
  BOTTOM w0.076: 136.03,47.02 136.03,47.18 135.83,47.38 135.34,47.38 135.17,47.55 135.17,48.06 134.81,48.41 UC1.AY5
  BOTTOM w0.102: 136.03,47.02 136.03,46.92 136.41,46.54 137.91,46.54 v1(138.44,46) ; JEDP1.32 100.8,91.02 100.67,90.89 100.67,90.28 RV8.1 99.19,88.77 99.78,88.18 v1(99.87,88.18)
TOUCH_SCREEN_PD#: length 47.6
  TOP w0.102: v1(115.94,88.26) v2(115.32,88.26)
  IN3 w0.122: v1(115.94,88.26) 115.97,88.29 120.8,88.29 121.57,87.52 129.06,87.52 129.42,87.88 135.51,87.88 137.77,85.61 137.77,82.47 138.31,81.93 v1(138.31,81.81)
  BOTTOM w0.102: v1(138.31,81.81) 138.31,81.55 RC272.1 139.45,79.65 139.45,76.12 133.94,70.61 UC1.A7 ; JEDP1.5 114.3,91.24 115.94,89.61 v1(115.94,88.26)
TOUCHPAD_INTR#: length 213.4
  TOP w0.102: RE318.2 297.51,64.54 297.34,64.38 295.85,64.38 295.55,64.07 295.55,60.79 v3(295.74,60.6) 296.11,60.6 296.17,60.66 v1(297.12,60.66) ; RC414.1 140.19,43.49 v1(140.04,43.49) ; v1(211.71,19.7) 212.66,20.65 JKBTP1.5
  IN1 w0.089: v1(229.37,21.74) 228.04,20.4 221.05,20.4 220.14,19.49 218.73,19.49 218.37,19.85 214.95,19.85 214.26,19.16 212.26,19.16 v1(211.71,19.7) 211.66,19.75 204.42,19.75 203.01,21.16 200.66,21.16 194,27.82 187.1,27.82 185.84,26.56 180.32,26.56 179.61,27.27 171.47,27.27 168.34,30.4 164.31,30.4 161.41,33.3 160.03,33.3 159.4,33.92 154.89,33.92 153.32,35.49 151.58,35.49 151.34,35.73 147.62,35.73 146.03,37.32 146.03,38.78 141.33,43.49 v1(140.04,43.49)
  IN3 w0.122: v1(297.12,60.66) 297.12,54.74 296.22,53.84 295.54,53.84 294.91,53.22 294.91,52.33 294.59,52.01 294.59,51.53 291.57,48.5 291.57,47.56 291.8,47.33 291.8,46.81 291.23,46.24 289.41,46.24 286.53,43.36 286.53,41.1 285.55,40.12 283.92,40.12 283.08,39.28 283.08,36.46 281.56,34.94 281.13,34.94 277.73,31.54 259.36,31.54 257.95,30.13 253.02,30.13 252.6,29.7 249.44,29.7 247.95,28.21 244.13,28.21 239.25,23.33 231.8,23.33 230.21,21.74 v1(229.37,21.74)
  BOTTOM w0.102: UC1.BA5 134.87,47.66 134.63,47.42 134.63,46.92 134.81,46.74 135.28,46.74 135.45,46.56 135.67,46.56 136.17,46.06 137.55,46.06 138.33,45.28 138.49,45.28 140.04,43.73 v1(140.04,43.49)
TP_LAN_JTAG_TCK: length 4.7
  TOP w0.102: UL1.35 274.9,83.82 274.44,83.36 274.44,83.23 273.78,82.57 RL2.1 273.13,82.49 272.24,81.6 v3(271.66,81.6)
TP_LAN_JTAG_TDI: length 1.4
  TOP w0.102: T88.1 274.5,84.63 274.89,85.02
  TOP w0.112: 274.89,85.02 UL1.32
TP_LAN_JTAG_TDO: length 1.7
  TOP w0.102: T89.1 273.99,83.44 274.77,84.22 UL1.34
TP_LAN_JTAG_TMS: length 4.5
  TOP w0.102: v2(271.34,83.36) 272.4,83.36 RL1.1
  TOP w0.112: RL1.1 274.37,84.09 274.9,84.62 UL1.33
TPM_GPIO0: length 2.7
  TOP w0.102: UZ12.29 167.32,34.31 167.84,33.8 RZ112.2 v2(166.81,33.37)
TPM_GPIO4: length 1.6
  TOP w0.102: T283.1 167.44,40.96 166.82,40.34 UZ12.13
TPM_LPM#: length 2.6
  TOP w0.102: v2(171,38.12) RZ363.2 170.63,36.67 UZ12.3
TPM_PIRQ#: length 7.6
  TOP w0.102: RC561.2 159.72,42.61 RC560.2 160.3,42.61 161.68,41.24 v2(161.68,40.89) 161.68,40.34 162.12,39.9 162.68,39.9 RZ69.2 163.39,39.18 163.39,38.88 163.6,38.67 UZ12.18
TPM_PIRQ#_R: length 35.3
  TOP w0.102: v1(160.13,40.94) 160.28,41.09 RC560.1
  IN3 w0.122: v1(132.52,51.66) 132.06,51.2 132.06,49.8 133.99,47.87 138.71,47.87 139.53,47.05 142.07,47.05 145.55,43.58 150.09,43.58 152.25,41.42 155.83,41.42 156.32,40.94 v1(160.13,40.94)
  BOTTOM w0.076: v1(132.52,51.66) 132.98,52.12 UC1.AP8
TPM_TYPE: length 14.6
  TOP w0.102: v1(140.38,40.49) 140.09,40.19 RC349.1
  BOTTOM w0.076: UC1.AY7 133.7,48.17 133.3,47.77 133.3,46.95 133.51,46.74 134.02,46.74 134.8,45.95 135.34,45.95
  BOTTOM w0.102: 135.34,45.95 135.44,45.95 136,45.39 137.31,45.39 139.94,42.77 140.84,42.77 141.33,42.27 v2(141.33,41.88) 140.85,41.39 140.85,40.96 v1(140.38,40.49)
TRST#_XDP: length 12.2
  TOP w0.102: UC8.12 53.72,30.6 54.3,30.02 55.4,30.02 v2(56.03,29.39) 57.28,28.13 61.99,28.13 62.45,28.6 JXDP1.54
TUSB546A_SBU1_R: length 3.4
  TOP w0.094: v1(19.99,90.49) 20.1,90.39 20.1,90.21 RT414.1
  BOTTOM w0.094: UT9.27 20.21,91.34 20.31,91.24 20.31,91.09 20.19,90.96 20.19,90.7 v1(19.99,90.49) 20.12,90.36 20.12,90.16 19.72,89.76 RT414.1
TUSB546A_SBU2_R: length 3.2
  TOP w0.094: RT415.1 20.48,89.76 20.31,89.92 20.31,90.23 v1(20.57,90.49)
  BOTTOM w0.094: UT9.26 20.61,91.34 20.53,91.25 20.53,91 20.4,90.87 20.4,90.67 v1(20.57,90.49) 20.33,90.25 20.33,89.93 RT415.1
TYPEC_CON_SEL1: length 15
  BOTTOM w0.076: 139.1,60.52 139.02,60.44 137.43,60.44 137.3,60.48 137.29,60.49 137.28,60.49 137.02,60.49 137,60.48 136.67,60.48 136.64,60.49 136.59,60.49 136.57,60.51 136.37,60.51 136.26,60.48 136.08,60.48 136.02,60.48 135.93,60.52 135.67,60.52 135.51,60.37 UC1.W4
  BOTTOM w0.102: 139.1,60.52 140.19,61.61 141.81,61.61 142.58,62.38 142.58,63.04 143.44,63.9 v2(144.1,63.9) 145.45,63.9 146,64.46 146.16,64.46 RC556.1 RC555.1
TYPEC_CON_SEL2: length 12.5
  BOTTOM w0.076: 139.91,58.59 139.27,58.59 139.17,58.49 138.44,58.49 138.28,58.64 137.55,58.64 137.42,58.51 136.43,58.51 UC1.AB3
  BOTTOM w0.102: RC553.1 145.7,59.84 RC554.1 146.08,58.59 144.76,58.59 144.51,58.84 143.85,58.84 143.69,58.69 143.18,58.69 142.93,58.95 140.72,58.95 v2(140.53,58.76) 140.37,58.59 139.91,58.59
TYPEC_ID: length 6.5
  TOP w0.102: UE1.F2 299.19,72.35 299.19,71.77 298.73,71.32 v2(298.73,70.5) 298.84,70.4 298.84,67.59 CE62.1 RE343.2
UART_MISO: length 4.7
  TOP w0.076: UT5.F2 32.89,82.79 32.89,83.15 32.85,83.19 32.85,84.08 v1(32.96,84.19)
  BOTTOM w0.102: v1(32.96,84.19) 32.69,84.45 RT83.2 32.69,85.72 RT82.1 33,86.02 33,86.73 v2(33.09,86.82)
UART_MOSI: length 4.5
  TOP w0.076: v1(33.41,83.57) 33.4,83.56 33.4,82.79 UT5.E2
  BOTTOM w0.102: v2(34.61,84.54) 34.3,84.85 RT83.1 ; RT83.1 33.61,83.77 v1(33.41,83.57) ; RT83.1 33.61,85.72 RT81.1
UG1_ISL9538: length 10.8
  IN1 w0.762: 9.53,23.94 14.36,23.94 15.35,22.95 18.65,22.95 19.25,22.36 19.25,21.93
  vias: v1(8.74,24.71) v1(8.74,24.1) v1(19.37,20.72)
UG2_ISL9538: length 11.1
  TOP w0.102: v1(33.28,15.66) v2(32.75,15.66)
  IN1 w0.762: 32.44,15.51 27.16,15.51 26.55,14.9 24.52,14.9 22.81,16.6
  vias: v1(21.53,17.1) v1(22.17,17.1) v1(33.91,15.66)
UIM_CLK: length 259.5
  IN1 w0.089: v1(119.33,109.59) 119.33,109.99 119.42,110.08 119.78,110.08 120.06,109.81 120.06,107.37 126.36,101.07 130.27,101.07 130.57,100.77 134.89,100.77 135.63,100.03 138.47,100.03 v1(138.89,100.45)
  IN4 w0.089: v1(138.89,100.45) 138.89,100.35 138.98,100.26 140.23,100.26 145.28,95.2 145.94,95.2 149.99,91.15 151.97,91.15 155.99,87.14 155.99,86.15 162.11,80.03 162.11,76.57 168.25,70.43 168.25,56.04 180.85,43.44 186.58,43.44 194.19,35.83 194.19,34.03 198.98,29.24 206.52,29.24 208.63,27.13 209.85,27.13 210.29,26.69 213.87,26.69 214.34,27.16 220.71,27.16 220.9,26.97 231.43,26.97 233.94,24.45 236.96,24.45 237.15,24.64 257.98,24.64 269.27,35.93 269.3,35.93 274.97,41.61 275.83,41.61 276.89,42.67 276.89,43.11 280.43,46.65 281.65,46.65 282.62,47.63 283.85,47.63 286,49.78 287.36,49.78 287.76,49.38 288.92,49.38 291.54,52 292.04,52 293.3,53.27 294.73,53.27 295.71,52.3 296.7,52.3 v1(296.88,52.48)
  BOTTOM w0.102: JSIM1.3 128.82,107.19 125.76,110.25 121.41,110.25 120.93,109.78 119.79,109.78 119.47,110.1 119.03,110.1 CZ38.1 118.85,109.59 v1(119.33,109.59) ; JNGFF2.32 294.55,50.24 294.69,50.38 294.69,51.56 295.34,52.22 296.09,52.22 296.22,52.34 296.74,52.34 v1(296.88,52.48)
UIM_DATA: length 265
  IN1 w0.089: v1(119.33,110.79) 119.33,110.39 119.42,110.3 119.87,110.3 120.27,109.9 120.27,107.46 126.45,101.29 130.36,101.29 130.66,100.98 134.98,100.98 135.72,100.25 138.1,100.25 v1(138.31,100.45)
  IN4 w0.089: v1(138.31,100.45) 138.71,100.04 140.14,100.04 145.19,94.99 145.85,94.99 149.9,90.94 151.88,90.94 155.77,87.05 155.77,86.06 161.89,79.94 161.89,76.48 168.03,70.34 168.03,55.95 180.76,43.22 186.49,43.22 193.97,35.74 193.97,33.94 198.89,29.02 206.43,29.02 208.54,26.92 209.76,26.92 210.2,26.47 213.96,26.47 214.43,26.94 220.62,26.94 220.82,26.74 231.35,26.74 233.85,24.24 237.05,24.24 237.24,24.43 258.07,24.43 269.36,35.72 269.38,35.72 275.06,41.39 275.92,41.39 277.11,42.58 277.11,43.02 280.52,46.44 281.74,46.44 282.71,47.41 283.94,47.41 286.09,49.56 287.27,49.56 287.67,49.16 289.01,49.16 291.63,51.79 292.13,51.79 293.39,53.05 294.65,53.05 295.62,52.08 296.64,52.08 v1(296.87,51.86)
  BOTTOM w0.102: CZ39.1 118.85,110.79 v1(119.33,110.79) ; CZ39.1 118.98,110.33 119.56,110.33 119.89,110 120.84,110 121.32,110.48 125.77,110.48 126.05,110.76 126.05,111.91 125.96,111.99 125.96,113.33 126.65,114.01 127.44,114.01 128.82,115.4 JSIM1.7 ; CZ39.1 RZ335.2 ; v1(296.87,51.86) 296.61,52.11 296.31,52.11 296.19,51.99 295.43,51.99 294.91,51.47 294.91,50.4 295.05,50.26 JNGFF2.34
UIM_RESET: length 232.6
  TOP w0.102: v3(292.34,52.25) 292.37,52.22 v1(293.51,52.22)
  IN4 w0.089: v1(139.65,98.83) 142.42,96.06 143.59,96.06 145.12,94.53 145.79,94.53 149.75,90.57 151.73,90.57 155.26,87.04 155.26,85.93 161.5,79.7 161.5,76.29 167.66,70.13 167.66,55.72 180.62,42.77 186.43,42.77 193.6,35.59 193.6,33.79 199.78,27.62 207.17,27.62 209.05,25.74 213.8,25.74 214.62,26.56 220.35,26.56 220.54,26.37 230.98,26.37 233.69,23.66 253.8,23.66 254.23,23.23 257.46,23.23 268.61,34.38 269.45,34.38 270.34,35.28 270.34,36.14 275.21,41.01 276.07,41.01 276.86,41.8 277.25,41.8 278.01,42.56 278.01,42.74 281.32,46.05 281.87,46.05 282.87,47.05 284.09,47.05 286.23,49.18 287.13,49.18 287.51,48.79 289.16,48.79 291.67,51.3 293.22,51.3 293.51,51.59 v1(293.51,52.22)
  BOTTOM w0.102: v1(293.51,52.22) 293.96,52.22 294.13,52.04 294.13,50.48 294.05,50.4 JNGFF2.30 ; JSIM1.2 131.94,100.22 CZ40.1 132.47,99.76 132.69,99.54 139.21,99.54 139.65,99.11 v1(139.65,98.83)
UPD1_SMBCLK: length 352.6
  TOP w0.102: UE1.C3 v1(296.74,73.11) ; RE303.1 289.43,73.88 288.69,73.88 v1(288.57,74) ; QT1.1 v1(36.81,81.05) ; v1(184.78,40.81) 184.95,40.98 184.95,41.33 184.49,41.8 183.54,41.8 174.91,50.42 174.91,59.67 167.12,67.46 165.16,67.46 159.54,73.07 159.54,74.54 157.19,76.89 157.19,85.6 151.24,91.55 150.74,91.55 v1(150.72,91.57)
  IN2 w0.122: v1(36.81,81.05) 37.22,81.05 38.42,82.25 39.21,82.25 39.31,82.15 42.49,82.15 44.05,83.72 49.32,83.72 55.35,89.75 58.89,89.75 59.3,89.34 62.07,89.34 65.07,92.35 67.28,92.35 68.43,93.5 72.67,93.5 73.56,92.61 85.25,92.61 86.17,93.53 86.17,95.48 88.12,97.43 90.58,97.43 90.88,97.13 93.69,97.13 95.55,95.27 96.86,95.27 97.46,94.66 105.82,94.66 106.18,95.02 107.98,95.02 108.8,94.19 113.73,94.19 114.53,93.39 117.45,93.39 119.81,91.04 130.87,91.04 131.41,91.57 145.1,91.57 145.71,92.18 147.31,92.18 148.3,91.18 149.8,91.18 150.37,91.75 150.54,91.75 v1(150.72,91.57) ; v1(184.78,40.81) 185.29,40.31 188.82,40.31 199.84,29.29 210.79,29.29 211.36,28.72 213.37,28.72 214.02,28.06 218.77,28.06 221.33,30.63 228.78,30.63 229.44,31.29 239.51,31.29 241.49,33.27 246.21,33.27 247.83,34.89 254.74,34.89 255.66,35.81 257.77,35.81 258.85,36.9 259.34,36.9 260.81,38.37 267.82,38.37 271,41.55 271.43,41.55 272.09,42.21 273.61,42.21 275.65,44.24 275.96,44.24 276.69,44.98 277.72,44.98 278.07,45.33 278.64,45.33 280.3,46.99 281.1,46.99 282.51,48.39 283.98,48.39 287.43,51.83 287.43,52.8 288.16,53.54 290.96,53.54 292.03,54.6 292.03,57.48 293.29,58.74 293.29,65.5 294.85,67.06 294.85,70.38 295.46,70.99 295.46,73.25 295.73,73.53 296.33,73.53 v1(296.74,73.11)
  IN4 w0.089: v1(296.74,73.11) 296.53,73.11 296.12,73.53 295.48,73.53 294.99,74.02 290.74,74.02 290.54,73.82 288.75,73.82 v1(288.57,74)
  BOTTOM w0.102: RT58.1 37.24,81.48 v1(36.81,81.05)
UPD1_SMBCLK_Q: length 27.7
  TOP w0.076: 35.97,81.29 34.89,81.29 UT5.B5
  TOP w0.102: RT92.1 v1(25.28,83.84) ; 35.97,81.29 36.97,82.29 v1(37.41,82.29) 37.39,82.3 QT1.6 ; RT375.2 24.95,87.8 v1(25.35,88.21) 26.57,88.21 v2(26.88,87.9)
  IN4 w0.089: v1(25.28,83.84) 25.68,84.24 27.9,84.24 29.27,82.88 35.55,82.88 35.93,83.27 36.47,83.27 36.85,82.89 37.71,82.89 38.02,82.58 38.02,82.42 37.89,82.29 v1(37.41,82.29)
  BOTTOM w0.102: RT67.1 37.29,82.17 v1(37.41,82.29) 37.51,82.39 RT58.2 ; v1(25.35,88.21) 25.28,88.13 v1(25.28,83.84)
UPD1_SMBDAT: length 347.8
  TOP w0.102: RE302.1 289.74,74.36 v1(289.06,74.36) ; v1(185.39,40.83) 185.18,41.04 185.18,41.43 184.58,42.03 183.63,42.03 175.14,50.52 175.14,59.76 167.22,67.68 165.25,67.68 159.77,73.16 159.77,74.63 157.42,76.98 157.42,85.7 151.05,92.07 150.1,92.07 v1(149.91,91.88) ; v1(295.96,73.93) UE1.B4 ; QT1.4 38.99,83.25 v1(38.99,83.58)
  IN2 w0.122: v1(38.99,83.58) 38.99,82.82 39.41,82.4 42.38,82.4 43.95,83.97 49.22,83.97 55.25,90 59,90 59.4,89.59 61.97,89.59 64.97,92.59 67.18,92.59 68.33,93.74 72.78,93.74 73.67,92.86 85.15,92.86 85.92,93.63 85.92,95.59 88.02,97.68 90.68,97.68 90.99,97.38 93.8,97.38 95.66,95.52 96.96,95.52 97.56,94.91 105.72,94.91 106.08,95.27 108.08,95.27 108.9,94.44 113.84,94.44 114.64,93.64 117.55,93.64 119.91,91.29 130.77,91.29 131.3,91.82 145,91.82 145.6,92.43 147.41,92.43 148.4,91.43 149.7,91.43 149.91,91.64 v1(149.91,91.88) ; v1(295.96,73.93) 295.84,73.81 295.67,73.81 295.21,73.36 295.21,71.1 294.6,70.48 294.6,67.16 293.04,65.61 293.04,58.84 291.78,57.58 291.78,54.71 290.86,53.78 288.06,53.78 287.18,52.9 287.18,51.94 283.88,48.64 282.4,48.64 281,47.24 280.2,47.24 278.54,45.58 277.97,45.58 277.61,45.22 276.59,45.22 275.85,44.49 275.54,44.49 273.51,42.46 271.99,42.46 271.33,41.8 270.89,41.8 267.72,38.62 260.71,38.62 259.24,37.15 258.75,37.15 257.66,36.06 255.55,36.06 254.64,35.14 247.73,35.14 246.11,33.52 241.38,33.52 239.4,31.54 229.34,31.54 228.68,30.87 221.23,30.87 218.67,28.31 214.13,28.31 213.47,28.97 211.47,28.97 210.89,29.54 199.94,29.54 188.93,40.56 185.67,40.56 v1(185.39,40.83)
  IN4 w0.089: v1(295.96,73.93) 295.39,73.93 295.08,74.24 290.65,74.24 290.45,74.03 289.39,74.03 v1(289.06,74.36)
  BOTTOM w0.102: RT59.1 38.99,82.77 v1(38.99,83.58)
UPD1_SMBDAT_Q: length 25.5
  TOP w0.076: UT5.A5 36.06,81.04
  TOP w0.102: v2(23.94,86.12) 23.94,85.4 v1(23.96,85.39) 23.96,85.37 23.68,85.1 RT66.1 RT93.1 22.81,83.77 RT376.2 ; QT1.3 38.69,81.69 v1(38.71,81.71) 36.74,81.71 36.06,81.04
  IN4 w0.089: v1(38.71,81.71) 38.69,81.71 38.23,82.17 38.23,82.67 37.8,83.1 36.94,83.1 36.56,83.48 35.84,83.48 35.46,83.1 29.36,83.1 27.99,84.46 26.08,84.46 25.15,85.39 v1(23.96,85.39)
  BOTTOM w0.102: v1(38.71,81.71) 39.14,81.71 RT59.2
UPD1_SMBINT#: length 367.8
  TOP w0.102: UE1.F10 v1(299.16,79.53) ; RE91.1 304.06,88.93 v1(303.92,88.79) ; RT60.1 v1(38.92,79.01)
  IN3 w0.122: v1(303.92,88.79) 303.92,88.75 302.88,87.71 300.41,87.71 297.07,84.37 295.99,84.37 291.06,79.44 287.92,79.44 287.03,78.55 287.03,75.71 285.6,74.29 285.6,71.98 285.02,71.39 285.02,68.5 284.2,67.67 284.2,59.04 285.28,57.96 285.28,55.95 283.39,54.07 283.39,53.23 279.44,49.27 279.44,47.79 277.9,46.26 277.03,46.26 275.44,44.66 274.87,44.66 273.8,43.59 273.8,41.32 272.37,39.9 269.17,39.9 266.78,37.51 257.89,37.51 256.14,35.76 241.67,35.76 236.78,30.88 229.8,30.88 229.23,30.31 226.23,30.31 225.53,31.01 218.88,31.01 217.84,29.96 204.44,29.96 203.17,31.23 200.56,31.23 187.1,44.7 181.69,44.7 163.84,62.55 163.84,66.27 164.37,66.79 164.37,72.56 161.65,75.28 161.65,85.46 155.45,91.66 151.49,91.66 150.42,92.73 146.06,92.73 145.55,92.22 144.58,92.22 143.71,93.09 127.9,93.09 125.4,90.59 121.11,90.59 118.96,92.74 99.99,92.74 99.43,93.29 95.29,93.29 93.4,91.41 92.39,91.41 91.35,90.37 87.53,90.37 87.2,90.7 72.59,90.7 71.82,91.46 67.95,91.46 67.29,90.8 64.83,90.8 61.54,87.52 59.69,87.52 57.03,84.85 56.11,84.85 56.11,84.86 v1(55.86,84.86)
  IN4 w0.089: v1(299.16,79.53) 299.57,79.94 300.95,79.94 301.17,80.16 301.17,81.35 303.76,83.94 303.76,88.64 v1(303.92,88.79)
  BOTTOM w0.102: v1(55.86,84.86) 55.85,84.87 54.35,84.87 53.98,84.5 49.56,84.5 48.57,83.51 v2(46.84,83.51) 44,83.51 39.5,79.01 v1(38.92,79.01)
UPD1_SMBINT#_R: length 4.1
  TOP w0.076: UT5.B6 34.9,80.79 35.47,80.79 35.62,80.64
  TOP w0.102: RT60.2 RT68.1 36.66,80.64 v2(36.38,80.64) 35.62,80.64
UPD2_SMBCLK: length 20.9
  TOP w0.102: v1(297.56,76.33) UE1.D7 ; RPE12.3 313.32,81.53 313.18,81.66 313.18,82.13 312.52,82.8 v4(311.31,82.8) 309.49,82.8 v1(309.29,83)
  IN4 w0.089: v1(297.56,76.33) 298.18,76.94 301.1,76.94 301.55,77.39 304.21,77.39 306.61,79.78 306.61,80.31 308.55,82.25 308.55,82.53 308.83,82.81 309.11,82.81 v1(309.29,83)
