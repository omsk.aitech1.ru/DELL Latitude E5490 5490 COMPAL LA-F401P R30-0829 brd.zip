# Allegro board LAF401PR30-0829.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 247.31,15.46 247.3,15.2 247.3,14.8 246.15,14.8 245.93,14.8 245.71,14.77 242.9,11.74 245.33,8.4 245.74,8.32 246.15,8.3 247.3,8.3 247.3,7.55 246.15,7.55 242.15,11.55 246.15,15.55 247.07,15.55 247.07,15.55 247.32,15.55
GND on BOTTOM (solid shape): outline of 82 points within 0.25,99.54 76.25,119.65
GND on BOTTOM (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.47,100.13 326.45,98.67 326.45,98.67 326.52,98.31 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.57 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.35,100.19 317.3,100.14 317.3,100.12 315.99,98.81 315.66,98.77 315.61,98.43 312.17,94.99 308.18,94.99 306.58,96.59 306.58,109.42 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on BOTTOM (solid shape): outline of 361 points within 73.41,82.88 91.1,101.1
GND on BOTTOM (solid shape): outline of 117 points within 133.28,38.34 288,120.8
GND on BOTTOM (solid shape): outline of 119 points within 1.35,0.25 327.8,32.1
GND on BOTTOM (solid shape): outline of 1058 points within 85.53,90.55 127.64,120.55
GND on BOTTOM (solid shape): outline of 9465 points within 117.47,2.11 189.11,15.7
GND on BOTTOM (solid shape): outline of 10057 points within 36.04,2.56 104.49,25.48
GND on IN1 (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.36,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.4 325.19,40.4 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on IN1 (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 320.4,56.9 320.36,56.93 320.36,56.94 320.14,57.13 319.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
GND on IN1 (solid shape): 15.69,68.61 15.69,66.41 14.51,65.23 5.18,65.23 4.85,64.9 4.48,64.01 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.87,34.96 3.26,34.11 2.75,34.11 2.51,34.6 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 15.07,69.23
GND on IN1 (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.74,99.89 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.35,100.19 312.94,95.78 308.62,95.78 306.58,97.81 306.58,109.42 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on IN1 (solid shape): outline of 93 points within 0.25,79.65 75.39,119.65
GND on IN1 (solid shape): outline of 147 points within 85.53,38.34 288,120.55
GND on IN1 (solid shape): outline of 146 points within 1.35,0.25 327.8,32.72
GND on IN1 (solid shape): outline of 968 points within 95.45,44.34 106.42,55.07
GND on IN1 (solid shape): outline of 2227 points within 40.33,3.19 104.84,11.96
GND on IN1 (solid shape): outline of 2783 points within 141.17,5.73 173.87,15.13
GND on IN2 (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.36,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.4 325.19,40.4 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on IN2 (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 321.19,56.9 320.4,56.9 320.38,56.91 320.14,57.13 319.85,57.2 318.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
GND on IN2 (solid shape): 15.2,69.21 15.75,68.67 15.75,66.31 14.63,65.2 8.64,65.2 8.63,65.21 5.16,65.21 4.85,64.9 4.85,64.9 4.48,64.01 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.87,34.96 3.26,34.11 2.75,34.11 2.51,34.6 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 15.2,69.23
GND on IN2 (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.74,99.89 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.38,100.19 312.86,95.67 308.59,95.67 306.58,97.68 306.58,109.42 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on IN2 (solid shape): outline of 236 points within 28.26,5.58 36.52,20.72
GND on IN2 (solid shape): outline of 88 points within 0.25,79.65 75.39,119.65
GND on IN2 (solid shape): outline of 150 points within 85.53,38.34 288,120.55
GND on IN2 (solid shape): outline of 143 points within 1.35,0.25 327.8,32.72
GND on IN2 (solid shape): outline of 11974 points within 38.74,3.83 185.81,23.01
GND on IN3 (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.36,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.4 325.19,40.4 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on IN3 (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 320.4,56.9 320.36,56.93 320.36,56.94 320.14,57.13 319.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
GND on IN3 (solid shape): 14.12,69.23 15.19,69.23 15.76,68.66 15.76,66.32 14.64,65.21 5.16,65.21 4.85,64.9 4.48,64.01 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.87,34.96 3.26,34.11 2.75,34.11 2.51,34.6 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 14.12,69.23
GND on IN3 (solid shape): outline of 239 points within 28.26,9.99 36.52,20.72
GND on IN3 (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.74,99.89 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.38,100.19 312.97,95.78 308.62,95.78 307.08,97.31 307.08,108.92 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on IN3 (solid shape): outline of 90 points within 0.25,79.65 75.39,119.65
GND on IN3 (solid shape): outline of 150 points within 85.53,38.34 288,120.55
GND on IN3 (solid shape): outline of 139 points within 1.35,0.25 327.8,32.72
GND on IN3 (solid shape): outline of 2798 points within 120.34,3.83 185.81,8.78
GND on IN3 (solid shape): outline of 2941 points within 81.43,3.83 176.41,23.01
GND on IN3 (solid shape): outline of 3413 points within 38.74,3.83 79.22,23.01
GND on IN3 (solid shape): outline of 3313 points within 78.75,36.78 106.53,54.18
GND on IN4 (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.36,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.41 325.19,40.41 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on IN4 (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 320.4,56.9 320.36,56.93 320.36,56.94 320.14,57.13 319.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
GND on IN4 (solid shape): 15.7,68.61 15.7,66.38 14.56,65.24 5.19,65.24 4.85,64.9 4.48,64.01 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.87,34.96 3.26,34.11 2.75,34.11 2.51,34.6 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 15.08,69.23
GND on IN4 (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.74,99.89 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.25,100.19 314.11,97.05 314.08,97.05 312.81,95.78 308.62,95.78 306.58,97.81 306.58,109.42 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on IN4 (solid shape): outline of 92 points within 0.25,79.65 75.39,119.65
GND on IN4 (solid shape): outline of 147 points within 85.53,38.34 288,120.55
GND on IN4 (solid shape): outline of 858 points within 120.91,9.29 143.58,11.96
GND on IN4 (solid shape): outline of 925 points within 120.21,5.86 146.63,8.27
GND on IN4 (solid shape): outline of 952 points within 1.35,0.25 327.8,32.72
GND on IN4 (solid shape): outline of 1680 points within 41.22,3.07 58.74,21.29
GND on IN4 (solid shape): outline of 1684 points within 62.17,5.23 79.57,21.29
GND on TOP: 127.42,55.94 127.79,55.94 128.02,55.71 128.46,55.71 128.6,55.57 128.6,55.37 128.21,54.98 127.41,54.98 127.39,55 127.39,55.92
GND on TOP: 132.57,39.14 133.98,39.14 134.24,39.39 135.24,39.39 135.36,39.27 135.36,38.1 135.27,38.01 134.97,38.01 134.9,38.08 134.9,38.46 134.77,38.59 132.58,38.59 132.56,38.6 132.56,39.12
GND on TOP: 127.15,32.92 128.41,32.92 128.68,32.65 128.68,32.38 128.48,32.18 128.11,32.18 127.96,32.03 127.96,31.39 127.89,31.32 127.26,31.32 127.11,31.47 127.11,32.89
GND on TOP: 148.81,60.89 149.21,60.89 149.49,60.62 149.49,59.47 149.36,59.34 149.16,59.34 148.77,59.73 148.77,60.85
GND on TOP: 125.43,58.76 125.7,58.76 126.13,58.33 127.05,58.33 127.07,58.35 127.07,59.25 127.07,59.25 127.07,59.32 127.29,59.54 127.29,59.78 127.18,59.89 126.96,59.89 126.83,59.76 126.83,59.58 126.55,59.3 125.43,59.3 125.39,59.26 125.39,58.8
GND on BOTTOM: 135.69,83.27 135.79,83.27 136.31,83.55 136.38,83.62 136.38,83.87 135.77,84.48 134.09,84.48 133.83,84.22 132.88,84.22 132.76,84.1 132.76,83.56 133.13,83.19 134.1,83.19 134.72,83.81 135.15,83.81
GND on BOTTOM: 154.11,51.97 153.13,51.97 152.98,51.82 151.99,51.82 151.97,51.8 151.97,51.17 152.15,50.99 153.25,50.99 154.17,50.07 155.11,50.07 155.12,50.09 155.12,50.66 154.97,50.82 154.37,50.82 154.13,51.06 154.13,51.95
GND on GND1: outline of 328 points within 0.25,0.25 327.8,120.55 ; 1 cut-out
GND on GND2: outline of 333 points within 0.25,0.25 327.8,120.55 ; 1 cut-out
GND on VCC: 72.52,105.43 71.76,106.19 63.43,106.19 62.11,107.51 62.11,110.31 62.22,110.6 62.25,110.9 62.26,111.26 62.31,111.54 62.48,111.88 63.02,112.44 63.02,112.46 63.24,112.68 63.62,113.25 63.75,113.92 63.75,115.24 63.76,115.24 63.76,119.65 72.85,119.65 72.85,118.49 73.35,117.99 73.35,109.45 73.81,108.76 74.63,108.91 74.92,109.2 86.18,109.2 86.48,108.91 87.29,108.76 87.75,109.45 87.75,117.99 88.25,118.49 88.25,119.65 95.05,119.65 95.05,113.52 94.76,113.23 94.77,112.17 95.83,112.16 96.12,112.45 109.98,112.45 110.27,112.16 111.33,112.17 111.34,113.23 111.05,113.52 111.05,119.15 116.8,119.15 117.29,119.24 117.7,119.53 119,119.53 119,115.69 111.98,108.67 90.49,108.67 89.22,107.4 86.05,107.4 84.08,105.43
GND on VCC: 2.37,1.27 2.37,14.68 10.75,14.68 12.14,16.06 12.14,23.86 12.41,24.13 42.09,24.13 50.17,32.21 50.17,33.06 53.32,36.21 53.96,36.21 54.49,36.74 54.49,38.01 56.12,39.64 58.66,39.64 58.86,39.84 64.36,45.32 72.4,53.36 72.4,53.99 87.64,53.99 90.11,56.47 90.11,56.98 101.1,56.98 104.21,53.87 113.51,53.87 114.88,52.49 118.82,52.49 119.44,53.11 127.55,53.11 127.56,53.1 134.29,53.1 138.27,53.1 141.7,49.68 146.92,49.68 147.37,50.12 150.27,50.12 151.83,48.55 151.83,43.66 153.57,41.92 160.21,41.92 172.06,30.07 172.06,28.72 173.69,27.08 175.04,27.08 179.95,22.18 179.95,20.23 181.97,18.21 181.97,16.7 185.74,12.92 185.74,5.74 185.74,5.74 185.74,4.03 184.97,3.26 169.26,3.26 168.59,2.6 168.59,1.32 168.56,1.29 167.42,1.29 167.42,1.75 167.28,2.59 166.87,3.35 163.78,4.33 161.88,1.7 161.88,1.27 116.42,1.27 116.42,2.1 113.15,5.37 109.88,2.1 109.88,1.27 13.22,1.27 13.22,1.75 10.7,4.27 8.18,1.75 8.18,1.27
GND on VCC: outline of 85 points within 266.92,57.92 325.53,117.73
GND on VCC: 83.95,61.61 88.14,57.42 89.29,57.42 89.6,57.1 89.6,56.72 87.38,54.5 72.4,54.5 72.4,61.61
GND on VCC: 3.06,109.65 13.15,109.65 19.06,103.74 19.06,102.06 16.26,99.27 16.26,79.01 18.1,77.17 18.1,67.01 16.26,65.17 4.34,65.17 4.34,67.4 13.37,67.4 14.06,67.85 13.91,68.67 13.61,68.98 13.61,79.82 13.91,80.13 14.06,80.95 13.37,81.4 4.34,81.4 4.34,84.8 4.12,85.33 3.59,85.55 1.15,85.55 1.15,88.23 1.44,88.52 1.62,89.26 1.07,89.78 1.06,89.79 0.25,89.98 0.25,92.1 3.93,92.1 4.22,91.81 5.04,91.66 5.5,92.35 5.5,94.89 5.61,95.37 5.92,95.76 5.94,95.86 5.96,95.96 5.93,96.29 5.99,96.61 5.97,96.88 6,97.14 5.96,97.46 6,97.77 5.97,98.06 6.01,98.35 5.97,98.64 6,98.93 5.98,99 5.97,99.08 5.63,99.47 5.5,99.98 5.5,101.75 5.04,102.44 4.22,102.29 3.93,102 0.25,102 0.25,104.12 1.06,104.31 1.07,104.32 1.62,104.84 1.44,105.58 1.15,105.87 1.15,108.31 1.15,108.31 1.15,108.9 1.37,109.43 1.9,109.65 3.06,109.65
GND on VCC: 295.26,32.02 295,32.28 294.62,32.28 294.52,32.38 294.52,32.93 296.04,34.46 296.04,38.65 296.53,39.13 300.36,39.13 300.36,39.06 300.23,38.93 300.23,37.81 300.43,37.61 301.56,37.61 301.76,37.81 301.76,38.57 302.06,38.88 302.7,38.88 303.15,39.34 303.15,39.84 303.71,40.4 305.82,40.4 305.82,38.22 305.59,37.99 304.45,37.99 304.17,37.72 304.17,37.54 303.36,36.72 303.01,36.72 302.88,36.85 302.16,36.85 301.76,36.45 301.76,33.27 301.65,33.17 297.21,33.17 296.32,32.28 295.94,32.28 295.68,32.02
GND on GND3: outline of 277 points within 0.25,0.25 327.8,120.55 ; 1 cut-out
GNDA on TOP (solid shape): 320.03,39.28 320.03,38.19 319.83,37.99 318.2,37.99 318.08,38.12 318.08,39.39 318.14,39.45 319.85,39.45
GNDA on TOP (solid shape): 308.42,34.38 308.42,33.8 309.12,33.1 310.9,33.1 310.9,33.1 312.87,33.1 313.19,32.78 313.19,32.02 312.87,31.7 310.46,31.7 310.14,31.39 309.25,31.39 308.87,31.77 307.6,31.77 307.28,32.09 307.28,34.5 307.41,34.63 308.18,34.63
GNDA on TOP (solid shape): 305.63,42.5 306.14,42.5 306.14,43.07 306.52,43.07 306.65,42.94 308.62,42.94 308.62,42.5 308.42,42.31 307.35,42.31 306.84,41.8 306.84,41.17 306.33,40.66 305.76,40.66 305.57,40.85 305.57,41.55 305.31,41.8 303.79,41.8 303.15,41.17 303.15,40.98 302.58,40.98 302.52,41.04 302.52,41.8 302.58,41.86 303.09,41.86 303.47,42.25 303.47,42.82 303.73,43.07 305.63,43.07
GNDA on TOP (solid shape): 303.66,32.85 303.67,32.85 304.1,32.85 304.18,32.81 304.2,32.73 304.21,32.56 304.28,32.42 304.3,32.4 304.42,32.28 304.93,32.28 305.12,32.09 305.12,31.45 305.06,31.39 303.85,31.39 303.28,31.96 303.28,32.59 302.86,33.01 302.26,33.01 302.2,33.07 302.2,33.17 302.27,33.23 303.28,33.23
GNDA on GND1: outline of 89 points within 293.5,27.2 327.8,43.21
GNDA on GND2: outline of 89 points within 293.5,27.2 327.8,43.45
GNDA on VCC: outline of 93 points within 293.5,27.2 326.78,43.45
GNDA on GND3: 314.66,27.27 313.52,28.41 312.4,28.41 311.71,29.1 310.37,29.1 310.2,29.27 310.2,34.73 309.74,35.2 304.85,35.2 304.61,35.43 304.61,37.06 304.78,37.23 307.45,37.23 307.79,37.57 307.79,39.85 307.96,40.02 309.93,40.02 310.58,40.68 310.58,41.57 311.2,42.18 311.71,42.18 313.15,40.74 325.7,40.74 325.7,39.25 327.8,39.25 327.8,37.8 315.55,37.8 314.81,37.18 315.3,36.34 315.3,30.96 314.81,30.12 315.55,29.5 327.8,29.5 327.8,27.27
VCCSA_B+ on BOTTOM (solid shape): 74.74,89.05 74.74,86.7 72.2,86.7 71.71,86.2 70.38,86.2 70.17,86.41 70.17,88.08 71.57,88.08 71.57,87.6 71.9,87.27 72.7,87.27 72.84,87.4 72.84,87.95 72.45,88.35 71.83,88.35 71.57,88.08 70.17,88.08 70.17,88.28 70.43,88.54 71.25,88.54 71.44,88.73 71.44,89.17 72.01,89.17 72.01,89.68 71.44,89.68 71.44,90 71.51,90.06 73.73,90.06
VIN_1.8VALW on TOP (solid shape): 124.4,110.19 125.67,110.19 125.82,110.04 125.82,108.29 125.73,108.2 124.36,108.2 124.15,107.99 123.74,107.99 123.64,108.1 123.64,108.68 123.64,108.68 123.64,108.92 122.69,109.87 122.69,110.89 123.7,110.89
VIN_1V_PRIM on TOP (solid shape): 134.43,116.99 133.91,116.46 133.91,114.97 133.64,114.71 131.88,114.71 131.2,114.03 131.2,113.24 131.16,113.2 129.82,113.2 129.68,113.33 129.68,116.68 129.78,116.78 130.27,116.78 130.43,116.61 130.43,116.45 130.52,116.36 132.79,116.36 132.97,116.54 132.97,117.81 133.1,117.94 134.43,117.94
VIN_1VS_VCCIO on TOP (solid shape): 137.86,116.22 137.86,114.65 138.3,114.22 138.36,114.22 140.03,114.22 140.23,114.01 140.23,113.87 140.44,113.67 141.95,113.67 141.99,113.63 141.99,112.44 141.61,112.06 141.61,110.89 141.56,110.84 139.3,110.84 139.25,110.89 138.82,110.89 138.44,111.27 138.44,112.54 137.86,113.11 137.36,113.11 137,113.47 137,114.93 136.66,115.27 136.66,116.29 136.78,116.41 137.67,116.41
+AC_IN on TOP (solid shape): 7.26,54.6 7.35,54.6 7.36,54.58 7.66,54.58 7.67,54.57 7.67,54.07 7.7,54.05 8.01,54.05 8.02,54.04 8.55,54.04 8.56,54.05 8.64,54.05 8.64,54.13 8.65,54.14 8.65,54.6 8.85,54.6 8.88,54.57 8.88,54.07 8.9,54.05 9.22,54.05 9.23,54.04 9.76,54.04 9.77,54.05 9.84,54.05 9.84,54.12 9.85,54.13 9.85,54.6 10.12,54.6 10.13,54.59 10.85,54.59 11.81,53.63 12.44,53 13.71,53 13.71,53 13.96,53 14.1,52.85 14.1,51.88 14.28,51.71 14.28,49.45 14.23,49.4 13.72,49.4 13.27,49.85 11.8,49.85 11.59,50.06 10.99,50.06 10.86,50.18 10.86,50.88 10.74,51.01 10.25,51.01 9.94,51.31 6.56,51.31 6.14,51.74 6.14,54.18 6.1,54.22 6.1,54.44 6.28,54.61 7.26,54.61
+BL_PWR_SRC on BOTTOM (solid shape): 108.44,92.74 108.44,91.53 109,90.98 109,89.2 109,88.38 109,88.26 109,87.5 109,87.39 109.39,86.99 109.39,84.89 109.4,84.88 109.4,84.76 109.53,84.63 109.53,84.58 109.58,84.58 109.6,84.56 109.69,84.56 109.7,84.57 110.14,84.57 110.6,84.11 110.6,80.72 110.09,80.21 108.66,80.21 108.53,80.33 108.53,82.34 108.66,82.48 108.66,84.11 108.11,84.67 107.52,84.67 107.38,84.81 107.38,89.22 107.17,89.43 107.17,92.75 107.22,92.8 108.38,92.8
+CHARGER_SRC on TOP (solid shape): 7,26.1 7,22.43 10.44,18.99 10.44,15.82 10.26,15.64 6.55,15.64 6.39,15.79 6.39,17.49 5.66,18.23 5.66,26.05 5.78,26.18 6.93,26.18
+CHARGER_SRC on BOTTOM (solid shape): outline of 87 points within 5.64,17.29 11.18,29.28
+CHARGER_SRC on IN4 (solid shape): 11.17,29.1 11.17,24.74 11.09,24.66 10.14,24.66 10.08,24.71 10.08,26.17 10.11,26.2 10.11,26.98 9.95,27.14 8.2,27.14 7.14,26.08 7.14,21.41 6.56,20.83 5.77,20.83 5.66,20.93 5.66,28.93 6.03,29.29 10.98,29.29
+CRT_VCC on TOP (solid shape): 282.58,54.54 282.58,53.28 282.48,53.18 281.53,53.18 281.38,53.02 281.14,53.02 280.99,53.17 280.99,53.81 281.34,54.16 281.35,54.23 281.36,54.3 281.78,54.71 282.41,54.71
+CRT_VCC on BOTTOM (solid shape): 319.92,78.73 319.92,78.15 320.1,77.97 320.22,77.97 320.25,77.95 320.25,76.95 320,76.95 319.77,76.73 318.19,76.73 318.09,76.83 318.09,77.31 317.78,77.62 316.84,77.62 316.84,78.09 318.18,79.42 318.18,80.05 318.59,80.05
+CRT_VCC on IN1 (solid shape): 319,81.65 319,77.89 318.7,77.59 317.76,77.59 316.74,78.61 316.74,80.58 318.14,80.58 318.14,80.52 318.15,80.47 318.17,80.42 318.2,80.37 318.23,80.33 318.27,80.3 318.32,80.27 318.37,80.24 318.42,80.23 318.47,80.22 318.52,80.22 318.58,80.23 318.63,80.24 318.67,80.27 318.72,80.3 318.76,80.33 318.79,80.37 318.82,80.42 318.84,80.47 318.85,80.52 318.85,80.58 318.85,80.63 318.84,80.68 318.82,80.73 318.79,80.78 318.76,80.82 318.72,80.85 318.67,80.88 318.63,80.91 318.58,80.92 318.52,80.93 318.47,80.93 318.42,80.92 318.37,80.91 318.32,80.88 318.27,80.85 318.23,80.82 318.2,80.78 318.17,80.73 318.15,80.68 318.14,80.63 318.14,80.58 316.74,80.58 316.75,80.68 316.76,80.7 316.82,80.71 316.87,80.71 316.92,80.73 316.97,80.75 317.01,80.78 317.05,80.82 317.09,80.86 317.11,80.91 317.13,80.96 317.15,81.01 317.15,81.06 317.15,81.11 317.13,81.17 317.11,81.22 317.09,81.26 317.05,81.31 317.01,81.34 316.97,81.37 316.92,81.39 316.87,81.41 316.82,81.42 316.76,81.43 316.75,81.44 316.74,81.47 316.74,81.96 317.34,82.57 318.08,82.57
+CRT_VCC on IN1 (solid shape): outline of 571 points within 272.1,53.14 282.36,80.16
+CRT_VCC on IN3 (solid shape): outline of 272 points within 314.77,73.46 318.79,80.24
+DC_IN on TOP (solid shape): 53.09,94.03 53.09,91.81 53.12,91.77 53.11,91.74 53.18,91.33 53.58,91.27 53.62,91.28 54.47,90.43 54.47,88.71 54.3,88.54 53.22,88.54 52.9,88.85 51.57,88.85 51.57,89.24 51.44,89.36 50.36,89.36 50.11,89.11 48.51,89.11 48.38,89.24 48.38,89.88 48.56,90.06 49.03,90.06 49.53,90.56 49.53,94.05 49.74,94.25 52.86,94.25
+DC_IN on BOTTOM (solid shape): 72.97,101.45 72.97,100.95 72.62,100.6 70.93,100.6 70.74,100.79 70.74,101.55 70.93,101.75 72.67,101.75
+DC_IN_SS on TOP (solid shape): 47.68,88.82 49.85,88.82 50.15,88.51 50.17,88.51 50.17,87.2 50.55,86.82 52.71,86.82 52.84,86.7 52.84,85.46 52.46,85.08 52.46,83.23 51.16,81.93 49.15,81.93 48.7,82.39 48.7,84.93 48.37,85.26 47.53,85.26 47.38,85.41 47.38,86.68 46.87,87.19 42.92,87.19 42.67,87.44 42.67,88.75 42.96,89.05 47.45,89.05
+DCIN_JACK on TOP (solid shape): 57.37,91.75 57.37,87.94 56.83,87.39 55,87.39 54.67,87.72 54.67,91.84 54.83,91.99 57.13,91.99
+DCIN_JACK on BOTTOM (solid shape): 57.27,91.56 57.27,87.84 56.63,87.2 54.39,87.2 53.82,87.77 53.82,91.42 54.26,91.85 56.97,91.85
+EDP_VDD on BOTTOM (solid shape): 100.31,84.73 100.31,84.23 100.32,84.22 100.32,84.2 100.34,84.2 100.35,84.19 100.74,84.19 100.78,84.15 100.78,83.5 100.75,83.42 100.75,83.35 100.75,83.3 100.58,83.13 99.18,83.13 98.78,83.53 97.56,83.53 97.36,83.73 97.36,84.07 97.56,84.27 97.85,84.27 98.1,84.52 99.24,84.52 99.59,84.17 100.08,84.17 100.11,84.2 100.11,84.73 100.14,84.76 100.28,84.76
+LCDVDD on BOTTOM (solid shape): 101.94,92.71 101.94,91.61 102.81,90.73 102.81,90.25 103,90.06 103.07,90.06 103.07,89.68 103,89.62 102.75,89.62 102.43,89.3 102.43,88.09 102.24,87.9 102.05,87.9 101.61,87.46 101.21,87.46 100.84,87.09 100.84,86.68 100.97,86.56 101.35,86.56 101.43,86.48 101.43,84.59 101.16,84.32 100.47,84.32 100.44,84.35 100.44,84.78 100.43,84.79 100.43,84.88 100.42,84.89 100.33,84.89 100.33,84.89 100.08,84.89 100.08,84.89 100,84.89 99.98,84.87 99.98,84.33 99.97,84.32 99.71,84.32 99.37,84.66 99.37,87.13 100.27,88.03 100.27,89.43 101.03,90.19 101.26,90.19 101.48,90.41 101.48,90.72 101.15,91.05 101.15,92.71 101.22,92.79 101.86,92.79
+LINE1-VREFO-L on TOP (solid shape): 305.76,36.59 305.76,36.47 305.25,35.96 304.55,35.96 303.98,35.39 302.27,35.39 302.2,35.46 302.2,35.58 302.27,35.64 302.43,35.64 302.53,35.59 302.65,35.57 303.54,35.57 303.54,35.57 303.66,35.57 303.66,35.58 303.79,35.58 304.42,36.21 304.8,36.21 305,36.4 305,36.59 305.31,36.91 305.44,36.91
+LINE1-VREFO-R on TOP (solid shape): 305.76,35.32 305.76,35.2 305.44,34.88 305.19,34.88 305.07,34.99 305.07,35.05 304.73,35.39 304.37,35.09 304.36,35.07 304.3,35.01 302.26,35.01 302.2,35.07 302.2,35.16 302.26,35.23 303.14,35.23 303.18,35.2 303.98,35.2 304.55,35.77 305.31,35.77
+MIC2-VREFO on BOTTOM (solid shape): 311.05,37.84 311.05,37.41 310.49,36.85 310.01,36.85 309.96,36.9 309.96,38.4 310.49,38.4
+PBATT on TOP (solid shape): 30.8,4.23 30.8,1.92 30.68,1.8 23.31,1.8 23.12,1.99 23.12,4.16 23.38,4.42 30.62,4.42
+PWR_SRC on TOP (solid shape): 178.41,100.04 178.41,99.36 177.6,98.54 175.62,98.54 175.42,98.75 175.42,99.99 175.6,100.17 178.29,100.17
+PWR_SRC on TOP (solid shape): 162.06,117.89 162.06,112.92 161.99,112.86 161.49,112.86 161.23,113.11 159.97,113.11 159.97,113.61 159.43,113.61 159.42,113.62 159.42,113.83 159.43,113.85 159.97,113.85 159.97,114.39 159.43,114.4 159.41,114.42 159.41,114.64 159.42,114.65 159.96,114.65 159.96,115.27 159.82,115.41 159.29,115.41 159.03,115.66 159.03,116.26 158.56,116.73 158.56,118.08 158.95,118.46 161.49,118.46
+PWR_SRC on TOP (solid shape): outline of 1311 points within 27.87,7.49 79.63,97.3
+PWR_SRC on BOTTOM (solid shape): 108.16,83.9 108.16,82.69 107.86,82.39 107.4,82.39 107.23,82.57 105.14,82.57 105.14,83.4 105.36,83.62 106.51,83.62 106.52,83.63 106.57,83.63 107.1,84.16 107.9,84.16
+PWR_SRC on BOTTOM (solid shape): 178.06,99.56 178.06,98.63 177.93,98.51 175.71,98.51 175.58,98.63 175.58,99.52 175.71,99.65 177.97,99.65
+PWR_SRC on BOTTOM (solid shape): 44.61,61.07 45.37,61.07 45.37,61.61 45.83,61.61 45.83,61.07 46.58,61.07 46.58,61.61 51.88,61.61 52.14,61.36 52.14,56.53 52.01,56.41 43.06,56.41 42.8,56.66 42.8,61.36 43.06,61.61 44.61,61.61
+PWR_SRC on BOTTOM (solid shape): 81.16,96.92 81.16,96.16 81.03,96.03 80.02,96.03 79.57,95.59 79.57,94.82 79.38,94.63 77.79,94.63 77.54,94.89 77.54,95.26 77.35,95.45 76.36,95.45 76.13,95.67 76.13,96.87 76.43,97.17 80.9,97.17
+PWR_SRC on BOTTOM (solid shape): 161.1,119.36 161.1,118.26 160.79,117.94 160.79,116.99 160.81,116.97 161.33,116.97 161.35,116.95 161.35,116.73 161.33,116.71 160.81,116.71 160.79,116.68 160.79,116.2 160.81,116.17 161.34,116.17 161.36,116.16 161.36,115.92 161.34,115.91 160.8,115.91 160.79,115.9 160.79,115.49 160.77,115.47 160.79,115.46 160.79,114.83 161.17,114.45 161.17,113.87 161.1,113.81 159.64,113.81 159.39,114.06 159.39,115.46 159.01,115.84 159.01,116.29 158.44,116.86 158.44,118 159.01,118.57 159.39,118.57 159.58,118.76 159.58,119.33 159.68,119.44 161.03,119.44
+PWR_SRC on BOTTOM (solid shape): 36.83,17.19 36.83,12.13 35.75,11.04 35.75,9.79 35.49,9.52 32.89,9.52 32.59,9.22 32.59,7.67 32.49,7.57 30.58,7.57 30.42,7.73 30.42,12.08 29.68,12.82 28.79,12.82 28.61,13 28.61,14.61 28.39,14.83 24.61,14.83 24.41,15.04 24.41,15.28 30.97,15.28 30.97,14.64 31.19,14.42 31.51,14.42 31.73,14.64 31.73,15.28 31.78,15.28 31.78,16.02 32.1,16.02 32.1,15.35 32.27,15.18 34.14,15.18 34.38,15.42 34.38,15.96 34.17,16.16 32.25,16.16 32.22,16.14 32.19,16.14 32.19,16.1 32.1,16.02 31.78,16.02 31.78,16.14 30.92,16.14 30.92,15.28 24.41,15.28 24.41,17.28 24.59,17.46 36.57,17.46
+PWR_SRC on IN1 (solid shape): outline of 441 points within 76.52,82.44 109.35,96.73
+PWR_SRC on IN2 (solid shape): outline of 18105 points within 3.43,7.53 164.66,118.38
+PWR_SRC on IN3 (solid shape): outline of 18815 points within 4.32,9.73 184.41,118.38
+PWR_SRC_AC on BOTTOM (solid shape): 8.9,17.67 8.9,17.16 8.92,17.14 9.58,17.14 9.63,17.19 9.63,17.67 9.66,17.7 10.06,17.7 10.09,17.67 10.09,17.19 10.11,17.16 10.86,17.16 10.98,17.05 10.98,15.51 10.98,15.51 10.98,13.79 10.32,13.13 8.72,13.13 7.34,11.75 5.09,11.75 4.88,11.96 4.88,13.28 4.63,13.53 2.85,13.53 2.75,13.63 2.75,15.97 2.88,16.1 5.12,16.1 5.12,15.55 5.48,15.19 5.84,15.55 5.84,16.1 6.1,16.1 7.17,17.16 8.36,17.16 8.41,17.21 8.41,17.67 8.44,17.7 8.87,17.7
+PWR_SRC_L on TOP (solid shape): 222.4,7.31 223.45,7.31 223.55,7.21 223.55,6.75 223.34,6.55 221,6.55 220.89,6.65 220.89,7.52 220.99,7.62 222.09,7.62
+REGCTL_PNP10 on TOP (solid shape): 284.1,87.04 284.1,85.74 283.98,85.62 283.22,85.62 283.16,85.67 282.58,85.67 282.45,85.7 282.33,85.67 280.8,85.67 280.68,85.79 280.68,85.87 280.8,86 282.12,86 282.61,86.13 282.47,86.62 282.41,86.68 282.41,86.93 282.65,87.17 283.97,87.17
+RTC_CELL_PCH on TOP (solid shape): 321.83,65.83 321.83,64.83 321.8,64.8 320.83,64.8 320.71,64.93 320.07,64.93 320.02,64.97 320.02,65.5 320.07,65.54 320.7,65.54 320.94,65.78 320.94,66.11 321.07,66.23 321.43,66.23
+RTC_CELL_PCH on TOP: 126.62,52.96 126.25,52.96 126.23,52.98 126.23,53.24 125.89,53.58 125.89,53.9 126.3,54.31 126.64,54.31 126.78,54.45 126.78,55.89 126.82,55.93 127.23,55.93 127.25,55.91 127.25,54.96 127.16,54.87 127.16,54.36 126.66,53.86 126.66,53.01
+SDC_IN on TOP (solid shape): 8.9,46.75 10.29,46.75 10.55,46.5 10.55,44.72 10.42,44.6 9.62,44.6 9.5,44.47 9.5,43.04 9.66,42.88 9.66,41.42 9.53,41.29 7.63,41.29 6.74,42.18 3.43,42.18 2.8,42.82 2.8,46.88 3.43,47.52 8.13,47.52
+SDC_IN on TOP (solid shape): outline of 317 points within 17.43,57.75 48.29,86.7
+SDC_IN on BOTTOM (solid shape): 6.74,19.89 6.74,17.29 6.53,17.09 5.84,17.09 5.84,17.63 5.48,17.99 5.12,17.63 5.12,17.09 2.88,17.09 2.74,17.23 2.74,20.02 2.86,20.15 6.48,20.15
+SDC_IN on IN1 (solid shape): outline of 319 points within 2.55,41.42 24.14,62.38
+SDC_IN on VCC: 2.37,15.18 2.37,24.32 3.38,24.94 3.77,26.05 3.77,34.05 3.51,34.97 2.82,35.62 2.82,35.62 2.42,35.77 2,35.82 1.72,35.82 1.72,36.37 1.72,47.59 8.53,47.59 9.71,46.41 9.71,37.9 11.63,35.98 11.63,16.27 10.54,15.18
+SDREG2 on TOP (solid shape): 24.16,48.68 24.16,48.61 24.01,48.46 24.01,48.15 23.22,47.36 21.98,47.36 21.74,47.13 21.07,47.13 21.04,47.17 21.04,48.11 21.07,48.14 21.83,48.14 21.92,48.05 21.93,48.05 22.05,47.92 23.14,47.92 23.35,48.13 23.35,48.53 23.3,48.58 23.3,48.68 23.37,48.76 24.08,48.76
+TBTA_VBUS on TOP (solid shape): 14.74,87.2 14.74,84.79 11.82,84.79 11.12,85.49 11.12,87.46 11.56,87.9 14.04,87.9
+TBTA_VBUS on TOP (solid shape): 10.74,96.09 10.74,95.2 10.61,95.08 9.47,95.08 9.15,95.4 8.07,95.4 8.07,96.16 8.26,96.35 10.48,96.35
+TBTA_VBUS on TOP (solid shape): 11.18,98.79 11.18,97.81 10.95,97.58 7.59,97.58 7.04,98.13 6.67,98.13 6.55,98.25 6.55,98.44 6.67,98.57 7.12,98.57 7.45,98.24 8.48,98.24 8.75,98.51 9.45,98.51 9.53,98.58 9.53,98.76 9.69,98.92 11.05,98.92
+TBTA_VBUS on BOTTOM (solid shape): 15.64,89.54 15.64,89.16 15.63,89.06 15.64,88.95 15.64,88.8 15.65,88.79 15.65,88.78 16.26,88.17 16.26,84.98 16.13,84.85 12.26,84.85 10.98,86.14 10.98,88.69 11.49,89.2 14.07,89.2 14.48,89.62 15.56,89.62
+TBTA_VBUS on BOTTOM (solid shape): 8.34,96.4 9.63,96.4 9.64,96.39 10.46,96.39 10.85,96 10.85,95.4 10.52,95.06 9.51,95.06 8.85,95.73 7.19,95.73 6.99,95.52 6.99,95.34 6.89,95.24 6.51,95.24 6.48,95.27 6.48,95.4 6.46,95.42 6.46,95.57 6.79,95.57 7.02,95.8 7.02,95.95 7.14,96.08 8.02,96.08 8.34,96.4
+TBTA_VBUS on BOTTOM (solid shape): 11.21,98.9 11.21,98.57 10.5,97.86 9.4,97.86 9.06,98.2 7.11,98.2 6.99,98.09 6.56,98.09 6.53,98.06 5.92,98.06 5.9,98.09 5.9,98.29 6.32,98.29 6.5,98.47 6.5,98.48 6.61,98.6 6.84,98.6 6.89,98.64 8.93,98.64 9.39,99.1 11,99.1
+TBTA_VBUS on IN1 (solid shape): outline of 566 points within 6.52,85.17 14.67,99.08
+TBTA_VBUS on IN2 (solid shape): outline of 438 points within 7.14,85.36 15.43,99.08
+TBTA_VBUS on IN3 (solid shape): outline of 710 points within 6.51,84.98 15.5,99.05
+TBTA_VBUS_1 on TOP (solid shape): 47.78,99.14 47.78,96.88 47.4,96.5 46.5,96.5 46.09,96.92 46.09,97.79 45.78,98.1 45.78,99.11 46.14,99.47 47.45,99.47
+TBTA_VBUS_1 on TOP (solid shape): 19.75,86.91 20.58,86.91 21.39,86.1 21.39,83.77 20.91,83.29 18.64,83.29 18.23,83.71 18.23,84.53 17.98,84.77 15.39,84.77 15.03,85.13 15.03,86.73 15.56,87.25 19.41,87.25
+TBTA_VBUS_1 on TOP (solid shape): 36.16,78.48 36.32,78.48 36.78,78.02 36.78,77.63 36.82,77.59 36.82,76.88 37.1,76.6 37.47,76.6 37.47,75.71 37.28,75.52 36.24,75.52 36.01,75.75 36.01,76.43 35.8,76.64 35.8,77.98 35.43,78.35 34.58,78.35 34.47,78.46 34.47,78.54 34.61,78.68 35.96,78.68
+TBTA_VBUS_1 on TOP (solid shape): 31.39,78.62 31.39,78.51 31.4,78.47 31.51,78.32 31.69,78.29 31.72,78.29 31.76,78.26 31.76,76.96 31.55,76.75 31.43,76.75 31.29,76.62 30.6,76.62 30.33,76.89 30.33,77.87 30.39,77.96 30.4,78.06 30.39,78.09 30.45,78.15 30.57,78.26 30.73,78.26 30.91,78.44 30.91,78.61 31,78.7 31.32,78.7
+TBTA_VBUS_1 on TOP (solid shape): 15.17,57.98 15.17,55.73 15.02,55.59 14.97,55.39 15,55.25 15.08,55.13 15.17,55.04 15.17,53.49 14.83,53.15 12.66,53.15 11.08,54.73 9.74,54.73 9.72,54.71 9.72,54.18 9.71,54.17 9.28,54.17 9.26,54.19 9.26,54.69 9.23,54.73 8.53,54.73 8.52,54.71 8.52,54.19 8.5,54.17 8.07,54.17 8.05,54.19 8.05,54.68 8.04,54.7 8.02,54.7 8.02,54.71 7.42,54.71 7.37,54.76 7.37,57.93 7.88,58.44 14.71,58.44
+TBTA_VBUS_1 on BOTTOM (solid shape): outline of 108 points within 35.23,87.78 48,98.14
+TBTA_VBUS_1 on BOTTOM (solid shape): outline of 296 points within 16.64,74.95 37.22,89.26
+TBTA_VBUS_1 on IN1 (solid shape): outline of 798 points within 9.48,56.03 24.03,85.07
+TBTA_VBUS_1 on IN2 (solid shape): outline of 1148 points within 29.79,75.65 37.22,89.36
+USB_EX2_PWR on TOP (solid shape): 20.59,78.5 21.2,78.5 21.2,78.5 21.72,78.5 21.98,78.25 21.98,75.84 21.72,75.58 17.66,75.58 16.13,77.11 15.63,77.11 15.05,77.68 15.05,78.06 15.5,78.5 20.59,78.5
+USB_EX3_PWR on BOTTOM (solid shape): 88.03,105.29 88.03,103.38 88.19,103.22 89.24,103.22 89.49,102.96 89.49,101.12 89.47,101.1 85.72,101.1 85.6,101.21 85.6,101.89 85.78,102.08 86.38,102.08 86.56,102.25 86.56,103.07 86.43,103.19 85.54,103.19 83.32,105.42 83.32,107.21 83.83,107.71 85.61,107.71
+UZ12_TPM on TOP (solid shape): 173.26,42.11 173.26,41.55 173.16,41.45 173.16,39.47 172.69,39.01 170.31,39.01 170.31,39.26 170.38,39.26 170.5,39.39 170.5,39.58 170.63,39.71 172.13,39.71 172.37,39.95 172.37,41.39 172.5,41.52 172.5,42.03 172.73,42.26 173.11,42.26
+UZ12_VHIO on TOP (solid shape): 170.74,43.2 170.74,42.33 170.62,42.21 170.62,41.65 170.45,41.48 168.66,41.48 168.03,42.12 167.77,42.12 167.14,41.48 167.14,41.1 166.45,40.42 166.45,39.57 166.4,39.52 166.25,39.52 166.2,39.57 166.2,40.51 166.02,40.68 164.88,40.68 164.6,40.4 163.58,40.4 163.43,40.56 163.43,41.48 163.68,41.74 166.57,41.74 166.69,41.86 166.69,42.31 167.33,42.94 168.31,42.94 168.58,42.66 169.42,42.66 169.98,43.22 170.72,43.22
+VCHGR on TOP (solid shape): 29.4,8.43 29.74,8.09 30.07,8.43 30.07,8.97 30.57,8.97 30.61,8.93 30.61,7.61 30.99,7.23 32.33,7.23 32.52,7.05 32.52,4.79 32.39,4.67 29.04,4.67 28.96,4.74 28.96,6.18 28.71,6.43 28.71,8.91 28.77,8.97 29.4,8.97
+VCHGR on BOTTOM (solid shape): 32.55,6.95 32.55,5.88 32.34,5.67 31.06,5.67 30.96,5.77 30.96,7.02 31.01,7.06 32.44,7.06
+VHDMI_VCC on TOP (solid shape): 113.81,108.44 113.81,106.48 113.78,106.44 113.75,106.4 113.64,106.29 111.21,106.29 111,106.49 111,107.8 111.61,108.4 112.48,108.4 112.73,108.65 113.59,108.65
+VHDMI_VCC on IN1 (solid shape): 107.65,109.9 107.65,108.55 108.54,107.66 112.45,107.66 112.68,107.43 112.68,106.49 112.48,106.29 107.88,106.29 106.28,107.89 106.28,109.34 106.53,109.58 106.57,109.93 106.59,110.01 106.67,110.05 107.5,110.05
+VR_CAP on IN2 (solid shape): outline of 345 points within 295.01,76.66 301.04,82.07
AUD_HP_NB_SENSE on TOP (solid shape): 320.05,29.23 320.05,27.83 319.85,27.64 318.46,27.64 318.27,27.83 318.27,29.23 318.46,29.42 319.85,29.42
AUD_HP_OUT_L1 on TOP (solid shape): 317.39,39.12 317.39,38.2 317.22,38.04 317.11,38.04 317.06,37.99 315.66,37.99 315.47,38.18 315.47,39.2 315.6,39.32 317.19,39.32
AUD_HP_OUT_R1 on IN1 (solid shape): 322.97,29.16 322.97,27.7 322.71,27.45 321.19,27.45 321,27.64 321,29.29 321.12,29.42 322.71,29.42
BGATE_ISL9538 on TOP (solid shape): 20.01,15.26 20.45,15.26 20.71,15 20.71,14.12 20.64,14.05 19.94,14.05 19.75,14.24 19.75,15.26 19.82,15.32 19.94,15.32
BGATE_ISL9538 on TOP (solid shape): 28.52,6.5 28.52,6.3 28.77,6.05 28.77,4.79 28.62,4.64 27.18,4.64 27.07,4.76 27.07,5.31 27.21,5.45 27.61,5.45 27.75,5.59 27.75,6.47 27.88,6.6 28.41,6.6
BGATE_ISL9538 on IN1 (solid shape): 28.24,5.52 28.24,4.89 28.05,4.7 26.46,4.7 26.33,4.82 26.33,5.41 26.57,5.65 28.11,5.65
BGATE_ISL9538 on IN1 (solid shape): 20.96,15.19 20.96,14.02 21.15,13.83 21.15,13.29 21.09,13.23 20.65,13.23 20.13,13.74 20.13,15.19 20.26,15.32 20.83,15.32
BL_PWR_SRC_ON on BOTTOM (solid shape): 107.06,81.81 107.26,81.81 107.93,81.81 108.14,81.6 108.14,80.23 108.03,80.12 107.66,80.12 107.57,80.21 107.57,80.58 107.58,80.59 107.58,80.69 107.42,80.86 107.37,80.86 107.2,81.03 106.78,81.03 106.61,80.86 106.18,80.86 106,81.04 104.22,81.04 104.12,81.11 103.04,81.13 102.88,81.3 102.88,81.81 103.13,82.06 106.81,82.06
BOOT1_ISL9538 on TOP (solid shape): 20.01,21.29 19.88,21.16 19.25,21.16 18.78,20.69 18.78,19.47 18.74,19.44 18.74,18.6 18.7,18.55 18.59,18.55 18.51,18.64 18.51,19.55 18.42,19.64 18.42,21.04 18.45,21.06 18.62,21.06 18.62,21.24 18.83,21.44 18.83,22.15 18.92,22.24 20.01,22.24
BOOT2_ISL9538 on TOP (solid shape): 23.25,17.04 23.25,16.3 23.14,16.19 21.93,16.19 21.56,16.56 21.18,16.56 21.09,16.66 20.07,16.66 20.07,16.78 20.13,16.85 20.58,16.85 20.64,16.91 21.23,16.91 21.31,16.82 21.42,16.76 21.43,16.76 21.47,16.72 22.35,16.72 22.36,16.72 22.48,16.85 22.48,16.86 22.55,16.92 22.55,17.04 22.61,17.1 23.18,17.1
BST_3V on TOP (solid shape): 158.71,112.03 158.71,111.07 158.66,111.02 157.51,111.02 157.43,111.09 156.61,111.09 156.53,111.17 156.53,111.33 156.6,111.4 157.41,111.4 158.09,112.08 158.65,112.08
BST_5V on BOTTOM (solid shape): 166.59,113.77 166.59,113.65 166.43,113.48 165.79,113.48 165.13,112.82 164.47,112.82 164.44,112.84 164.44,113.7 164.6,113.86 166.5,113.86
BST_+1VALWP on BOTTOM (solid shape): 179.96,93.55 179.96,93.43 179.77,93.24 179.2,93.24 178.69,92.73 177.55,92.73 177.55,93.62 179.9,93.62
BST_+1VALWP_C on BOTTOM (solid shape): 176.79,91.52 176.15,91.52 176.15,93.62 176.79,93.62
CORE_VID1 on IN4 (solid shape): outline of 131 points within 129.61,51.96 131.35,53.74
CPU_B+ on TOP (solid shape): 66.38,82.8 66.38,77.41 66.35,77.39 65.05,77.39 64.95,77.49 64.95,79.4 64.62,79.73 61.85,79.73 61.75,79.82 61.75,81.13 61.9,81.28 62.8,81.28 64.37,82.85 66.33,82.85
CPU_B+ on TOP (solid shape): 58.38,75.18 58.38,73.76 58.56,73.58 59.13,73.58 59.18,73.53 59.18,72.75 59.57,72.36 59.67,72.36 59.72,72.35 59.76,72.35 59.83,72.32 59.86,72.25 59.86,71.79 59.84,71.77 59.82,71.77 59.82,71.76 59.76,71.76 59.57,71.76 59.57,71.75 59.18,71.36 59.18,70.93 59.09,70.84 58.1,70.84 58.01,70.94 58.01,71.96 57.19,72.78 56.31,72.78 53.9,70.37 53.9,69.98 53.9,69.98 53.9,68.07 54.06,67.91 54.87,67.91 54.95,67.84 54.95,66.95 54.79,66.79 52.2,66.79 51.96,67.03 51.96,70.42 53.06,71.52 53.06,74.55 53.8,75.28 58.28,75.28
CPU_B+ on BOTTOM (solid shape): 71.25,89.93 71.25,88.79 71.13,88.66 70.11,88.66 69.92,88.85 69.92,89.81 70.16,90.05 71.14,90.05
CPU_B+ on BOTTOM (solid shape): 56.43,76.7 56.43,74.82 56.71,74.54 56.75,74.54 58.95,74.54 59.13,74.36 59.13,74.36 59.18,74.31 59.18,70.85 59.16,70.83 58.04,70.83 57.98,70.89 57.98,72.23 57.84,72.37 57.02,72.37 56.48,72.91 55.21,72.91 54.99,73.13 54.99,73.47 54.69,73.76 53.42,73.76 53.27,73.91 53.27,74.74 52.66,75.36 52.66,76.8 52.95,77.09 56.04,77.09
CPU_B+ on BOTTOM (solid shape): 62.93,84.17 62.93,83.07 63.15,82.85 66.29,82.85 66.34,82.8 66.34,80.62 66.39,80.57 66.39,80.11 66.39,77.38 66.37,77.36 65.18,77.36 65.16,77.39 65.16,78.71 64.96,78.9 64.31,78.9 63.93,79.29 63.22,79.29 62.9,79.61 62.48,79.61 61.98,80.11 60.88,80.11 60.75,80.24 60.75,82.54 60.75,82.54 60.75,83.3 61.91,84.45 62.65,84.45
CPU_B+ on BOTTOM (solid shape): 53.9,70.31 53.9,68.11 53.91,68.11 53.91,68.08 54.06,67.94 54.91,67.94 54.99,67.86 54.99,66.4 54.43,66.4 54.43,65.85 54.99,65.85 54.99,65.61 54.43,65.61 54.43,65.04 54.99,65.04 54.99,63.93 54.88,63.83 53.09,63.83 52.08,62.82 48.38,62.82 47.33,61.77 46.41,61.77 46.41,61.23 45.98,61.23 45.98,61.78 45.22,61.78 45.22,61.23 44.77,61.23 44.77,61.77 43.22,61.77 42.87,62.12 42.87,68.53 44.73,70.39 53.82,70.39
CPU_B+ on IN1 (solid shape): 70.93,89.17 70.93,88.47 69.98,87.52 69.16,87.52 68.9,87.78 68.9,88.28 69.22,88.6 69.66,88.6 69.86,88.79 69.86,89.17 69.98,89.3 70.81,89.3
CPU_B+ on IN1 (solid shape): outline of 543 points within 50.34,66.6 66.38,84.23
CPU_B+ on IN2 (solid shape): outline of 419 points within 52.5,66.75 66.4,82.89
CPU_B+ on IN3 (solid shape): 65.88,82.73 65.88,80.49 66.4,79.97 66.4,77.41 66.32,77.33 64.42,77.33 64.3,77.44 64.3,79.57 64.2,79.67 62.13,79.67 61.85,79.95 61.85,81.14 63.72,83.02 65.6,83.02
CPU_B+ on IN3 (solid shape): outline of 186 points within 52.39,66.74 59.2,75.28
DCIN_ISL9538 on TOP (solid shape): 12.96,22.37 12.96,20.21 13.28,19.89 15.38,19.89 16.84,18.43 16.84,18.3 16.76,18.23 16.01,18.23 15.1,19.13 12.39,19.13 12.07,19.45 12.07,20.49 11.84,20.72 11.84,22.47 11.92,22.55 12.78,22.55
GPU_B+ on TOP (solid shape): 58.86,67.12 58.86,64.16 59.23,63.79 59.23,63.1 59.41,62.92 59.41,62.9 59.49,62.9 59.57,62.88 59.64,62.87 59.72,62.85 59.75,62.77 59.75,62.3 59.73,62.28 59.63,62.29 59.56,62.28 59.34,62.28 59.23,62.18 59.23,61.42 59.17,61.35 58.05,61.35 57.93,61.47 57.93,62.61 57.52,63.03 53.46,63.03 53.22,63.27 53.22,65.62 53.41,65.8 53.89,65.8 54.58,66.49 55.02,66.49 55.56,67.03 57.69,67.03 57.88,67.22 58.76,67.22
GPU_B+ on BOTTOM (solid shape): 56.95,67.19 57.16,67.1 57.36,67.19 58.81,67.19 58.89,67.11 58.89,64.29 59.08,64.1 59.08,61.37 57.88,61.37 57.84,61.41 57.84,62.76 57.7,62.9 56.39,62.9 56.28,63.01 56.28,63.44 56.06,63.66 55.37,63.66 55.12,63.91 55.12,65.18 54.59,65.18 54.59,65.48 55.12,65.48 55.12,65.98 54.59,65.98 54.59,66.27 55.12,66.27 55.12,66.95 55.36,67.19
GPU_B+ on IN1 (solid shape): 57.91,66.86 57.91,64.5 58.26,64.15 59.07,64.15 59.16,64.06 59.16,61.63 58.93,61.4 55.8,61.4 55.5,61.7 55.5,66.87 55.77,67.15 57.63,67.15
GPU_B+ on IN3 (solid shape): 57.91,66.86 57.91,64.5 58.26,64.15 59.07,64.15 59.16,64.06 59.16,61.68 58.88,61.4 55.8,61.4 55.5,61.7 55.5,66.87 55.77,67.15 57.63,67.15
GT_SW on BOTTOM (solid shape): 67.12,64.66 67.12,63.07 66.96,62.91 65.03,62.91 65.03,62.07 65.97,62.07 65.97,60.71 65.66,60.41 64.65,60.41 62.59,58.35 60.3,58.35 60.26,58.39 60.26,59.22 60.3,59.26 61.55,59.26 61.74,59.44 61.74,63.23 63.32,64.81 66.97,64.81
IA_SW1 on BOTTOM (solid shape): 66.11,72.54 66.11,70.5 65.17,70.5 65.17,69.74 66.11,69.74 66.11,68.3 66.02,68.22 63.79,68.22 63.55,67.98 60.38,67.98 60.37,67.99 60.37,68.67 60.4,68.7 61.65,68.7 61.83,68.87 61.83,72.5 61.83,72.67 61.85,72.69 65.95,72.69
IA_SW2 on BOTTOM (solid shape): 73.36,80.72 73.36,79.33 72.47,79.33 72.47,78.57 73.36,78.57 73.36,76.97 73.24,76.85 71.96,76.85 69.46,74.36 67.68,74.36 67.59,74.45 67.59,75.26 67.64,75.31 68.79,75.31 69.1,75.62 69.1,79.75 70.11,80.76 73.31,80.76
INT_SPK_L+ on TOP (solid shape): 300.23,40.72 300.23,39.77 299.92,39.45 299.92,37.98 299.86,37.92 299.75,37.92 299.69,37.98 299.69,38.76 299.66,38.79 299.66,39.58 299.73,39.64 299.73,40.76 299.8,40.83 300.12,40.83
INT_SPK_L+ on TOP (solid shape): 290.2,30.54 290.2,29.86 289.83,29.48 289.35,29.48 289.02,29.65 288.66,29.7 288.58,29.73 288.55,29.8 288.55,30.42 288.55,30.5 288.68,30.62 289.82,30.62 289.88,30.69 290.05,30.69
INT_SPK_L+ on BOTTOM (solid shape): 300.3,40.72 300.3,40.15 300.74,39.71 300.74,39.01 300.61,38.88 300.11,38.88 299.98,39.01 299.98,39.58 299.79,39.77 299.79,40.72 299.93,40.86 300.16,40.86
INT_SPK_L+ on IN1 (solid shape): 291.34,30.55 291.34,30.47 290.37,29.51 289.51,29.51 289.24,29.78 289.24,30.49 289.35,30.6 290.11,30.6 290.18,30.68 291.2,30.68
INT_SPK_L+ on IN1 (solid shape): 300.18,40.79 300.21,40.79 300.23,40.78 300.28,40.72 300.28,39.76 300.43,39.62 300.43,37.59 300.12,37.28 300.02,37.26 299.95,37.34 299.35,37.54 299.55,36.94 299.63,36.87 299.61,36.77 299.59,36.75 298.52,36.75 298.24,37.03 298.24,37.63 298.49,37.88 298.74,37.88 299.8,38.94 299.8,40.71 299.88,40.79
INT_SPK_L- on TOP (solid shape): 290.26,31.64 290.26,30.94 290.14,30.82 289.76,30.82 289.69,30.75 288.61,30.75 288.55,30.82 288.55,31.7 288.65,31.81 290.1,31.81
INT_SPK_L- on TOP (solid shape): 299.6,40.73 299.6,39.77 299.53,39.71 299.53,38.83 299.51,38.8 299.51,37.97 299.46,37.92 299.34,37.92 299.28,37.99 299.28,39.39 299.15,39.52 299.15,40.82 299.19,40.86 299.47,40.86
INT_SPK_L- on BOTTOM (solid shape): 299.66,40.75 299.66,40.66 299.66,40.63 299.65,40.58 299.66,40.52 299.66,40.07 299.65,40 299.66,39.93 299.66,39.72 299.66,39.64 299.79,39.52 299.79,38.94 299.73,38.88 299.22,38.88 299.15,38.94 299.15,40.77 299.24,40.86 299.55,40.86
INT_SPK_L- on IN1 (solid shape): 290.26,32.19 290.26,31.2 289.84,30.78 289.36,30.78 289.26,30.88 289.26,32.17 289.29,32.2 290.25,32.2
INT_SPK_L- on IN1 (solid shape): 299.6,40.73 299.6,39.21 298.78,38.39 298.28,38.39 297.71,38.39 297.24,38.87 297.9,39.53 298.92,39.53 299.08,39.69 299.08,39.96 299.09,40.05 299.08,40.13 299.08,40.48 299.13,40.6 299.14,40.73 299.14,40.75 299.19,40.81 299.52,40.81
INT_SPK_R+ on TOP (solid shape): 289.62,38.62 289.62,38.09 289.29,37.76 289.29,36.47 289.21,36.39 288.42,36.39 288.32,36.49 288.32,38.03 289.04,38.75 289.48,38.75
INT_SPK_R+ on TOP (solid shape): 298.39,40.77 298.39,40.14 298.38,40.05 298.39,39.95 298.39,39.46 298.39,39.45 298.71,39.13 298.71,37.98 298.65,37.92 298.53,37.92 298.48,37.97 298.48,38.98 298.36,39.1 298.36,39.13 297.88,39.61 297.88,40.01 297.88,40.06 297.88,40.8 298,40.91 298.25,40.91
INT_SPK_R+ on BOTTOM (solid shape): 298.39,40.8 298.39,40.14 298.38,40.05 298.39,39.95 298.39,39.83 298.07,39.52 298.07,38.94 298.01,38.88 297.44,38.88 297.38,38.94 297.38,39.6 297.88,40.11 297.88,40.77 298.02,40.91 298.28,40.91
INT_SPK_R+ on IN4 (solid shape): 290.53,39.19 290.53,38.75 290.21,38.44 289.66,37.88 289.66,37.86 289.46,37.66 288.57,37.66 288.45,37.79 288.45,38.32 289.01,38.88 289.01,39.19 289.36,39.54 290.17,39.54
INT_SPK_R+ on IN4 (solid shape): 296.28,40.81 296.45,40.8 296.47,40.79 296.49,40.77 296.5,40.75 296.51,40.68 296.52,40.62 296.53,40.57 296.56,40.52 296.59,40.47 296.63,40.43 296.67,40.4 296.72,40.37 296.75,40.36 296.75,40.34 297.38,40.34 297.95,40.91 298.27,40.91 298.37,40.81 298.37,39.52 298.05,39.2 295.85,39.2 295.15,39.9 294.71,39.9 294.71,40.13 295.79,40.13 295.79,40.08 295.8,40.03 295.82,39.98 295.84,39.93 295.87,39.88 295.91,39.84 295.95,39.81 296,39.78 296.04,39.76 296.1,39.75 296.15,39.75 296.2,39.75 296.25,39.76 296.3,39.78 296.35,39.81 296.39,39.84 296.43,39.88 296.46,39.93 296.48,39.98 296.5,40.03 296.51,40.08 296.51,40.13 296.5,40.18 296.48,40.24 296.46,40.28 296.43,40.33 296.39,40.37 296.35,40.4 296.3,40.43 296.25,40.45 296.2,40.46 296.15,40.46 296.1,40.46 296.04,40.45 296,40.43 295.95,40.4 295.91,40.37 295.87,40.33 295.84,40.28 295.82,40.24 295.8,40.18 295.79,40.13 294.71,40.13 294.71,40.91 296.18,40.91
INT_SPK_R- on TOP (solid shape): 288.27,39.34 288.27,38.85 287.91,38.49 287.91,36.66 287.66,36.4 286.71,36.4 286.64,36.47 286.64,38.69 287.45,39.5 288.12,39.5
INT_SPK_R- on TOP (solid shape): 299.03,40.8 299.03,40.65 299.01,40.56 299.03,40.46 299.03,40.13 299.02,40.12 298.99,39.97 299.02,39.82 299.03,39.81 299.03,39.46 299.03,39.45 299.11,39.37 299.11,37.98 299.05,37.93 298.94,37.93 298.9,37.97 298.9,39.13 298.52,39.52 298.52,40.85 298.58,40.91 298.91,40.91
INT_SPK_R- on BOTTOM (solid shape): 299.03,40.82 299.01,40.56 299.03,40.46 299.03,40.13 299.02,40.12 298.99,39.97 299.02,39.82 299.03,39.81 299.03,38.94 298.96,38.88 298.33,38.88 298.26,38.94 298.26,39.45 298.52,39.71 298.52,39.78 298.52,40.82 298.63,40.94 298.91,40.94
INT_SPK_R- on IN4 (solid shape): 288.45,39.85 288.45,39.1 287.44,38.08 286.74,38.08 286.37,38.45 286.37,39.16 287.39,40.18 288.13,40.18
INT_SPK_R- on IN4 (solid shape): 299.67,41.94 299.67,40.97 299.62,40.88 299.52,40.88 299.09,40.78 299.09,40.34 299.11,40.28 299.08,40.21 299,40.08 298.99,39.92 298.9,39.83 298.57,39.83 298.51,39.9 298.51,41.01 298.47,41.04 298.43,41.06 298.43,41.29 298.2,41.53 298.2,42.44 299.17,42.44
INT_SPKR_L+ on TOP (solid shape): 266.22,30.05 266.54,29.86 266.9,29.8 267.02,29.8 267.02,29.23 266.9,29.1 264.1,29.1 264.04,29.16 264.04,29.93 264.17,30.05
INT_SPKR_L+ on TOP (solid shape): 288.42,30.37 288.42,29.67 288.33,29.64 288.26,29.61 288.17,29.61 286.96,28.4 284.49,28.4 284.49,28.91 284.93,29.36 286.52,29.36 287.6,30.43 288.36,30.43
INT_SPKR_L- on TOP (solid shape): 266.4,31.26 266.64,31.16 266.9,31.13 267.28,31.13 267.28,30.56 267.15,30.43 264.23,30.43 264.04,30.63 264.04,31.07 264.23,31.26
INT_SPKR_L- on TOP (solid shape): 286.83,31.99 287.24,31.65 287.75,31.8 287.96,32.02 288.23,32.02 288.42,31.83 288.42,30.82 288.36,30.75 287.28,30.75 286.64,30.12 285.69,30.12 284.87,30.94 283.98,30.94 283.85,31.07 283.85,31.77 284.03,31.95 284.08,31.89 286.35,31.89 286.47,32.02 286.82,32.02
INT_SPKR_R+ on TOP (solid shape): 267.21,32.66 267.47,32.66 267.66,32.47 267.66,31.9 267.59,31.83 266.9,31.83 266.64,31.8 266.4,31.7 264.23,31.7 264.1,31.83 264.1,32.47 264.29,32.66 267.19,32.66
INT_SPKR_R+ on TOP (solid shape): 289.12,36.15 289.12,35.39 286.14,32.4 284.9,32.4 284.73,32.45 284.55,32.47 284.23,32.47 284.1,32.59 284.1,33.36 284.29,33.55 285.25,33.55 285.76,34.05 286.52,34.05 287.22,34.75 287.22,35.9 287.5,36.18 289.09,36.18
INT_SPKR_R- on TOP (solid shape): 267.66,33.99 267.66,33.23 267.59,33.17 266.9,33.17 266.58,33.12 266.3,32.97 264.23,32.97 264.06,33.15 265.16,34.24 267.4,34.24
INT_SPKR_R- on TOP (solid shape): 286.45,37.29 286.45,36.28 286.96,35.77 286.96,34.94 286.77,34.75 285.44,34.75 285.43,34.76 285.25,34.8 285.08,34.75 285.06,34.75 284.42,35.39 284.42,36.21 284.68,36.47 285.5,36.47 285.63,36.59 285.63,37.29 285.69,37.36 286.39,37.36
LG1_ISL9538 on TOP (solid shape): 21.7,20.39 21.7,20.13 20.51,18.95 20.27,18.95 19.87,18.56 19.79,18.56 19.73,18.61 19.73,19.41 19.78,19.46 20.02,19.46 21.1,20.54 21.54,20.54
LG1_ISL9538 on BOTTOM (solid shape): 16.1,25.18 16.1,24.03 15.93,23.86 13.67,23.86 13.49,24.05 13.49,25.19 13.56,25.27 16.01,25.27
LG1_ISL9538 on IN1 (solid shape): 16.83,24.74 16.83,24.2 16.54,23.91 15.63,23.91 15.54,24 15.54,24.91 15.68,25.05 16.52,25.05
LG1_ISL9538 on IN1 (solid shape): 21.7,20.26 21.7,20 20.86,19.16 20.37,19.16 20.22,19.31 20.22,19.7 21.12,20.6 21.36,20.6
LG2_ISL9538 on TOP (solid shape): 22.1,18.62 22.1,18.31 21.98,18.18 21.79,18.18 21.47,17.86 20.13,17.86 20.07,17.93 20.07,17.99 20.13,18.05 20.96,18.05 21.66,18.75 21.98,18.75
LG2_ISL9538 on BOTTOM (solid shape): 33.66,21.74 33.66,20.03 33.42,19.79 32.33,19.79 32.26,19.86 32.26,21.57 32.55,21.86 33.53,21.86
LG2_ISL9538 on IN1 (solid shape): 33.73,21.73 33.73,20.94 33.3,20.51 32.13,20.51 32.09,20.55 32.09,21.32 32.17,21.4 32.71,21.4 33.18,21.87 33.6,21.87
