# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D46: length 52.3
  IN1 w0.076: v1(124.93,43.06) 125.23,43.06 126.72,41.57 126.72,39.7 127.57,38.86 127.7,38.86
  IN1 w0.089: 127.7,38.86 128.78,37.78 128.78,37.11 130.95,34.94 130.95,34.37 131.08,34.23 131.08,31.5 133.01,29.57 133.01,26.98 134.43,25.56 134.43,23.8 139.43,18.81 139.43,12.31 138.76,11.65 138.76,10.19 140.2,8.75 140.42,8.75 140.53,8.86 140.65,8.86 140.89,8.62 140.89,8.45 140.81,8.37 140.81,8.14 141.01,7.94 v1(141.43,7.94)
  BOTTOM w0.076: UC1.BA25 123.98,47.59 124.13,47.44 124.26,47.17 124.26,45.61 124.58,45.29 124.58,43.42 v1(124.93,43.06)
  BOTTOM w0.102: v1(141.43,7.94) 140.16,6.67 140.16,6.41 140.03,6.27 JDIMM2.80
DDR_B_D47: length 51.3
  IN1 w0.076: 130.03,35.26 130.03,35.39 128.55,36.87 128.55,37.56 126.46,39.65 126.46,41.44 125.44,42.46 v1(124.95,42.46)
  IN1 w0.089: 130.03,35.26 130.03,34.37 130.7,33.7 130.7,31.25 131.88,30.07 131.88,27.68 134.13,25.43 134.13,23.68 138.4,19.4 138.4,18.94 138.41,18.93 138.41,9.74 138.78,9.37 138.78,9.2 138.41,8.83 138.41,8.63 138.59,8.45 138.83,8.45 139.18,8.8 139.32,8.8 141.43,6.69 v1(141.43,6.67)
  BOTTOM w0.076: UC1.BB25 123.98,46.86 124.09,46.75 124.09,45.54 124.41,45.22 124.41,42.85 124.8,42.46 v1(124.95,42.46)
  BOTTOM w0.102: JDIMM2.84 141.03,6.26 v1(141.43,6.67)
DDR_B_D48: length 86.2
  IN1 w0.076: v1(121.55,49.85) 121.35,49.66 121.35,48.42 121.45,48.31 121.45,48.29
  IN1 w0.089: 121.45,48.29 121.45,47.96 122.49,46.92 122.49,46.41 123.17,45.73 125.73,45.73 129.36,42.11 129.66,42.11 130.73,41.04 130.73,40.22 132.39,38.56 132.39,36.86 132.64,36.61 133.37,36.61 134.27,35.72 134.27,33.86 136.4,31.73 136.4,28.82 137.74,27.47 137.92,27.47 138.06,27.61 138.06,27.82 137.46,28.42 137.46,28.63 137.59,28.77 137.78,28.77 149.31,17.23 168.04,17.23 170.73,14.54 170.73,14.14 171.42,13.45 173.94,13.45 175.01,12.38 175.01,8.52 v1(175.59,7.94)
  BOTTOM w0.076: v1(121.55,49.85) UC1.AU27
  BOTTOM w0.102: JDIMM2.216 176.03,4.8 176.03,7.51 v1(175.59,7.94)
DDR_B_D49: length 86.6
  IN1 w0.076: v1(121.55,50.5) 121.55,50.39 121.12,49.96 121.12,48.01
  IN1 w0.089: v1(174.33,9.54) 174.7,9.92 174.7,12.22 173.78,13.15 170.75,13.15 170.32,13.58 170.32,14.46 168.5,16.28 149.74,16.28 138.58,27.43 138.39,27.43 138.25,27.29 138.25,27.1 139.09,26.25 139.09,26.06 138.96,25.93 138.76,25.93 135.53,29.16 135.53,31.09 133.63,32.98 133.63,35.46 133.31,35.79 132.93,35.79 132.09,36.63 132.09,38.37 130.29,40.16 130.29,40.3 129.75,40.85 129.64,40.85 129.37,41.12 129.37,41.63 125.57,45.43 122.98,45.43 122.14,46.27 122.14,46.84 121.12,47.86 121.12,48.01
  BOTTOM w0.076: v1(121.55,50.5) UC1.AT27
  BOTTOM w0.102: v1(174.33,9.54) 175.52,10.74 175.52,11.75 175.78,12 JDIMM2.215
DDR_B_D50: length 85.3
  IN1 w0.076: 122.9,49.51 122.84,49.57 122.84,50.04 122.46,50.42 v1(122.46,50.5)
  IN1 w0.089: v1(178.6,7.84) 177.3,9.15 177.3,14.84 173.15,18.99 149.97,18.99 139.72,29.24 139.72,31.56 136.04,35.25 136.04,36.27 135.81,36.49 135.81,38.53 135.36,38.98 134.48,38.98 133.02,40.44 133.02,41.21 130.71,43.52 129.43,43.52 125.41,47.54 124.28,47.54 122.9,48.92 122.9,49.51
  BOTTOM w0.076: v1(122.46,50.5) UC1.AT25
  BOTTOM w0.102: JDIMM2.224 178.03,4.8 178.03,7.26 v1(178.6,7.84)
DDR_B_D51: length 84.5
  IN1 w0.089: v1(122.46,49.87) 122.46,49.23 122.59,49.1 122.59,48.8 124.15,47.23 125.33,47.23 129.35,43.22 130.42,43.22 132.08,41.56 132.08,40.81 134.21,38.68 135.23,38.68 135.51,38.4 135.51,36.37 135.73,36.14 135.73,35.12 139.42,31.44 139.42,29.06 149.79,18.69 172.86,18.69 176.85,14.7 176.85,8.75 v1(178.61,6.99)
  BOTTOM w0.076: v1(122.46,49.87) UC1.AU25
  BOTTOM w0.102: v1(178.61,6.99) 179.03,6.57 JDIMM2.228
DDR_B_D52: length 86.9
  IN1 w0.076: 120.81,48.01 120.81,49.9 121.17,50.25 121.17,51.4 v1(121.55,51.77)
  IN1 w0.089: v1(174.22,11.04) 172.42,12.84 169.61,12.84 166.54,15.91 149.57,15.91 139.68,25.79 139.49,25.79 139.35,25.66 139.35,25.46 141.44,23.37 141.44,23.16 141.3,23.02 141.12,23.02 135.22,28.92 135.22,30.96 133.24,32.95 133.24,34.63 132.5,35.36 132.5,35.73 131.76,36.47 131.76,38.15 130.09,39.82 129.64,39.82 129.03,40.42 129.03,41.54 125.45,45.12 122.76,45.12 121.83,46.06 121.83,46.71 120.81,47.73 120.81,48.01
  BOTTOM w0.076: v1(121.55,51.77) UC1.AP27
  BOTTOM w0.102: JDIMM2.211 174.78,11.57 174.25,11.04 v1(174.22,11.04)
DDR_B_D53: length 87.6
  IN1 w0.076: 126.41,43.74 125.35,44.79 122.62,44.79 121.49,45.92 121.49,46.58 120.48,47.59 120.48,49.84 121,50.36 121,51.87 v1(121.55,52.41)
  IN1 w0.089: 126.41,43.74 128.71,41.44 128.71,40.25 129.43,39.52 129.94,39.52 131.37,38.09 131.37,36.4 132.18,35.59 132.18,35.23 132.72,34.69 132.72,33.03 134.92,30.84 134.92,28.74 141.1,22.56 142.27,22.56 142.41,22.41 142.41,22.22 142.2,22 142.2,21.81 142.34,21.67 142.53,21.67 142.75,21.88 142.94,21.88 143.08,21.75 143.08,21.55 142.87,21.34 142.87,21.14 143,21.01 143.2,21.01 143.41,21.22 143.61,21.22 149.33,15.5 165.1,15.5 168.06,12.54 172.22,12.54 172.91,11.86 172.91,10.12 174.96,8.07 174.96,7.3 175.49,6.77 v1(175.49,6.67)
  BOTTOM w0.076: v1(121.55,52.41) UC1.AN27
  BOTTOM w0.102: v1(175.49,6.67) 175.03,6.2 JDIMM2.212
DDR_B_D54: length 87.1
  IN1 w0.076: v1(122.46,52.41) 122.99,51.87 122.99,50.35 123.62,49.73 123.62,49.09 123.77,48.94
  IN1 w0.089: v1(178.76,10.42) 178.76,14.47 173.63,19.6 151.78,19.6 148.64,22.74 148.42,22.74 148.28,22.6 148.28,22.43 148.78,21.93 148.78,21.74 148.64,21.6 148.45,21.6 141.38,28.67 141.38,30 140.47,30.9 140.47,32.66 137.48,35.65 137.48,38.13 135.72,39.89 135.01,39.89 134.68,40.22 134.68,40.94 131.48,44.13 129.65,44.13 127.84,45.94 127.84,46.89 126.58,48.15 124.56,48.15 123.77,48.94
  BOTTOM w0.076: v1(122.46,52.41) UC1.AN25
  BOTTOM w0.102: JDIMM2.229 179.28,11.43 178.76,10.92 v1(178.76,10.42)
DDR_B_D55: length 86.3
  IN1 w0.076: v1(122.46,51.77) 122.83,51.41 122.83,50.28 123,50.11 123,49.94 123.14,49.8
  IN1 w0.089: v1(177.75,10.99) 178.13,11.37 178.13,14.62 173.46,19.3 151.6,19.3 149.7,21.19 149.51,21.19 149.37,21.05 149.37,20.85 150.26,19.97 150.26,19.76 150.12,19.62 149.94,19.62 140.98,28.58 140.98,29.91 140.17,30.72 140.17,32.53 137.12,35.58 137.12,35.94 136.12,36.94 136.12,38.65 135.4,39.37 134.56,39.37 133.45,40.48 133.45,41.71 131.35,43.81 129.7,43.81 127.52,46 127.52,46.7 126.37,47.84 124.41,47.84 123.23,49.02 123.23,49.71 123.14,49.8
  BOTTOM w0.076: v1(122.46,51.77) UC1.AP25
  BOTTOM w0.102: v1(177.75,10.99) 178.28,11.51 JDIMM2.225
DDR_B_D56: length 89.5
  IN4 w0.076: 131,45.65 130.38,46.27 130.38,46.63 129.75,47.26 128.76,47.26 128.49,47.53 126.57,47.53 125.66,48.44 124.49,48.44 123.8,49.13 123.8,49.92 124.29,50.4 v1(124.29,50.44)
  IN4 w0.089: v1(179.75,10.96) 178.58,10.96 178.49,11.04 178.49,11.31 178.58,11.4 179.27,11.4 179.35,11.49 179.35,11.74 179.27,11.83 178.57,11.83 178.45,11.94 178.45,12.22 178.54,12.31 179.19,12.31 179.28,12.4 179.28,12.74 179.19,12.83 178.18,12.83 177.58,12.23 177.41,12.23 177.2,12.45 177.2,12.62 178.07,13.5 178.07,13.72 177.91,13.88 177.69,13.88 176.79,12.99 176.65,12.99 176.42,13.22 176.42,13.39 177.39,14.36 177.39,14.58 175.59,16.38 175.59,20.31 172.61,23.29 172.61,24.02 164.89,31.73 164.17,31.73 159.28,36.62 155,36.62 154.38,37.23 151.97,37.23 151.92,37.19 150.83,37.19 150.18,37.84 150.18,38.55 149.89,38.83 149.12,38.83 148.59,39.36 146.34,39.36 145.5,40.2 142.36,40.2 141.8,39.64 137.36,39.64 131.35,45.65 131,45.65
  BOTTOM w0.076: v1(124.29,50.44) 124.29,50.44 124.3,50.51 UC1.AT22
  BOTTOM w0.102: JDIMM2.233 180.28,11.48 v1(179.75,10.96)
DDR_B_D57: length 88.8
  IN4 w0.076: v1(124.29,49.85) 124.29,49.73 125.1,48.92 125.42,48.92 126.64,47.69 128.56,47.69 128.83,47.42 129.82,47.42 131.98,45.26 132.33,45.26
  IN4 w0.089: v1(179.78,9.67) 179.58,9.46 179.58,9.04 179.7,8.92 180.18,8.92 180.29,9.04 180.29,12.16 179.91,12.54 179.91,12.67 180.23,12.99 180.23,13.11 180.1,13.24 179.98,13.24 179.66,12.92 179.53,12.92 179.41,13.05 179.41,13.17 179.72,13.49 179.72,13.61 179.6,13.74 179.47,13.74 179.16,13.42 179.03,13.42 178.9,13.55 178.9,13.67 179.16,13.93 179.16,14.06 179.03,14.18 178.91,14.18 178.65,13.93 178.53,13.93 178.4,14.05 178.4,14.18 178.67,14.45 178.67,14.57 178.54,14.7 178.42,14.7 178.15,14.43 178.02,14.43 175.9,16.56 175.9,20.44 172.91,23.42 172.91,24.31 165.19,32.04 164.3,32.04 160.08,36.25 160.08,37.04 159.58,37.54 153.39,37.54 152.7,38.24 151.4,38.24 150.37,39.26 149.21,39.26 148.55,39.93 147.5,39.93 147.12,40.31 146.29,40.31 145.99,40.61 142.33,40.61 141.66,39.95 137.65,39.95 132.33,45.26
  BOTTOM w0.076: v1(124.29,49.85) UC1.AU22
  BOTTOM w0.102: v1(179.78,9.67) 180.27,9.67 181.28,10.67 JDIMM2.237
DDR_B_D58: length 87.6
  IN4 w0.076: v1(125.2,49.91) 125.29,49.91 126.94,48.26 128.75,48.26 129,48.01 130.06,48.01 131.32,46.75 132.17,46.75
  IN4 w0.089: 132.17,46.75 132.9,46.75 135.33,44.32 136.03,44.32 137.7,42.65 143.28,42.65 143.55,42.39 150.48,42.39 152.79,40.08 153.19,40.08 154.28,38.99 156.47,38.99 157.48,39.99 159.09,39.99 163.17,35.91 163.17,35.19 164.87,33.5 165.76,33.5 174.24,25.02 174.24,24.03 177.34,20.93 177.34,18.8 178.14,18 178.14,17.77 178.08,17.71 178.08,17.48 178.24,17.32 178.46,17.32 178.53,17.38 178.75,17.38 178.91,17.22 178.91,17 178.85,16.93 178.85,16.71 179.01,16.55 179.23,16.55 179.3,16.61 179.52,16.61 179.69,16.45 179.69,16.23 179.62,16.16 179.62,15.93 179.78,15.77 180.01,15.77 180.07,15.84 180.3,15.84 182.18,13.96 182.18,10.78 181.89,10.49 181.89,8.64 181.97,8.55 182.36,8.55 182.45,8.64 182.45,10.5 182.78,10.83 v1(182.78,11.01)
  BOTTOM w0.076: UC1.AU21 125.49,50.2 v1(125.2,49.91)
  BOTTOM w0.102: JDIMM2.245 183.28,11.5 v1(182.78,11.01)
DDR_B_D59: length 88.6
  IN4 w0.076: 132.14,47.06 131.25,47.06 130.13,48.17 129.39,48.17 128.48,49.08 126.63,49.08 v1(125.2,50.5)
  IN4 w0.089: v1(182.94,9.77) 183.34,10.18 183.34,13.35 180.03,16.66 180.03,16.78 180.24,17 180.24,17.2 180.11,17.34 179.94,17.34 179.71,17.1 179.58,17.1 179.25,17.44 179.25,17.67 179.49,17.91 179.49,18.07 179.28,18.29 179.1,18.29 178.86,18.05 178.63,18.05 178,18.69 178,18.96 178.16,19.12 178.64,19.12 178.8,19.28 178.8,19.51 178.64,19.67 178.16,19.67 178,19.83 178,20.05 178.16,20.21 178.64,20.21 178.8,20.37 178.8,20.6 178.64,20.76 178.16,20.76 174.54,24.37 174.54,25.17 161.49,38.22 161.3,38.22 159.22,40.3 157.36,40.3 156.45,39.4 154.43,39.4 153.38,40.45 152.9,40.45 150.61,42.74 143.78,42.74 143.49,43.03 138.06,43.03 134.03,47.06 132.14,47.06
  BOTTOM w0.076: v1(125.2,50.5) UC1.AT21
  BOTTOM w0.102: JDIMM2.249 184.28,10.74 183.23,9.7 183.01,9.7 v1(182.94,9.77)
DDR_B_D60: length 90.6
  IN4 w0.076: v1(124.29,52.41) 123.74,51.86 123.74,50.35 123.36,49.97 123.36,49.1 124.35,48.11 125.52,48.11 126.43,47.2 128.03,47.2 130.66,44.57
  IN4 w0.089: v1(180.54,6.68) 179.81,7.41 178.14,7.41 178.06,7.5 178.06,8.34 177.97,8.43 177.73,8.43 177.64,8.34 177.64,7.31 177.55,7.22 177.32,7.22 177.23,7.31 177.23,8.36 177.14,8.45 176.81,8.45 176.68,8.58 176.68,11.6 174.98,13.3 174.98,20.06 171.94,23.1 171.94,23.59 164.4,31.12 163.92,31.12 159.03,36.01 154.2,36.01 153.62,36.58 152.27,36.58 152.13,36.45 150.11,36.45 149.69,36.87 148.86,36.87 147.99,37.75 147.62,37.75 146.87,38.5 145.72,38.5 144.86,39.36 143.87,39.36 143.54,39.04 143.31,39.04 142.99,39.36 142.49,39.36 142.16,39.03 137.1,39.03 134.4,41.74 133.49,41.74 130.66,44.57
  BOTTOM w0.076: UC1.AN22 v1(124.29,52.41)
  BOTTOM w0.102: v1(180.54,6.68) 180.65,6.68 181.03,6.3 181.03,4.8 JDIMM2.236
DDR_B_D61: length 90.4
  IN4 w0.076: 130.25,45.8 129.99,46.06 129.99,46.68 129.58,47.09 128.7,47.09 128.42,47.36 126.5,47.36 125.59,48.28 124.42,48.28 123.6,49.09 123.6,49.96 123.92,50.28 123.92,51.41 v1(124.29,51.77)
  IN4 w0.089: v1(180.55,7.94) 179.07,7.94 178.88,8.13 178.88,9.8 178.82,9.86 178.53,9.86 178.45,9.78 178.45,8.84 178.36,8.76 178.15,8.76 178.06,8.84 178.06,9.52 177.97,9.61 177.18,9.61 177.06,9.72 177.06,11.73 175.89,12.9 175.89,14.71 175.29,15.31 175.29,20.18 172.3,23.17 172.3,23.89 164.77,31.43 164.04,31.43 159.16,36.31 154.87,36.31 154.28,36.9 152.15,36.9 152.12,36.87 150.26,36.87 149.24,37.89 149.24,38.26 148.59,38.91 146.07,38.91 145.08,39.9 142.55,39.9 141.99,39.34 137.23,39.34 134.58,41.99 134.06,41.99 130.25,45.8
  BOTTOM w0.076: v1(124.29,51.77) UC1.AP22
  BOTTOM w0.102: v1(180.55,7.94) 179.94,7.33 179.94,6.47 180.03,6.39 180.03,4.8 JDIMM2.232
DDR_B_D62: length 89.8
  IN4 w0.076: 132.07,47.67 131.54,47.67 129.73,49.48 126.9,49.48 126.62,49.75 126.62,51.27 v1(126.12,51.77)
  IN4 w0.089: v1(184.99,7.94) 184.46,7.94 184.32,8.08 184.32,8.51 184.41,8.6 184.75,8.6 184.84,8.69 184.84,8.91 184.75,9 184.24,9 184.15,9.09 184.15,9.3 184.24,9.39 184.75,9.39 184.84,9.48 184.84,9.66 184.75,9.75 184.24,9.75 184.15,9.84 184.15,13.51 181.62,16.04 181.62,17.98 179.62,19.98 179.62,20.64 175.15,25.1 175.15,25.44 161.72,38.87 161.5,38.87 159.44,40.93 155.88,40.93 155.39,41.43 152.96,41.43 150.92,43.46 144.34,43.46 143.54,44.27 142.3,44.27 142.12,44.09 142.12,43.95 141.95,43.77 141.7,43.77 141.53,43.95 141.53,44.09 141.35,44.27 138.19,44.27 134.79,47.67 132.07,47.67
  BOTTOM w0.076: v1(126.12,51.77) 125.74,52.15 UC1.AP21
  BOTTOM w0.102: JDIMM2.246 183.53,6.18 183.69,6.34 183.69,6.76 184.86,7.94 v1(184.99,7.94)
DDR_B_D63: length 90.9
  IN4 w0.076: 132.12,47.36 131.55,47.36 129.6,49.31 126.68,49.31 125.67,50.32 125.67,51.92 125.2,52.39 v1(125.2,52.41)
  IN4 w0.089: 132.12,47.36 134.57,47.36 138,43.92 140.69,43.92 141.14,43.47 143.76,43.47 144.18,43.05 150.81,43.05 152.82,41.03 155.11,41.03 155.54,40.6 159.34,40.6 161.42,38.53 161.64,38.53 174.85,25.32 174.85,24.98 179.27,20.56 179.27,19.76 181.2,17.83 181.2,16 183.65,13.55 183.65,8.3 183.73,8.21 183.93,8.21 184.02,8.12 184.02,7.94 183.93,7.85 183.57,7.85 183.48,7.77 183.48,7.55 183.57,7.46 184.52,7.46 184.62,7.36 184.62,7.17 184.53,7.08 183.62,7.08 183.54,6.99 183.54,6.76 183.62,6.67 v1(184.99,6.67)
  BOTTOM w0.102: UC1.AN21 125.62,52.8 125.24,52.42 125.2,52.42 v1(125.2,52.41) ; v1(184.99,6.67) 184.53,6.2 JDIMM2.250
DDR_B_DQS0: length 47.1
  IN1 w0.076: v1(116.15,43.38) 116.15,43.47 116.25,43.57 116.41,43.57 116.56,43.42 116.56,37.02 116.55,37.01 116.55,36.99
  IN1 w0.091: v1(122.12,10.2) 121.92,10.41 121.72,10.41 121.5,10.63 121.5,11.43 118.87,14.06 118.67,14.06 118.54,13.93 118.19,13.93 117.95,14.17 117.95,14.52 118.08,14.65 118.08,14.85 117.95,14.99 117.75,14.99 117.62,14.85 117.27,14.85 117.03,15.1 117.03,15.44 117.16,15.58 117.16,15.77 116.74,16.19 116.74,36 116.55,36.18 116.55,36.99
  BOTTOM w0.076: v1(116.15,43.38) 115.97,43.55 115.74,43.55 115.59,43.71 115.59,46.07 115.49,46.17 115.49,46.68 115.58,46.78 115.58,47.19 115.53,47.3 115.53,47.52 115.58,47.63 115.58,47.96 115.63,48.08 UC1.AY38
  BOTTOM w0.099: JDIMM2.13 123.28,12.08 123.19,12 123.19,10.76 122.85,10.41 122.33,10.41 v1(122.12,10.2)
DDR_B_DQS1: length 51.1
  IN1 w0.076: v1(119.54,42.03) 119.54,42.23 119.46,42.31 119.26,42.31 119.14,42.2 119.14,39.25 119.61,38.78 119.61,37.81 120.77,36.66 120.77,35.75 120.77,35.75 120.77,35.73
  IN1 w0.091: 120.77,35.73 120.77,29.99 120.96,29.81 120.96,23.03 121.28,22.71 121.47,22.71 121.66,22.89 122,22.89 122.32,22.57 122.32,22.29 122.07,22.04 122.07,21.91 122.2,21.78 122.4,21.78 122.64,22.02 122.92,22.02 123.23,21.71 123.23,21.43 122.99,21.19 122.99,21 125,18.99 125,14.7 126.95,12.75 126.95,8.34 127.21,8.08 127.87,8.08 128.19,7.76 128.19,7.08 v1(128.6,6.67)
  BOTTOM w0.076: v1(119.54,42.03) 119.45,42.03 118.79,42.69 118.79,45.92 118.57,46.14 118.57,47.23 118.62,47.34 118.62,47.47 118.57,47.6 118.57,47.72 118.33,47.95 UC1.BA34
  BOTTOM w0.099: JDIMM2.34 128.53,5.56 128.21,5.87 128.21,6.28 v1(128.6,6.67)
DDR_B_DQS2: length 87.1
  IN4 w0.076: v1(115.17,51.19) 115.17,51.04 115.25,50.96 115.51,50.96 115.68,50.79 115.68,49.08 116.91,47.84 117.35,47.84 118.06,47.13 119.95,47.13 120.36,46.72 120.36,46.34 120.86,45.85 122.04,45.85 122.66,45.23 123.64,45.23 124.3,44.57 124.3,43.99 124.3,43.98 124.3,43.96
  IN4 w0.091: v1(166.02,10.3) 166.02,10.42 166.14,10.53 166.56,10.53 166.76,10.73 166.76,14.99 167.54,15.78 167.54,18.63 164.12,22.06 163.56,22.06 163.44,21.94 163.3,21.94 163.05,22.19 163.05,22.32 163.44,22.71 163.44,23.09 163.17,23.36 162.8,23.36 162.44,23 162.23,23 162.05,23.18 162.05,23.38 162.41,23.74 162.41,24.09 162.21,24.29 160.94,24.29 156.38,28.85 149.95,28.85 149.73,28.62 148.19,28.62 148,28.82 147.05,28.82 146.86,28.62 133.71,28.62 131.08,31.25 131.08,31.59 128.43,34.25 127.94,34.25 124.3,37.88 124.3,43.96
  BOTTOM w0.099: v1(115.17,51.19) 115.33,51.19 115.6,51.47 UC1.AR38 ; JDIMM2.179 166.78,10.78 166.56,10.56 166.28,10.56 v1(166.02,10.3)
DDR_B_DQS3: length 87.4
  IN4 w0.076: 127.14,45.07 127.13,45.09 127.13,45.1 125.15,47.08 123.98,47.08 123.12,47.94 121.43,47.94 120.06,49.31 119.36,49.31 119.17,49.5 119.17,50.77 v1(118.8,51.14)
  IN4 w0.091: v1(172.55,6.8) 172.31,7.03 172.07,7.03 171.63,7.46 171.63,11.47 171.68,11.52 171.68,12.33 172.68,13.32 172.68,14.75 171.76,15.66 171.76,20.3 161.34,30.72 160.43,30.72 159.95,31.21 159.95,31.74 158.31,33.37 151.52,33.37 151.25,33.64 139.16,33.64 138.12,34.68 134.25,34.68 133.61,35.32 133.61,36.32 133.26,36.67 132.81,36.67 131.69,37.79 131.69,38.24 130.72,39.22 130.72,41.5 127.14,45.07
  BOTTOM w0.076: UC1.AR32 118.9,51.14 v1(118.8,51.14)
  BOTTOM w0.099: JDIMM2.200 172.03,5.82 171.87,5.98 171.87,6.94 171.97,7.04 172.3,7.04 v1(172.55,6.8)
DDR_B_DQS4: length 49.9
  IN1 w0.076: 124.21,35.33 124.21,36.01 122.17,38.06 122.17,42 122.05,42.12 v1(121.39,42.12)
  IN1 w0.091: 124.21,35.33 124.35,35.2 124.35,33.06 124.61,32.79 124.61,27.08 129.58,22.11 129.58,16.93 130.13,16.38 130.47,16.38 130.98,16.89 131.11,16.89 131.31,16.68 131.31,16.55 130.81,16.05 130.81,15.7 132.19,14.32 132.19,10.47 132.39,10.28 132.61,10.28 v1(132.79,10.1)
  BOTTOM w0.076: v1(121.39,42.12) 121.19,42.31 120.97,42.31 120.77,42.51 120.77,45.51 120.53,45.75 120.53,46.55 120.56,46.58 120.56,47.19 120.51,47.3 120.51,47.52 120.56,47.63 120.56,48.18 UC1.AY30
  BOTTOM w0.099: JDIMM2.55 133.78,12.12 133.72,12.06 133.72,10.38 133.44,10.1 v1(132.79,10.1)
DDR_B_DQS5: length 52.8
  IN1 w0.076: v1(124.99,40.52) 124.99,40.69 125.14,40.84 125.41,40.84 125.49,40.75 125.49,39.37 125.89,38.98 126.4,38.98 127.88,37.5 127.88,36.75 129.22,35.41 129.22,34.99 129.22,34.98 129.22,34.96
  IN1 w0.091: 129.22,34.96 129.22,34.11 129.94,33.38 129.94,30.89 131.12,29.71 131.12,27.37 133.37,25.12 133.37,23.37 137.65,19.09 137.65,8.23 138.8,7.07 139.25,7.07 v1(139.53,6.8)
  BOTTOM w0.076: UC1.BA26 123.47,48.06 123.55,47.98 123.55,47.59 123.6,47.48 123.6,47.34 123.55,47.23 123.55,46.83 123.75,46.62 123.75,45.29 124.01,45.03 v4(124.01,41.99) 124.01,41.2 124.37,40.85 124.77,40.85 124.99,40.62 v1(124.99,40.52)
  BOTTOM w0.099: v1(139.53,6.8) 139.25,7.07 138.99,7.07 138.71,6.79 138.71,5.88 139.03,5.56 JDIMM2.76
DDR_B_DQS6: length 85.9
  IN1 w0.076: v1(121.55,51.14) 121.92,50.77 121.92,49.55 121.6,49.24 121.6,48.59 121.95,48.24 122.18,48.24 122.79,47.63 122.79,47.62 122.81,47.6
  IN1 w0.091: v1(176.23,10.22) 176,10.45 175.8,10.45 175.6,10.65 175.6,12.84 173.58,14.86 170.57,17.87 170.31,17.87 170.14,17.69 170.14,17.45 171.18,16.41 171.18,16.05 170.9,15.76 170.47,15.76 168.35,17.88 149.52,17.88 145.96,21.44 138.66,28.74 138.66,31.03 134.97,34.72 134.97,35.84 133.45,37.36 133.45,38.33 131.31,40.47 131.31,41.37 130.09,42.59 129.31,42.59 125.24,46.67 123.74,46.67 122.81,47.6
  BOTTOM w0.076: v1(121.55,51.14) UC1.AR27
  BOTTOM w0.099: JDIMM2.221 177.28,12.01 177.17,11.9 177.17,10.83 176.74,10.4 176.4,10.4 v1(176.23,10.22)
DDR_B_DQS7: length 89
  IN4 w0.076: 132.36,46.15 132.34,46.15 132.34,46.16 131.43,46.16 129.92,47.67 128.82,47.67 128.58,47.91 126.74,47.91 125.52,49.12 125.21,49.12 124.66,49.68 124.66,50.69 124.46,50.89 124.46,51.37 124.63,51.54 124.97,51.54 v1(125.2,51.77)
  IN4 w0.091: 132.36,46.15 132.55,46.15 135.79,42.91 136.59,42.91 137.66,41.84 142.77,41.84 142.98,41.62 147.67,41.62 149.36,39.94 150.76,39.94 151.45,39.25 152.86,39.25 153.88,38.23 157.07,38.23 158.05,39.21 158.81,39.21 160.66,37.36 160.66,36.61 164.54,32.73 165.38,32.73 173.49,24.63 173.49,23.72 176.52,20.68 176.52,17.05 177.04,16.53 177.95,16.53 180.93,13.56 180.93,8.48 181.7,7.7 181.7,7.46 182.37,6.8 182.83,6.8 v1(182.96,6.67)
  BOTTOM w0.076: v1(125.2,51.77) 125.47,51.5 UC1.AR21
  BOTTOM w0.099: JDIMM2.242 182.53,5.82 182.37,5.98 182.37,6.67 182.53,6.83 182.8,6.83 v1(182.96,6.67)
DDR_B_DQS#0: length 47
  IN1 w0.076: v1(116.15,44.08) 116.15,43.81 116.23,43.74 116.48,43.74 116.73,43.49 116.73,37.02 116.74,37.01 116.74,36.99
  IN1 w0.091: 116.74,36.99 116.74,36.26 116.92,36.07 116.92,16.27 117.34,15.85 117.34,15.5 117.21,15.37 117.21,15.17 117.35,15.03 117.54,15.03 117.67,15.17 118.02,15.17 118.26,14.92 118.26,14.58 118.13,14.44 118.13,14.25 118.27,14.11 118.46,14.11 118.6,14.24 118.94,14.24 121.68,11.51 121.68,10.7 121.8,10.59 122.01,10.59 122.13,10.71 v1(122.13,11.05)
  BOTTOM w0.076: v1(116.15,44.08) 116.17,44.06 116.17,43.93 115.96,43.72 115.81,43.72 115.75,43.78 115.75,46.14 115.65,46.24 115.65,46.61 115.75,46.71 115.75,47.22 115.69,47.36 115.69,47.47 115.75,47.6 115.75,47.93 115.78,48.02 115.82,48.06 UC1.BA38
  BOTTOM w0.099: v1(122.13,11.05) 122.13,10.71 122.23,10.6 122.77,10.6 123.01,10.84 123.01,12 122.94,12.08 122.87,12.08 122.78,12.17 JDIMM2.11
DDR_B_DQS#1: length 51.1
  IN1 w0.076: v1(119.54,42.68) 119.33,42.48 119.19,42.48 118.98,42.27 118.98,39.18 119.45,38.71 119.45,37.74 120.6,36.59 120.6,35.75 120.59,35.75 120.59,35.73
  IN1 w0.091: 120.59,35.73 120.59,29.92 120.78,29.73 120.78,22.95 121.2,22.53 121.55,22.53 121.73,22.71 121.93,22.71 122.14,22.5 122.14,22.37 121.89,22.12 121.89,21.84 122.13,21.6 122.47,21.6 122.71,21.84 122.84,21.84 123.05,21.64 123.05,21.51 122.81,21.27 122.81,20.92 124.82,18.91 124.82,14.63 126.77,12.67 126.77,8.26 127.14,7.9 127.8,7.9 128.01,7.68 v1(128.01,6.68)
  BOTTOM w0.076: UC1.AY34 118.43,48.57 118.73,48.27 118.73,47.63 118.78,47.52 118.78,47.3 118.73,47.19 118.73,46.21 118.95,45.99 118.95,42.76 119.2,42.51 119.37,42.51 v1(119.54,42.68)
  BOTTOM w0.099: JDIMM2.32 128.03,6.66 v1(128.01,6.68)
DDR_B_DQS#2: length 87.1
  IN4 w0.076: 124.12,43.96 124.12,43.98 124.13,43.99 124.13,44.5 123.57,45.06 122.6,45.06 121.97,45.69 120.79,45.69 120.2,46.27 120.2,46.65 119.88,46.96 117.99,46.96 117.28,47.68 116.84,47.68 115.51,49.01 115.51,50.72 115.44,50.79 115.22,50.79 115.12,50.69 v1(115.12,50.48)
  IN4 w0.091: v1(166.02,11.02) 166.02,10.84 166.14,10.71 166.48,10.71 166.58,10.81 166.58,15.07 167.36,15.86 167.36,18.56 164.04,21.88 163.64,21.88 163.52,21.76 163.22,21.76 162.87,22.12 162.87,22.4 163.26,22.79 163.26,23.01 163.1,23.18 162.87,23.18 162.51,22.82 162.15,22.82 161.87,23.11 161.87,23.46 162.23,23.82 162.23,24.01 162.14,24.11 160.87,24.11 156.31,28.67 150.03,28.67 149.8,28.44 148.11,28.44 147.92,28.64 147.12,28.64 146.93,28.44 133.63,28.44 130.9,31.18 130.9,31.51 128.35,34.07 127.86,34.07 124.12,37.81 124.12,43.96
  BOTTOM w0.076: v1(115.12,50.48) 115.23,50.37 115.35,50.37 115.48,50.49 115.61,50.49 115.68,50.57 115.68,50.77 UC1.AT38
  BOTTOM w0.099: v1(166.02,11.02) 166.02,10.86 166.13,10.74 166.48,10.74 166.59,10.85 166.59,11.88 166.28,12.19 JDIMM2.177
DDR_B_DQS#3: length 87.4
  IN4 w0.076: 127.27,45.2 127.26,45.22 127.25,45.22 125.21,47.25 124.04,47.25 123.19,48.11 121.5,48.11 120.13,49.48 119.43,49.48 119.34,49.57 119.34,50.76 v1(119.72,51.14)
  IN4 w0.091: v1(172.55,7.43) 172.32,7.21 172.14,7.21 171.81,7.53 171.81,11.4 171.86,11.44 171.86,12.25 172.86,13.25 172.86,14.82 171.95,15.74 171.95,20.37 161.41,30.9 160.51,30.9 160.13,31.28 160.13,31.81 158.39,33.55 151.59,33.55 151.33,33.82 139.24,33.82 138.19,34.86 134.33,34.86 133.79,35.4 133.79,36.39 133.33,36.85 132.88,36.85 131.87,37.86 131.87,38.32 130.9,39.29 130.9,41.57 127.27,45.2
  BOTTOM w0.076: UC1.AT32 119.55,51.14 v1(119.72,51.14)
  BOTTOM w0.099: v1(172.55,7.43) 172.34,7.23 171.89,7.23 171.68,7.02 171.68,5.98 171.53,5.82 JDIMM2.198
DDR_B_DQS#4: length 49.8
  IN1 w0.076: v1(121.39,42.77) 121.39,42.58 121.44,42.52 121.58,42.52 121.66,42.44 121.66,42.37 121.75,42.28 122.12,42.28 122.33,42.07 122.33,38.13 124.38,36.08 124.38,35.42 124.39,35.41
  IN1 w0.091: 124.39,35.41 124.53,35.28 124.53,33.14 124.8,32.87 124.8,27.15 129.76,22.18 129.76,17 130.2,16.56 130.4,16.56 130.9,17.07 131.18,17.07 131.5,16.76 131.5,16.48 130.99,15.97 130.99,15.78 132.37,14.39 132.37,10.55 132.46,10.46 132.59,10.46 132.79,10.66 v1(132.79,10.73)
  BOTTOM w0.076: v1(121.39,42.77) 121.39,42.55 121.31,42.48 121.03,42.48 120.93,42.58 120.93,45.58 120.7,45.81 120.7,46.48 120.73,46.51 120.73,47.23 120.68,47.34 120.68,47.48 120.73,47.59 120.73,48.02 120.81,48.1 120.92,48.1 UC1.BA30
  BOTTOM w0.099: JDIMM2.53 133.28,12.18 133.34,12.11 133.46,12.11 133.53,12.04 133.53,10.46 133.36,10.29 133.18,10.29 132.97,10.5 132.85,10.5 132.79,10.56 v1(132.79,10.73)
DDR_B_DQS#5: length 52.9
  IN1 w0.076: v1(124.99,41.17) 125.17,41 125.47,41 125.66,40.82 125.66,39.44 125.96,39.15 126.46,39.15 128.05,37.56 128.05,36.82 129.39,35.48 129.39,34.99 129.4,34.98 129.4,34.96
  IN1 w0.091: 129.4,34.96 129.4,34.18 130.12,33.46 130.12,30.97 131.3,29.79 131.3,27.44 133.55,25.2 133.55,23.44 137.83,19.17 137.83,8.31 138.88,7.25 139.4,7.25 v1(139.53,7.38)
  BOTTOM w0.076: UC1.AY26 123.71,48.11 123.71,47.63 123.77,47.52 123.77,47.3 123.71,47.19 123.71,46.9 123.92,46.69 123.92,45.35 124.18,45.09 124.18,42.33 124.22,42.29 124.22,41.7 124.18,41.65 124.18,41.27 124.44,41.02 124.83,41.02 v1(124.99,41.17)
  BOTTOM w0.099: v1(139.53,7.38) 139.4,7.25 138.91,7.25 138.52,6.87 JDIMM2.74
DDR_B_DQS#6: length 85.9
  IN1 w0.076: v1(122.46,51.14) 122.26,51.14 122.08,50.96 122.08,49.48 121.77,49.17 121.77,48.66 122.02,48.41 122.25,48.41 122.91,47.74 122.92,47.74 122.94,47.73
  IN1 w0.091: 122.94,47.73 123.82,46.85 125.32,46.85 129.39,42.77 130.17,42.77 131.49,41.45 131.49,40.54 133.63,38.41 133.63,37.44 135.15,35.91 135.15,34.8 138.84,31.11 138.84,28.81 149.59,18.06 168.42,18.06 170.54,15.95 170.82,15.95 171,16.12 171,16.33 169.96,17.38 169.96,17.77 170.24,18.05 170.64,18.05 175.78,12.91 175.78,10.72 175.87,10.63 176,10.63 v1(176.23,10.86)
  BOTTOM w0.076: UC1.AR25 122.97,51.45 122.97,51.32 122.67,51.02 122.65,51.01 122.54,51.01 122.46,51.09 v1(122.46,51.14)
  BOTTOM w0.099: v1(176.23,10.86) 176.23,10.77 176.41,10.59 176.66,10.59 176.98,10.91 176.98,11.89 176.78,12.09 JDIMM2.219
DDR_B_DQS#7: length 89.1
  IN4 w0.076: 132.36,46.33 132.34,46.33 132.34,46.33 131.5,46.33 129.99,47.84 128.88,47.84 128.65,48.07 126.81,48.07 125.59,49.29 125.28,49.29 124.82,49.75 124.82,50.76 124.63,50.95 124.63,51.3 124.7,51.38 124.97,51.38 v1(125.2,51.14)
  IN4 w0.091: 132.36,46.33 132.62,46.33 135.87,43.09 136.66,43.09 137.74,42.02 142.84,42.02 143.06,41.8 147.75,41.8 149.43,40.12 150.84,40.12 151.53,39.43 152.94,39.43 153.95,38.41 156.99,38.41 157.97,39.39 158.88,39.39 160.84,37.43 160.84,36.69 164.62,32.91 165.46,32.91 173.67,24.7 173.67,23.79 176.7,20.76 176.7,17.13 177.11,16.71 178.03,16.71 181.11,13.64 181.11,8.55 181.88,7.78 181.88,7.54 182.44,6.98 182.69,6.98 182.96,7.24 v1(182.96,7.3)
  BOTTOM w0.076: v1(125.2,51.14) 124.84,51.5 UC1.AR22
  BOTTOM w0.099: JDIMM2.240 182.03,5.82 182.18,5.98 182.18,6.75 182.45,7.02 182.75,7.02 182.96,7.23 v1(182.96,7.3)
DDR_B_MA0: length 85
  IN4 w0.076: v1(112.05,43.46) 111.71,43.11 111.71,40.01 115.19,36.53
  IN4 w0.142: v1(156.67,6.54) 157.26,7.13 157.26,14.6 156.17,15.68 154.88,15.68 150.86,19.7 150.19,19.7 149.27,20.62 122.36,20.62 115.31,27.67 115.31,31.35 115.5,31.54 116.27,31.54 116.46,31.73 116.46,32 116.27,32.19 115.5,32.19 115.31,32.38 115.31,32.65 115.5,32.84 116.27,32.84 116.46,33.03 116.46,33.3 116.27,33.49 115.5,33.49 115.31,33.68 115.31,33.95 115.5,34.14 116.04,34.14 116.18,34.28 116.18,34.65 116.04,34.79 115.52,34.79 115.38,34.93 115.38,36.34 115.19,36.53
  BOTTOM w0.076: UC1.BA46 111.69,47.56 111.95,47.29 111.95,46.08 111.46,45.58 111.46,44.05 v1(112.05,43.46)
  BOTTOM w0.168: v1(156.67,6.54) 156.67,6.29 156.03,5.64 JDIMM2.144
DDR_B_MA1: length 85.1
  IN4 w0.076: 112.6,35.01 112.6,36.12 109.92,38.8 109.92,40.35 v1(109.55,40.72)
  IN4 w0.142: v1(152.48,9.72) 153.53,10.77 153.53,12.23 150.96,14.8 150.96,15.63 150.31,16.28 149.54,16.28 147.74,18.09 127.11,18.09 126.92,17.9 126.92,17.19 126.73,17.01 126.46,17.01 126.27,17.2 126.27,17.9 126.08,18.09 125.81,18.09 125.62,17.9 125.62,17.19 125.43,17.01 125.16,17.01 124.97,17.2 124.97,17.9 124.78,18.09 124.51,18.09 124.32,17.9 124.32,17.19 124.13,17.01 123.86,17.01 123.67,17.2 123.67,17.9 123.47,18.09 119.67,18.09 118.79,18.97 118.79,19.24 119.01,19.46 119.01,19.73 118.82,19.92 118.55,19.92 118.33,19.7 118.06,19.7 112.6,25.15 112.6,35.01
  BOTTOM w0.076: UC1.AY46 111.59,48.13 111.49,48.03 111.41,47.81 111.41,47.68 111.48,47.45 111.48,47.31 111.42,47.19 111.42,46.93 111.62,46.73 111.62,46.24 111.08,45.7 111.08,42.25 v1(109.55,40.72)
  BOTTOM w0.168: v1(152.48,9.72) 153.47,10.71 153.47,12.03 153.28,12.23 JDIMM2.133
DDR_B_MA2: length 85.3
  IN4 w0.076: v1(109.5,42) 109.16,41.66 109.16,38.58 111.54,36.2 111.54,35.99
  IN4 w0.142: v1(154,6.8) 153.58,6.37 153.58,5.41 153.44,5.28 153.1,5.28 152.92,5.45 152.92,6.43 153.06,6.57 153.06,8.28 152.05,9.28 152.05,12.5 147.54,17.01 128.05,17.01 127.19,16.16 123.23,16.16 122.38,17.01 118.31,17.01 111.54,23.78 111.54,35.99
  BOTTOM w0.076: UC1.AY47 111.29,48.41 111.29,47.98 111.24,47.82 111.24,47.68 111.3,47.46 111.3,47.34 111.27,47.26 111.26,47.23 111.26,46.86 111.46,46.66 111.46,46.32 110.88,45.73 110.88,43.38 v2(110.72,43.22) v1(109.5,42)
  BOTTOM w0.168: v1(154,6.8) 153.88,6.8 153.03,5.94 JDIMM2.132
DDR_B_MA3: length 82.8
  IN4 w0.076: v1(109.55,40.04) 109.55,38.72 112.02,36.24 112.02,35.33
  IN4 w0.142: v1(152.48,10.99) 152.96,11.47 152.96,12.18 147.72,17.43 127.86,17.43 127.01,16.58 123.41,16.58 122.56,17.43 118.86,17.43 118.21,18.07 117.94,18.07 117.75,18.27 117.75,18.53 118.05,18.83 118.05,19.1 117.86,19.29 117.59,19.29 117.29,18.99 117.02,18.99 116.83,19.19 116.83,19.45 117.13,19.75 117.13,20.02 116.94,20.21 116.67,20.21 116.37,19.91 116.1,19.91 115.91,20.11 115.91,20.37 116.21,20.67 116.21,20.94 116.02,21.13 115.75,21.13 115.45,20.83 115.18,20.83 114.99,21.03 114.99,21.29 115.29,21.59 115.29,21.86 115.1,22.05 114.83,22.05 114.53,21.75 114.26,21.75 114.07,21.95 114.07,22.21 114.37,22.51 114.37,22.78 114.18,22.97 113.91,22.97 113.61,22.67 113.34,22.67 113.15,22.87 113.15,23.13 113.45,23.43 113.45,23.7 113.26,23.89 112.99,23.89 112.69,23.59 112.42,23.59 112.23,23.79 112.23,24.05 112.53,24.35 112.53,24.62 112.02,25.13 112.02,35.33
  BOTTOM w0.076: v1(109.55,40.04) 111.26,41.74 111.26,45.63 111.79,46.16 111.79,46.98 UC1.BB46
  BOTTOM w0.168: v1(152.48,10.99) 152.87,10.99 153.04,11.15 153.04,11.85 152.78,12.12 JDIMM2.131
DDR_B_MA4: length 84.1
  IN4 w0.076: 110.53,35.83 110.53,36.17 108.72,37.98 108.72,42.29 v1(109.4,42.97)
  IN4 w0.142: v1(152.38,6.75) 151,5.37 150.53,5.37 150.22,5.68 150.22,6.64 150.69,7.12 150.69,8.96 151.19,9.46 151.19,12.17 147.19,16.17 128.65,16.17 127.79,15.31 122.89,15.31 122.03,16.17 117.96,16.17 110.53,23.6 110.53,35.83
  BOTTOM w0.076: v1(109.4,42.97) 110.67,44.24 110.67,46.7 110.79,46.82 110.79,47.22 110.79,47.22 110.76,47.31 110.76,47.51 110.79,47.6 110.79,47.6 110.8,47.6 110.8,47.61 110.8,47.84 UC1.BA47
  BOTTOM w0.168: v1(152.38,6.75) 152.03,6.39 JDIMM2.128
DDR_B_MA5: length 85.3
  IN4 w0.076: v1(109.36,44.17) 109.83,43.7 109.83,42.87 108.95,41.98 108.95,38.31 111.02,36.25 111.02,35.83
  IN4 w0.142: 111.02,35.83 111.02,23.71 118.14,16.59 122.21,16.59 123.06,15.73 127.62,15.73 128.47,16.59 147.37,16.59 151.62,12.34 151.62,9.29 151.12,8.79 151.12,8.56 151.31,8.37 151.68,8.37 151.87,8.18 151.87,7.91 151.68,7.72 151.31,7.72 151.12,7.53 151.12,7.06 151.28,6.9 151.92,6.9 152.06,7.04 152.06,7.39 v1(152.61,7.94)
  BOTTOM w0.076: v1(109.36,44.17) 109.77,44.17 v2(110.11,44.52) 110.51,44.91 110.51,46.81 110.63,46.93 110.63,47.19 110.59,47.28 110.59,47.29 110.59,47.54 110.63,47.63 110.63,47.84 110.6,47.92 110.6,47.92 110.56,48.02 110.56,48.19 UC1.AY48
  BOTTOM w0.168: JDIMM2.126 151.52,6.86 v1(152.61,7.94)
DDR_B_MA6: length 83
  IN4 w0.076: 109.56,35.74 109.56,36.07 108.27,37.36 108.27,42.78 108.72,43.23 108.72,44.62 v1(109.5,45.41)
  IN4 w0.142: v1(150.7,9.59) 150.43,9.59 150.24,9.78 150.24,10.59 149.45,11.38 149.45,11.77 149.82,12.14 149.82,12.35 149.48,12.69 149.23,12.69 149.09,12.55 148.84,12.55 148.66,12.73 148.66,12.97 148.8,13.11 148.8,13.36 148.63,13.54 148.38,13.54 148.24,13.4 147.99,13.4 147.82,13.57 147.82,13.82 147.96,13.96 147.96,14.21 147.42,14.75 142.55,14.75 141.98,15.32 136.32,15.32 135.68,14.68 132.51,14.68 131.87,15.32 129,15.32 128.08,14.41 122.6,14.41 121.68,15.32 120.34,15.32 120.34,15.3 119.86,14.82 119.48,14.82 119.29,15.01 119.29,15.1 119.09,15.29 118.83,15.29 118.64,15.1 118.64,15.01 118.44,14.82 118.18,14.82 117.98,15.01 117.98,15.1 117.79,15.29 117.53,15.29 117.33,15.1 117.33,15.01 117.14,14.82 116.65,14.82 114.87,16.6 114.87,18.07 109.56,23.38 109.56,35.74
  BOTTOM w0.076: UC1.BA48 110.36,47.51 110.09,47.24 110.09,46.92 110.18,46.84 110.18,46.29 109.5,45.62 v1(109.5,45.41)
  BOTTOM w0.168: v1(150.7,9.59) 151.78,10.66 JDIMM2.127
DDR_B_MA7: length 86.6
  IN4 w0.076: v1(109.66,51.77) 110.03,51.4 110.03,49.57 109.3,48.84 109.3,46.24 108.25,45.19 108.25,43.47 107.89,43.11 107.89,36.86 108.68,36.08 108.68,35.51
  IN4 w0.142: 108.68,35.51 108.68,23.07 113.91,17.84 113.91,16.29 116.36,13.84 120.9,13.84 121.17,13.57 137.17,13.57 137.36,13.76 137.36,14.29 137.55,14.48 137.82,14.48 138.01,14.29 138.01,13.76 138.2,13.57 139.71,13.57 139.89,13.74 139.89,14.31 140.05,14.47 140.3,14.47 140.49,14.29 140.49,13.74 140.66,13.57 144.87,13.57 145.25,13.19 146.97,13.19 148.27,11.89 148.27,11.3 149.36,10.21 149.36,9.08 149.65,8.79 v1(149.65,7.71)
  BOTTOM w0.076: v1(109.66,51.77) UC1.AP48
  BOTTOM w0.168: v1(149.65,7.71) 149.65,7.6 150.52,6.72 JDIMM2.122
DDR_B_MA8: length 82
  IN4 w0.076: 110.08,35.63 110.08,36.09 108.48,37.69 108.48,42.51 108.95,42.98 108.95,44.44 109.29,44.77 v1(109.5,44.77)
  IN4 w0.142: v1(150.7,10.8) 150.31,11.19 150.31,12.45 147.02,15.74 146.43,15.74 146.24,15.55 146.24,15.37 146.05,15.18 145.78,15.18 145.59,15.37 145.59,15.55 145.4,15.74 145.13,15.74 144.94,15.55 144.94,15.37 144.75,15.18 144.48,15.18 144.29,15.37 144.29,15.55 144.09,15.74 143.83,15.74 143.64,15.55 143.64,15.37 143.44,15.18 143.18,15.18 142.98,15.37 142.98,15.55 142.79,15.74 134.98,15.74 134.78,15.55 134.78,15.29 134.6,15.11 134.33,15.11 134.13,15.31 134.13,15.55 133.94,15.74 133.67,15.74 133.48,15.55 133.48,15.33 133.29,15.14 133.02,15.14 132.83,15.33 132.83,15.55 132.64,15.74 128.82,15.74 127.91,14.83 122.77,14.83 121.86,15.74 117.79,15.74 117.52,16.02 117.25,16.02 116.82,15.59 116.49,15.59 116.3,15.78 116.3,15.99 116.79,16.48 116.79,16.75 116.6,16.94 116.33,16.94 115.86,16.47 115.6,16.47 115.41,16.66 115.41,16.94 115.87,17.4 115.87,17.67 110.08,23.45 110.08,35.63
  BOTTOM w0.076: v1(109.5,44.77) 110.34,45.61 110.34,46.88 110.36,46.9 UC1.BB48
  BOTTOM w0.168: JDIMM2.125 151.28,11.18 150.89,10.8 v1(150.7,10.8)
DDR_B_MA9: length 82.7
  IN4 w0.076: v1(108.74,51.77) 109.12,51.4 109.12,49.73 108.68,49.29 108.68,48.39 107.98,47.69 107.98,45.81 106.86,44.69 106.86,39.47 107.4,38.93 107.4,36.37 107.69,36.09 107.69,35.34
  IN4 w0.142: 107.69,35.34 107.69,22.87 113.01,17.54 113.01,15.86 115.88,13 120.37,13 120.65,12.72 143.94,12.72 144.46,12.21 146.12,12.21 148.42,9.91 v1(148.42,9.57)
  BOTTOM w0.076: v1(108.74,51.77) UC1.AP50
  BOTTOM w0.168: v1(148.42,9.57) 148.65,9.57 150.28,11.2 JDIMM2.121
DDR_B_MA10: length 84.8
  IN4 w0.076: v1(112.1,44.05) 112.93,43.22 112.93,40.25 115.52,37.66 115.96,37.66 116.55,37.07
  IN4 w0.142: v1(158.19,7.18) 158.68,7.66 158.68,14.98 156.46,17.2 155.43,17.2 151.42,21.21 150.75,21.21 149.9,22.07 125.69,22.07 125.48,22.28 125.48,22.55 125.78,22.85 125.78,23.12 125.59,23.31 125.32,23.31 125.02,23.01 124.75,23.01 124.56,23.2 124.56,23.47 124.86,23.77 124.86,24.04 124.67,24.23 124.4,24.23 124.1,23.93 123.83,23.93 121.19,26.56 120.92,26.56 120.71,26.35 120.44,26.35 120.25,26.54 120.25,26.81 120.46,27.02 120.46,27.29 120.27,27.48 120,27.48 119.79,27.27 119.52,27.27 119.33,27.46 119.33,27.73 119.54,27.94 119.54,28.21 119.35,28.4 119.08,28.4 118.87,28.19 118.6,28.19 118.41,28.38 118.41,29.35 118.29,29.46 118.29,35.33 116.55,37.07
  BOTTOM w0.076: v1(112.1,44.05) 111.66,44.49 111.66,45.55 112.12,46 112.12,47.73 111.88,47.96 111.88,48.46 111.78,48.66 111.59,48.85 UC1.AW46
  BOTTOM w0.168: v1(158.19,7.18) 158.53,6.85 JDIMM2.146
DDR_B_MA11: length 88.4
  IN4 w0.076: v1(109.66,52.41) 109.28,52.03 109.28,49.43 109,49.15 109,46.37 107.38,44.76 107.38,44.44 107.92,43.91 107.92,43.54 107.69,43.31 107.69,36.62 108.13,36.17 108.13,35.73
  IN4 w0.142: v1(149.05,7.43) 149.02,7.46 147.05,7.46 146.89,7.62 146.89,8.18 147.14,8.43 148.77,8.43 148.91,8.57 148.91,10.06 147.84,11.13 147.84,11.71 146.89,12.67 144.95,12.67 144.48,13.14 120.96,13.14 120.68,13.42 116.17,13.42 113.47,16.12 113.47,17.68 108.13,23.02 108.13,35.73
  BOTTOM w0.076: v1(109.66,52.41) UC1.AN48
  BOTTOM w0.168: JDIMM2.120 150.03,6.46 v1(149.05,7.43)
DDR_B_MA12: length 85.7
  IN4 w0.076: v1(108.74,53.06) 108.2,52.52 108.2,50.24 107.93,49.96 107.93,48.75 107.26,48.08 107.26,46.44 106.48,45.66 106.48,38.7 106.77,38.4 106.77,37.55
  IN4 w0.142: v1(147.45,9.94) 147.09,10.31 141.18,10.31 140.46,9.59 137.01,9.59 136.48,9.06 132.38,9.06 132.38,9.06 121.75,9.06 121.39,9.43 121.39,10.25 120.6,11.04 120.6,11.59 120.15,12.03 115.04,12.03 106.77,20.3 106.77,37.55
  BOTTOM w0.076: v1(108.74,53.06) 109,52.8 UC1.AN50
  BOTTOM w0.168: JDIMM2.119 149.78,11.39 148.49,10.1 147.61,10.1 v1(147.45,9.94)
DDR_B_MA13: length 82.3
  IN4 w0.076: 121.12,35.1 121.12,35.26 118.51,37.86 118.15,37.86 116.84,39.18 116,39.18 115.05,40.13 115.05,42.81 v1(114.53,43.33)
  IN4 w0.142: v1(161.65,6.89) 161.74,6.98 161.74,13.96 161.65,14.05 161.65,15.74 159.15,18.24 159.15,19.88 158.57,20.45 158.23,20.45 158.05,20.27 157.75,20.27 157.56,20.46 157.56,20.7 157.81,20.95 157.81,21.22 157.62,21.41 157.35,21.41 157.17,21.23 156.91,21.23 156.71,21.43 156.71,21.69 156.89,21.87 156.89,22.14 156.7,22.33 156.43,22.33 156.25,22.15 155.99,22.15 155.79,22.35 155.79,22.61 155.97,22.79 155.97,23.06 155.78,23.25 155.51,23.25 155.33,23.07 155.07,23.07 154.87,23.27 154.87,23.53 155.05,23.71 155.05,23.98 154.62,24.41 151.19,24.41 150.97,24.63 129.1,24.63 127.93,25.8 127.93,26.4 123.44,30.88 123.44,32.37 121.12,34.7 121.12,35.1
  BOTTOM w0.076: UC1.BA43 113.61,47.83 113.61,47.59 113.62,47.56 113.66,47.47 113.66,47.36 113.61,47.22 113.61,46.97 113.61,46.96 113.61,46.84 113.75,46.7 113.75,44.06 v2(114.15,43.66) 114.48,43.33 v1(114.53,43.33)
  BOTTOM w0.168: JDIMM2.158 161.53,6.76 v1(161.65,6.89)
DDR_B_MA14: length 86.1
  IN4 w0.076: 120.09,34.9 120.09,35.31 116.74,38.66 115.74,38.66 114.35,40.04 v1(114.35,41.52)
  IN4 w0.142: 120.09,34.9 120.09,34.07 121.87,32.29 121.87,32.02 122.06,31.83 122.34,31.83 122.53,31.64 122.53,31.37 122.34,31.18 122.06,31.18 121.87,30.99 121.87,30.74 122.06,30.55 122.48,30.55 122.67,30.36 122.67,30.09 122.48,29.9 122.06,29.9 121.87,29.71 121.87,29.5 125.47,25.9 125.74,25.9 126.05,26.22 126.32,26.22 126.51,26.03 126.51,25.76 126.2,25.44 126.2,25.17 126.38,24.99 127.32,24.99 128.53,23.79 150.62,23.79 150.84,23.57 151.78,23.57 151.97,23.38 151.97,23.23 152.16,23.04 152.43,23.04 152.62,23.23 152.62,23.38 152.81,23.57 153.21,23.57 153.66,23.12 153.66,22.85 153.13,22.32 153.13,22.05 153.32,21.86 153.59,21.86 154.12,22.39 154.39,22.39 154.58,22.2 154.58,21.93 154.05,21.4 154.05,21.13 154.24,20.94 154.51,20.94 155.04,21.47 155.31,21.47 155.5,21.28 155.5,21.01 154.97,20.48 154.97,20.21 155.16,20.02 155.43,20.02 155.96,20.55 156.23,20.55 156.42,20.36 156.42,20.09 155.89,19.56 155.89,19.29 156.08,19.1 156.35,19.1 156.88,19.63 157.15,19.63 157.45,19.32 157.45,18.75 160.58,15.62 v1(160.58,11.09)
  BOTTOM w0.076: v1(114.35,41.52) 113.27,42.59 113.27,45.52 112.78,46.01 112.78,46.72 112.98,46.92 112.98,47.19 112.93,47.31 112.93,47.45 112.99,47.68 112.99,47.81 112.92,48.03 112.92,48.04 112.81,48.14 UC1.AY44
  BOTTOM w0.168: v1(160.58,11.09) 159.78,11.9 JDIMM2.151
DDR_B_MA15: length 86.6
  IN4 w0.076: 120.61,34.73 120.61,35.16 116.85,38.93 115.91,38.93 114.74,40.11 114.74,41.84 v1(114.48,42.1)
  IN4 w0.142: 120.61,34.73 120.61,34.42 123.02,32.01 123.02,30.7 123.9,29.82 123.9,29.55 123.32,28.97 123.32,28.7 123.51,28.51 123.78,28.51 124.36,29.09 124.63,29.09 124.82,28.9 124.82,28.63 124.24,28.05 124.24,27.78 124.43,27.59 124.7,27.59 125.28,28.17 125.55,28.17 125.74,27.98 125.74,27.71 125.16,27.13 125.16,26.86 125.35,26.67 125.62,26.67 126.2,27.25 126.47,27.25 127.51,26.22 127.51,25.63 128.93,24.21 150.79,24.21 151.01,23.99 153.38,23.99 158.13,19.24 158.13,18.67 161.17,15.63 161.17,13.85 161.27,13.75 161.27,8.05 161.13,7.91 160.7,7.91 160.55,8.05 v1(160.55,8.41)
  BOTTOM w0.076: UC1.AY43 113.19,48.42 113.19,48.32 113.11,48.16 113.11,47.98 113.16,47.82 113.16,47.68 113.1,47.46 113.1,47.34 113.15,47.23 113.15,46.85 112.96,46.67 112.96,46.19 113.45,45.7 113.45,43.13 v1(114.48,42.1)
  BOTTOM w0.168: v1(160.55,8.41) 161.03,7.94 JDIMM2.156
DDR_B_MA16: length 83.8
  IN4 w0.076: v1(112.1,45.32) 113.25,44.17 113.25,40.28 115.51,38.02 116.27,38.02 117.35,36.94
  IN4 w0.142: 117.35,36.94 118.8,35.49 118.8,29.64 123.39,25.05 124.45,25.05 127.01,22.49 150.08,22.49 150.78,21.79 151.49,21.79 155.5,17.78 156.48,17.78 159.11,15.15 159.11,6.6 158.62,6.11 158.62,5.53 158.79,5.36 159.59,5.36 159.73,5.5 159.73,6.14 v1(160.34,6.75)
  BOTTOM w0.076: v1(112.1,45.32) 112.28,45.5 112.28,47.73 112.52,47.96 112.52,48.43 112.54,48.5 112.65,48.71 112.81,48.88 UC1.AW44
  BOTTOM w0.168: v1(160.34,6.75) 160.03,6.43 JDIMM2.152
DDR_B_ODT0: length 87.4
  IN4 w0.076: v1(114.53,43.96) 115.35,43.14 115.35,40.23 116.17,39.42 116.83,39.42 118.06,38.18 118.64,38.18 121.7,35.12 121.7,35.04 121.88,34.86
  IN4 w0.142: 121.88,34.86 124.09,32.64 124.09,31.15 129.96,25.28 151.24,25.28 151.46,25.06 155.6,25.06 156.37,24.29 156.37,24.09 156.22,23.94 156.22,23.74 156.43,23.53 156.73,23.53 156.83,23.63 157.07,23.63 157.28,23.42 157.28,23.16 157.15,23.03 157.15,22.8 157.35,22.6 157.64,22.6 157.74,22.7 157.96,22.7 158.18,22.49 158.18,22.22 158.1,22.14 158.1,21.85 158.31,21.64 158.51,21.64 158.63,21.76 158.98,21.76 159.12,21.61 159.12,21.33 158.98,21.18 158.98,20.98 159.2,20.75 159.47,20.75 159.59,20.87 159.79,20.87 159.97,20.69 159.97,18.35 161.17,17.15 161.96,17.15 162.24,16.87 162.24,16.1 162.38,15.96 162.63,15.96 162.89,15.7 162.89,15.35 162.67,15.13 162.67,14.23 162.41,13.98 162.41,9.63 162.75,9.3 162.75,8.72 162.41,8.39 162.41,7.77 162.63,7.55 163.24,7.55 163.38,7.69 163.38,9.91 163.22,10.08 v1(162.9,10.08)
  BOTTOM w0.076: UC1.BA42 113.83,47.52 113.83,47.32 113.77,47.19 113.77,46.99 113.78,46.98 113.78,46.9 113.91,46.77 113.91,44.58 v1(114.53,43.96)
  BOTTOM w0.168: v1(162.9,10.08) 162.67,10.08 160.78,11.97 JDIMM2.155
DDR_B_ODT1: length 88.3
  IN4 w0.076: 117.62,45.52 115.26,47.88 114.45,47.88 113.37,48.96 v1(113.37,49.86)
  IN4 w0.142: v1(163.33,11.66) 163.33,13.13 163.59,13.38 164,13.38 164.35,13.73 164.35,17.64 155.95,26.04 152.11,26.04 151.85,26.29 130.47,26.29 128.86,27.9 128.86,29.35 128.43,29.78 128.15,29.78 126.36,31.57 126.36,31.66 123.2,34.82 123.2,35.19 120.92,37.48 120.92,43.37 120.81,43.48 120.23,43.48 120.12,43.37 120.12,39.27 119.84,38.98 119.08,38.98 118.74,39.32 118.74,44.41 117.62,45.52
  BOTTOM w0.076: v1(113.37,49.86) 113.45,49.86 114.04,49.27 UC1.AW42
  BOTTOM w0.127: v1(163.33,11.66) 162.88,11.66 162.28,12.27 JDIMM2.161
DDR_B_PARITY: length 88.4
  IN4 w0.076: 113.68,37.53 111.42,39.79 111.42,45.19 112.78,46.55 112.78,51.45 v1(112.43,51.79)
  IN4 w0.142: v1(155.02,8.7) 155.64,9.32 155.95,9.32 156.17,9.1 156.17,7.79 156.32,7.65 156.63,7.65 156.83,7.86 156.83,12.92 150.89,18.86 150.12,18.86 148.79,20.2 121.96,20.2 114.85,27.3 114.85,36.36 113.68,37.53
  BOTTOM w0.076: UC1.AP43 112.79,52.15 v1(112.43,51.79)
  BOTTOM w0.168: JDIMM2.143 155.78,9.46 v1(155.02,8.7)
DDR_DRAMRST#: length 216.7
  TOP w0.102: v1(66.66,3.3) RD12.2 RD11.2 ; v1(184.85,27.26) 184.85,27.26 184.35,26.75 184.35,22.81 180.37,18.84 v1(180.37,18.08)
  IN1 w0.089: v1(180.37,18.08) 180.37,16.38 180.79,15.96 180.79,9.35 181.74,8.4 181.74,3.7 180.92,2.88 169.68,2.88 166.78,5.77 162.79,5.77 160.98,3.96 160.41,3.96 159.33,2.88 139.71,2.88 139.13,2.3 119.89,2.3 115.96,6.24 111.26,6.24 107.45,2.43 104.84,2.43 104.46,2.81 103.13,2.81 102.75,2.43 90.68,2.43 90.3,2.81 85.98,2.81 85.35,2.18 67.79,2.18 v1(66.66,3.3) ; v1(184.85,27.26) 184.83,27.24 180.52,27.24 179.46,28.3 171.28,28.3 168.58,31.01 164.54,31.01 161.65,33.9 160.27,33.9 159.52,34.65 155.01,34.65 153.3,36.36 148.4,36.36 147.24,37.52 147.24,38.68 141.81,44.11 138.81,44.11 136.12,46.8 132.92,46.8 130.19,49.53 130.19,50.11 129.81,50.49 v1(129.71,50.49)
  BOTTOM w0.102: UC1.AT13 130.07,50.85 v1(129.71,50.49)
DDR_DRAMRST#_R: length 99.4
  TOP w0.102: v1(147.03,3.57) 146.15,2.7 143.13,2.7 v2(142.42,3.41) 142.07,3.76 CD61.1 ; v1(66.03,6.06) 65.88,5.92 CD29.1 65.92,5.23 RD12.1
  BOTTOM w0.102: v1(66.03,6.06) JDIMM1.108 66.03,2.26 66.57,1.72 101.56,1.72 102.71,2.87 106.32,2.87 107.5,4.05 107.68,4.05 111.08,7.45 115.44,7.45 120.39,2.51 145.96,2.51 v1(147.03,3.57) JDIMM2.108
DDR_VTT_CTRL: length 53.5
  TOP w0.102: v1(64.47,15.49) 63.89,16.07 UD1.2
  IN3 w0.122: v1(64.47,15.49) 66.68,15.49 84.66,33.46 v1(84.66,33.46)
  BOTTOM w0.076: v1(84.66,33.46) 84.66,36.57 91.72,43.63 91.72,45.51 92.46,46.25 93.94,46.25 94.98,47.28 94.98,47.87 95.28,48.18 95.28,48.53 95.69,48.94 96.49,48.94 96.75,49.2 98.02,49.2 98.08,49.13 98.72,49.13 98.82,49.03 UC1.AW67
DDR_XDP_WAN_SMBCLK: length 405
  TOP w0.102: QC2.1 152.22,65.6 152.61,65.99 RC319.1 152.74,66.6 v1(152.74,66.62) ; v1(260.58,24.4) 260.74,24.55 260.74,31.14 264.72,35.12 265.49,35.12 270.45,40.09 270.45,41.18 271.66,42.39 273.88,42.39 274.28,42.78 274.28,45.62 274.17,45.72 v1(273.33,45.72) ; JXDP1.53 62.45,34.73 62.55,34.63 62.55,34.28 62.04,33.77 60.21,33.77 59.33,34.65 59.33,36.23 56.99,38.57 56.13,38.57 v1(55.95,38.74)
  IN1 w0.089: v1(186.44,9.79) 186.44,8.03 188.9,5.57 196.3,5.57 196.75,6.02 201.31,6.02 203.05,4.27 209.24,4.27 209.75,3.76 224.36,3.76 226.3,5.69 236.5,5.69 241.34,10.53 241.34,13.38 247.42,19.46 253.27,19.46 254.37,20.55 258.35,20.55 259.09,21.29 259.09,22.37 260.76,24.05 260.76,24.22 v1(260.58,24.4)
  IN2 w0.122: v1(186.44,9.79) 186.44,8.73 186.23,8.53 185.71,8.53 184.37,9.86 184.37,11.29 183.02,12.64 135.67,12.64 134.85,13.45 104.12,13.45 103.49,14.09 103.49,14.72 103.65,14.88 104.15,14.88 104.28,14.76 v1(104.28,14.34)
  IN4 w0.089: v1(55.95,38.74) 55.76,38.56 55.59,38.56 55.3,38.27 55.3,35.51 53.67,33.87 53.24,33.87 47.06,27.7 47.06,25.16 47.33,24.9 47.66,24.9 47.75,24.81 v1(47.75,24.45) ; v1(152.74,66.62) 152.81,66.69 153.58,66.69 154.25,66.02 154.25,63.81 155.78,62.28 155.78,61.32 157.57,59.53 157.57,55.03 159.01,53.59 159.01,51.94 160.3,50.66 160.3,49.71 164.67,45.33 165.72,45.33 172.55,38.49 172.55,37.47 177.44,32.59 177.44,28.19 178.8,26.83 178.8,25.61 182.34,22.06 182.34,20.37 184.08,18.64 184.08,17.65 183.75,17.32 183.75,16.02 189.24,10.53 189.24,8.53 188.58,7.87 186.9,7.87 186.44,8.33 v1(186.44,9.79)
  BOTTOM w0.102: JDIMM2.253 185.28,10.91 186.39,9.79 v1(186.44,9.79) ; v1(273.33,45.72) 273.72,45.33 LGA1.1 ; v1(47.75,24.45) 48.44,24.45 51.25,21.65 95.16,21.65 101.87,14.93 104.17,14.93 104.28,14.83 v1(104.28,14.34) 104.98,15.05 107.8,15.05 108.81,14.04 108.81,9.29 108.65,9.13 108.26,9.13 107.63,9.77 107.63,12.84 106.28,14.19 104.8,14.19 104.28,13.67 JDIMM1.253
DDR_XDP_WAN_SMBDAT: length 404.9
  TOP w0.102: v1(274.99,45.75) 274.76,45.75 274.5,45.49 274.5,42.68 273.98,42.16 271.75,42.16 270.68,41.08 270.68,39.99 265.58,34.89 264.81,34.89 260.96,31.05 260.96,24.61 v1(261.17,24.4) ; QC2.4 148.79,66.9 RC318.1 148.86,67.2 149.48,67.2 150.65,68.37 152.32,68.37 v1(152.72,67.96) ; v1(55.95,38.16) 56.13,38.34 56.9,38.34 59.1,36.13 59.1,34.55 60.12,33.54 62.14,33.54 62.78,34.18 62.78,34.57 62.95,34.74 JXDP1.51
  IN1 w0.089: v1(186.31,7.06) 187.1,7.06 188.81,5.35 196.39,5.35 196.84,5.8 201.22,5.8 202.96,4.06 209.15,4.06 209.66,3.54 224.45,3.54 226.39,5.48 236.59,5.48 241.56,10.44 241.56,13.29 247.51,19.24 253.36,19.24 254.46,20.34 258.44,20.34 259.3,21.2 259.3,22.28 260.98,23.96 260.98,24.21 v1(261.17,24.4)
  IN2 w0.122: v1(186.31,7.06) 186.31,7.57 184.12,9.76 184.12,11.19 182.92,12.39 135.56,12.39 134.75,13.2 104.02,13.2 103.24,13.98 103.24,14.82 103.55,15.13 103.9,15.13 v1(104.09,15.32)
  IN4 w0.089: v1(47.92,25.3) 47.73,25.11 47.42,25.11 47.28,25.25 47.28,27.61 53.33,33.66 53.76,33.66 55.52,35.42 55.52,38.18 55.68,38.34 55.76,38.34 v1(55.95,38.16) ; v1(152.72,67.96) 152.72,67.56 153.38,66.9 153.67,66.9 154.47,66.11 154.47,63.9 156,62.37 156,61.41 157.78,59.62 157.78,55.12 159.23,53.68 159.23,52.03 160.51,50.75 160.51,49.79 164.76,45.55 165.81,45.55 172.77,38.58 172.77,37.56 177.65,32.68 177.65,28.28 179.02,26.92 179.02,25.7 182.56,22.15 182.56,20.46 184.31,18.71 184.31,17.57 183.96,17.23 183.96,16.11 189.45,10.62 189.45,8.44 188.67,7.65 186.9,7.65 v1(186.31,7.06)
  BOTTOM w0.102: v1(274.99,45.75) 275.22,45.52 LGA1.4 ; JDIMM2.254 185.53,5.83 186.31,6.62 v1(186.31,7.06) ; v1(47.92,25.3) 51.34,21.88 95.26,21.88 101.97,15.16 103.94,15.16 v1(104.09,15.32) 107.94,15.32 109.09,14.17 109.09,6.5 106.28,3.69 104.63,3.69 104.53,3.79 JDIMM1.254
DEBUG_TX: length 15.7
  BOTTOM w0.102: JDEG1.9 276.55,73.9 277.17,73.27 277.17,72.68 276.84,72.34 RE74.2 273.54,71.74 272.94,71.74 272.63,72.04 272.63,72.39 271.31,73.71 v2(271.31,77.26) 271.31,78 271.75,78.44 RE30.2
DEW1: length 5.6
  TOP w0.102: RN16.2 280.41,61.22 279.4,61.22 279,60.82 v1(278.76,60.82) 278.76,61.52 279.11,61.86 UN7.16
  BOTTOM w0.102: v2(279.99,61.22) 279.72,61.49 RN17.2 278.76,61.2 v1(278.76,60.82)
DEW2: length 3.9
  TOP w0.102: UN7.6 v1(273.61,64.32) 273.14,64.79 RN14.2
  BOTTOM w0.102: RN15.2 273.32,64.03 v1(273.61,64.32) 274.05,64.32 v2(274.21,64.48)
DGPU_PWROK: length 3.3
  TOP w0.102: UE1.M4 304.76,73.93 305.34,73.93 305.62,73.65 306.49,73.65 306.65,73.5 306.65,72.95 T147.1
DIMM1_SA0: length 4.9
  TOP w0.102: v1(104.9,6.06) 104.9,5.23 v2(104.58,4.91) RD4.2 RD5.1
  BOTTOM w0.102: JDIMM1.256 105.03,5.93 v1(104.9,6.06)
DIMM1_SA1: length 4.7
  TOP w0.102: RD6.2 RD7.1 105.66,3.98 v2(105.66,5.69) 106.03,6.06 v1(106.15,6.06)
  BOTTOM w0.102: v1(106.15,6.06) 106.03,5.94 JDIMM1.260
