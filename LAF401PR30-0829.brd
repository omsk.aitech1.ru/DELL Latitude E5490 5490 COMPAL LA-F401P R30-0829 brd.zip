# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA14: length 75.2
  IN1 w0.076: v1(110.57,51.14) 110.21,50.77 110.21,50.66 110.21,50.02 110.2,49.59 112.01,47.78 112.01,45.94 112.58,45.37 112.58,41.36 112.19,40.97 112.19,39.77 111.51,39.1 111.51,37.67
  IN1 w0.142: 111.51,37.67 111.51,24.66 106,19.14 105.73,19.14 105.41,19.46 105.14,19.46 104.95,19.27 104.95,19 105.4,18.54 105.4,18.27 105.21,18.08 104.95,18.08 104.49,18.54 104.22,18.54 104.03,18.35 104.03,18.08 104.48,17.62 104.48,17.37 104.29,17.18 104.01,17.18 103.57,17.62 103.3,17.62 103.11,17.43 103.11,17.16 103.43,16.84 103.43,16.32 102.8,15.69 87.53,15.69 87.33,15.49 81.93,15.49 80.79,14.35 80.79,13.84 80.52,13.57 80.01,13.57 79.68,13.25 79.68,10.98 79.54,10.84 v1(79.38,10.84)
  BOTTOM w0.076: v1(110.57,51.14) UC1.AT46
  BOTTOM w0.168: v1(79.38,10.84) 79.24,10.84 78.78,11.3 JDIMM1.151
DDR_A_MA15: length 75.8
  IN1 w0.076: v1(110.57,50.5) 110.96,50.12 110.96,49.31 112.52,47.74 112.52,46.29 113.14,45.68 113.14,39.67 112.53,39.06 112.53,37.67
  IN1 w0.142: 112.53,37.67 112.53,23.01 111.58,22.06 111.31,22.06 111.02,22.36 110.77,22.36 110.58,22.17 110.58,21.88 110.85,21.6 110.85,21.33 110.66,21.14 110.39,21.14 110.22,21.32 109.95,21.32 109.76,21.13 109.76,20.86 109.93,20.68 109.93,20.41 104.32,14.8 87.91,14.8 87.47,14.36 84.39,14.36 83.58,13.54 82.01,13.54 80.62,12.15 80.62,10.51 79.98,9.86 79.98,8.16 80.61,7.53 v1(80.61,7.3)
  BOTTOM w0.076: v1(110.57,50.5) UC1.AU48
  BOTTOM w0.168: JDIMM1.156 80.03,6.72 v1(80.61,7.3)
DDR_A_MA16: length 74.8
  IN1 w0.076: 110.6,37.77 110.6,39.04 111.36,39.8 111.36,45.63 110.43,46.56 110.43,48.62 109.66,49.39 v1(109.66,49.86)
  IN1 w0.142: 110.6,37.77 110.6,25.39 110.47,25.26 110.2,25.26 109.83,25.63 109.56,25.63 109.37,25.44 109.37,25.17 109.74,24.8 109.74,24.53 109.56,24.36 109.3,24.36 109.12,24.54 108.85,24.54 108.66,24.35 108.66,24.08 108.84,23.9 108.84,23.63 108.64,23.44 108.38,23.44 108.2,23.62 107.93,23.62 100.89,16.58 87.05,16.58 86.87,16.4 81.65,16.4 78.24,12.99 78.24,8.45 79.47,7.22 v1(79.47,6.92)
  BOTTOM w0.076: v1(109.66,49.86) 109.54,49.86 109.2,50.2 UC1.AU50
  BOTTOM w0.168: v1(79.47,6.92) 79.03,6.48 JDIMM1.152
DDR_A_ODT0: length 78.2
  IN1 w0.076: 113.62,37.67 113.62,39.22 113.72,39.33 113.72,47.89 111.95,49.66 111.95,50.04 v1(111.49,50.5)
  IN1 w0.142: v1(81.74,9.64) 81.84,9.75 81.84,11.85 82.46,12.47 84.16,12.47 84.87,13.18 104.35,13.18 105.42,14.24 106.13,14.24 106.53,13.85 106.8,13.85 106.99,14.04 106.99,14.31 106.37,14.93 106.37,15.2 106.56,15.39 106.83,15.39 107.45,14.77 107.72,14.77 107.91,14.96 107.91,15.23 107.29,15.85 107.29,16.12 107.48,16.31 107.75,16.31 108.37,15.69 108.64,15.69 108.83,15.88 108.83,16.23 108.26,16.79 108.26,17.09 113.62,22.45 113.62,37.67
  BOTTOM w0.076: v1(111.49,50.5) 111.83,50.85 UC1.AT45
  BOTTOM w0.168: v1(81.74,9.64) 79.78,11.61 JDIMM1.155
DDR_A_ODT1: length 79
  IN1 w0.076: 114.51,37.67 114.51,41.1 114.9,41.5 114.9,45.39 115.14,45.63 115.14,47.52 112.77,49.88 112.77,50.17 112.43,50.5 v1(112.41,50.5)
  IN1 w0.142: v1(82.73,10.94) 83.19,10.94 83.88,11.63 84.76,11.63 85.3,12.16 106.23,12.16 106.42,12.35 106.42,12.68 106.61,12.87 106.88,12.87 107.07,12.68 107.07,12.35 107.26,12.16 107.53,12.16 107.72,12.35 107.72,12.68 107.91,12.87 108.18,12.87 108.37,12.68 108.37,12.35 108.56,12.16 108.92,12.16 109.65,12.88 109.65,13.15 108.98,13.82 108.98,14.09 109.17,14.28 109.44,14.28 110.2,13.52 110.52,13.52 110.71,13.71 110.71,13.93 109.9,14.74 109.9,15.01 110.09,15.2 110.36,15.2 111.03,14.53 111.3,14.53 114.51,17.75 114.51,37.67
  BOTTOM w0.076: UC1.AT43 112.78,50.85 112.43,50.5 v1(112.41,50.5)
  BOTTOM w0.168: v1(82.73,10.94) 82.56,11.11 82,11.11 81.28,11.84 JDIMM1.161
DDR_A_PARITY: length 73.6
  IN1 w0.076: v1(107.81,50.52) 108.32,50.02 108.32,49.76 108.44,49.64 108.44,47.3 110.27,45.47 110.27,40.05 109.4,39.18 109.4,38.31 109.26,38.17 109.26,35.1
  IN1 w0.142: 109.26,35.1 109.26,28.09 108.92,27.75 108.65,27.75 108.52,27.88 108.25,27.88 108.06,27.69 108.06,27.42 108.19,27.29 108.19,27.02 108,26.83 107.73,26.83 107.6,26.96 107.33,26.96 107.14,26.77 107.14,26.5 107.27,26.37 107.27,26.1 107.08,25.91 106.81,25.91 106.68,26.04 106.41,26.04 106.22,25.85 106.22,25.58 106.35,25.45 106.35,25.18 106.16,24.99 105.89,24.99 105.76,25.12 105.49,25.12 105.3,24.93 105.3,24.66 105.43,24.53 105.43,24.26 105.24,24.07 104.97,24.07 104.84,24.2 104.57,24.2 104.38,24.01 104.38,23.74 104.57,23.55 104.57,23.22 104.38,23.03 104.17,23.03 103.92,23.28 103.65,23.28 103.46,23.09 103.46,22.82 103.91,22.36 103.91,21.89 100.31,18.28 84.54,18.28 84,17.75 80.4,17.75 76.8,14.15 76.8,11.54 v1(76.66,11.4)
  BOTTOM w0.076: UC1.AT52 108.14,50.85 v1(107.81,50.52)
  BOTTOM w0.168: v1(76.66,11.4) 76.32,11.74 75.29,11.74 74.78,12.25 JDIMM1.143
DDR_B_ACT#: length 85.6
  IN4 w0.076: v1(106.87,52.5) 106.38,52.01 106.38,49.58 105.58,48.78 105.58,44.26 105.3,43.99 105.3,36.54 104.81,36.05 104.81,35.34
  IN4 w0.142: 104.81,35.34 104.81,19.65 118.88,5.58 145.67,5.58 146.8,6.71 147.42,6.71 147.57,6.57 147.59,6.57 v1(147.93,6.22)
  BOTTOM w0.076: UC1.AN53 107.29,52.81 106.93,52.49 v1(106.87,52.5)
  BOTTOM w0.168: JDIMM2.114 148.52,5.63 v1(147.93,6.22)
DDR_B_ALERT#: length 89.6
  IN4 w0.076: 109.1,35.39 109.1,36.12 108.06,37.16 108.06,42.9 108.48,43.32 108.48,45 109.82,46.34 109.82,47.78 110.2,48.16 110.2,53.26 110.55,53.61 111.65,53.61 112.19,53.06 112.41,53.06 v1(112.43,53.09)
  IN4 w0.142: v1(149.03,6.14) 150.25,7.36 150.25,9.02 149.8,9.47 149.8,10.39 148.77,11.43 148.77,12.03 147.05,13.74 145.37,13.74 144.92,14.19 142.27,14.19 141.56,14.9 136.55,14.9 135.83,14.18 132.37,14.18 131.81,14.75 129.02,14.75 128.26,13.99 122.39,13.99 121.68,14.7 120.43,14.7 120.01,14.28 116.53,14.28 114.4,16.4 114.4,17.94 109.1,23.24 109.1,35.39
  BOTTOM w0.102: v1(112.43,53.09) 112.6,53.09 112.86,52.84 UC1.AN43
  BOTTOM w0.168: JDIMM2.116 v1(149.03,6.14)
DDR_B_BA0: length 83.5
  IN4 w0.076: 115.34,36.92 112.19,40.07 v1(112.19,41.62)
  IN4 w0.142: v1(158.19,8.45) 157.71,8.93 157.71,9.36 158.18,9.83 158.18,10.03 157.71,10.5 157.71,14.74 156.24,16.21 155.06,16.21 151.03,20.24 150.53,20.24 149.7,21.07 122.55,21.07 117.28,26.35 117.28,28.14 117.09,28.33 116.26,28.33 116.07,28.53 116.07,28.79 116.26,28.98 117.09,28.98 117.28,29.18 117.28,29.44 117.09,29.64 116.26,29.64 116.07,29.83 116.07,30.09 116.26,30.29 116.98,30.29 117.12,30.43 117.12,35.14 115.34,36.92
  BOTTOM w0.076: UC1.BB44 112.61,46.98 112.61,45.85 113.02,45.45 113.02,42.45 v1(112.19,41.62)
  BOTTOM w0.168: v1(158.19,8.45) 158.32,8.45 159.53,7.24 JDIMM2.150
DDR_B_BA1: length 84.5
  IN4 w0.076: v1(112.21,42.26) 112.56,41.91 112.56,40.24 115.94,36.87 115.98,36.87
  IN4 w0.142: v1(158.17,11.58) 158.17,14.89 156.32,16.73 155.22,16.73 151.23,20.73 150.64,20.73 149.84,21.53 122.84,21.53 122.42,21.95 122.42,22.22 123.06,22.86 123.06,23.13 122.87,23.32 122.6,23.32 121.96,22.68 121.69,22.68 121.5,22.87 121.5,23.14 122.14,23.78 122.14,24.05 121.95,24.24 121.68,24.24 121.04,23.6 120.77,23.6 120.58,23.79 120.58,24.06 121.22,24.7 121.22,24.97 121.03,25.16 120.76,25.16 120.12,24.52 119.85,24.52 119.66,24.71 119.66,24.98 120.3,25.62 120.3,25.89 120.11,26.08 119.84,26.08 119.2,25.44 118.93,25.44 118.74,25.63 118.74,25.9 119.38,26.54 119.38,26.81 119.19,27 118.92,27 118.28,26.36 118.01,26.36 117.78,26.6 117.78,35.07 115.98,36.87
  BOTTOM w0.076: UC1.BA44 112.45,47.47 112.45,45.69 112.64,45.5 v2(112.64,44.98) 112.64,42.68 v1(112.21,42.26)
  BOTTOM w0.168: v1(158.17,11.58) 158.28,11.68 JDIMM2.145
DDR_B_BG0: length 86.3
  IN4 w0.076: 106.27,35.35 106.27,37.17 105.69,37.75 105.69,43.43 106.15,43.89 106.15,45.8 106.91,46.56 106.91,48.99 107.43,49.5 107.43,51.37 v1(107.83,51.77)
  IN4 w0.142: v1(146.65,9.76) 141.43,9.76 140.83,9.17 137.55,9.17 137.03,8.64 136.66,8.64 136.65,8.64 121.51,8.64 120.89,9.26 120.89,10.12 120.04,10.97 117.49,10.97 117.32,10.79 117.32,9.68 117.14,9.5 116.9,9.5 116.72,9.68 116.72,10.79 116.54,10.97 115.47,10.97 106.27,20.17 106.27,35.35
  BOTTOM w0.076: UC1.AP52 108.21,52.15 v1(107.83,51.77)
  BOTTOM w0.168: v1(146.65,9.76) 147.42,10.53 147.67,10.53 148.78,11.64 JDIMM2.115
DDR_B_BG1: length 85.4
  IN4 w0.076: 107.27,35.19 107.27,36.16 107.1,36.33 107.1,38.81 106.68,39.23 106.68,45.05 107.62,45.99 107.62,47.87 108.37,48.61 108.37,52.04 v1(108.74,52.41)
  IN4 w0.142: 107.27,35.19 107.27,22.63 108.26,21.64 108.26,21.4 107.44,20.58 107.44,20.33 107.62,20.16 107.87,20.16 108.68,20.97 108.93,20.97 109.1,20.8 109.1,20.55 108.29,19.74 108.29,19.49 108.47,19.31 108.72,19.31 109.53,20.12 109.78,20.12 112.56,17.34 112.56,15.38 115.36,12.58 120.2,12.58 120.51,12.27 143.43,12.27 144.95,10.75 v1(146.83,10.75)
  BOTTOM w0.076: UC1.AN52 108.68,52.41 v1(108.74,52.41)
  BOTTOM w0.168: JDIMM2.113 148.28,11.74 147.58,11.04 147.21,11.04 146.92,10.75 v1(146.83,10.75)
DDR_B_CKE0: length 85.6
  IN4 w0.076: 105.5,34.66 105.5,43.66 105.86,44.03 105.86,48.64 106.55,49.32 106.55,51.89 106.77,52.12 107.02,52.12 107.24,52.34 107.24,52.7 v1(106.84,53.1)
  IN4 w0.142: v1(145.08,9.07) 144.53,8.52 138.05,8.52 137.52,7.99 120.31,7.99 120.06,7.74 117.73,7.74 105.5,19.97 105.5,34.66
  BOTTOM w0.076: v1(106.84,53.1) 106.32,53.1 106.08,52.86 105.81,52.86 105.75,52.8 UC1.AN56
  BOTTOM w0.168: v1(145.08,9.07) 145.94,9.93 145.94,10.85 147.28,12.18 JDIMM2.109
DDR_B_CKE1: length 85.3
  IN4 w0.076: 104.11,35.22 104.11,35.84 105.14,36.86 105.14,44.3 105.31,44.47 105.31,49.08 105.48,49.25 105.48,51.19 v1(106,51.71)
  IN4 w0.142: v1(147.15,6.06) 145.97,4.88 119.12,4.88 118.53,4.88 112.28,11.14 112.01,11.14 111.93,11.06 111.67,11.06 111.48,11.25 111.48,11.53 111.55,11.6 111.55,11.87 104.11,19.31 104.11,35.22
  BOTTOM w0.076: UC1.AP55 106.01,51.78 v1(106,51.71)
  BOTTOM w0.168: JDIMM2.110 147.52,5.69 v1(147.15,6.06)
DDR_B_CKE2: length 1.7
  TOP w0.168: v1(105.95,52.48) 104.95,52.48 T5.1
  BOTTOM w0.076: UC1.AN55 106.36,52.8 106.03,52.48 v1(105.95,52.48)
DDR_B_CKE3: length 2.2
  TOP w0.168: T6.1 106.43,52.9 106.43,52.3 106.94,51.79 v1(106.94,51.74)
  BOTTOM w0.076: UC1.AP53 106.94,51.8 v1(106.94,51.74)
DDR_B_CLK0: length 88.7
  IN4 w0.076: 114.12,35.64 114.12,35.66 114.11,35.66 114.11,36.44 111.06,39.5 111.06,45.29 111.88,46.11 111.88,47.96 111.8,48.03 111.8,49.26 112.03,49.49 112.03,52.14 112.3,52.41 v1(112.4,52.41)
  IN4 w0.089: v1(155.02,10.1) 155.2,10.28 155.91,10.28 156.19,10.56 156.19,11.09 155.81,11.47 155.81,11.69 156.19,12.07 156.19,12.61 150.57,18.23 149.87,18.23 148.53,19.57 121.5,19.57 119.55,21.52 119.31,21.76 118.08,21.76 117.87,21.97 117.87,22.22 118.31,22.65 118.31,22.95 117.93,23.32 117.62,23.32 117.2,22.9 116.95,22.9 116.77,23.07 116.77,23.32 117.22,23.76 117.22,24.04 116.85,24.4 116.5,24.4 116.05,23.95 115.9,23.95 115.63,24.22 115.63,24.37 116.04,24.79 116.04,25.06 115.64,25.46 115.36,25.46 115,25.1 114.75,25.1 114.12,25.72 114.12,26 114.5,26.38 114.5,26.78 114.12,27.15 114.12,35.64
  BOTTOM w0.076: UC1.AP45 112.2,52.41 v1(112.4,52.41)
  BOTTOM w0.094: v1(155.02,10.1) 154.86,10.26 154.52,10.26 154.24,10.54 154.24,11.42 154.28,11.45 JDIMM2.137
DDR_B_CLK1: length 87.7
  IN4 w0.076: v1(111.49,51.77) 111.32,51.94 111.08,51.94 110.98,51.85 110.98,51.5 111.12,51.36 111.12,47.96 110.42,47.26 110.42,44.48 110.5,44.39 110.5,39.12 113.41,36.21 113.41,35.87 113.42,35.86 113.42,35.84
  IN4 w0.089: 113.42,35.84 113.42,25.47 117.9,20.99 118.98,20.99 119.95,20.02 119.95,19.27 120.32,18.9 148.22,18.9 149.7,17.42 150.39,17.42 153.47,14.34 153.47,13.75 153.86,13.35 154.45,13.35 155.09,12.72 155.09,12.4 154.35,11.67 154.35,10.35 153.52,9.51 153.52,8.97 153.81,8.67 153.91,8.67 154.43,8.15 154.43,7.5 154.86,7.08 155.3,7.08 v1(155.53,7.3)
  BOTTOM w0.094: v1(111.49,51.77) 111.11,52.15 UC1.AP46 ; JDIMM2.138 154.53,5.57 154.65,5.7 154.65,6.76 154.94,7.05 155.27,7.05 v1(155.53,7.3)
DDR_B_CLK#0: length 88.6
  IN4 w0.076: 113.94,35.64 113.94,35.66 113.95,35.66 113.95,36.37 110.89,39.43 110.89,45.35 111.71,46.17 111.71,47.89 111.64,47.97 111.64,49.33 111.87,49.56 111.87,52.26 111.72,52.41 v1(111.49,52.41)
  IN4 w0.089: v1(155.02,10.74) 155.3,10.46 155.84,10.46 156.01,10.63 156.01,11.02 155.63,11.4 155.63,11.76 156.01,12.14 156.01,12.53 150.49,18.05 149.8,18.05 148.46,19.39 121.42,19.39 119.23,21.58 118.01,21.58 117.69,21.9 117.69,22.29 118.13,22.73 118.13,22.88 117.86,23.14 117.7,23.14 117.27,22.72 116.87,22.72 116.59,23 116.59,23.39 117.04,23.84 117.04,23.96 116.78,24.22 116.58,24.22 116.12,23.77 115.82,23.77 115.45,24.14 115.45,24.45 115.86,24.86 115.86,24.99 115.56,25.28 115.44,25.28 115.07,24.92 114.67,24.92 113.94,25.65 113.94,26.08 114.32,26.45 114.32,26.7 113.94,27.08 113.94,35.64
  BOTTOM w0.076: v1(111.49,52.41) 111.8,52.41 111.94,52.56 UC1.AN45
  BOTTOM w0.094: JDIMM2.139 154.78,12.21 154.46,11.9 154.46,11.37 154.43,11.34 154.43,10.62 154.6,10.45 154.79,10.45 155.02,10.68 v1(155.02,10.74)
DDR_B_CLK#1: length 87.7
  IN4 w0.076: 113.24,35.84 113.24,35.86 113.25,35.87 113.25,36.14 110.33,39.06 110.33,44.32 110.25,44.41 110.25,47.33 110.95,48.03 110.95,51.3 110.82,51.43 110.82,52.16 v1(110.57,52.41)
  IN4 w0.089: 113.24,35.84 113.24,25.4 117.82,20.81 118.9,20.81 119.77,19.95 119.77,19.2 120.24,18.72 148.15,18.72 149.63,17.24 150.32,17.24 153.29,14.26 153.29,13.67 153.79,13.17 154.38,13.17 154.91,12.64 154.91,12.48 154.17,11.74 154.17,10.42 153.34,9.59 153.34,8.89 153.73,8.49 153.83,8.49 154.25,8.08 154.25,7.43 154.78,6.9 155.3,6.9 v1(155.53,6.67)
  BOTTOM w0.094: UC1.AN46 110.97,52.8 v1(110.57,52.41) ; JDIMM2.140 155.03,5.55 154.85,5.72 154.85,6.68 155.02,6.86 155.34,6.86 v1(155.53,6.67)
DDR_B_CS#0: length 86.6
  IN4 w0.076: v1(114.53,45.2) 113.9,44.57 113.9,40.08 115.61,38.36 116.43,38.36 117.66,37.13
  IN4 w0.142: v1(160.61,9.74) 160.61,9.23 160.46,9.09 160.03,9.09 159.76,9.35 159.76,9.84 160.08,10.16 160.08,10.56 159.76,10.88 159.76,12.92 159.93,13.1 159.93,15.29 156.78,18.44 155.81,18.44 151.77,22.48 151,22.48 150.35,23.14 127.31,23.14 127.09,23.36 127.09,23.63 127.26,23.81 127.26,24.08 127.07,24.27 126.8,24.27 126.63,24.09 126.36,24.09 124.39,26.06 124.12,26.06 123.82,25.76 123.61,25.76 123.38,25.99 123.38,26.25 123.66,26.52 123.66,26.79 123.47,26.98 123.2,26.98 122.91,26.69 122.67,26.69 122.43,26.93 122.43,27.14 122.74,27.44 122.74,27.71 122.55,27.9 122.28,27.9 122,27.63 121.75,27.63 121.53,27.85 121.53,28.08 121.82,28.36 121.82,28.63 121.63,28.82 121.36,28.82 121.08,28.55 120.85,28.55 120.62,28.78 120.62,29.01 120.9,29.28 120.9,29.55 120.71,29.74 120.44,29.74 120.2,29.51 119.93,29.51 119.74,29.7 119.74,29.97 120.35,30.57 120.35,30.93 120.2,31.07 119.88,31.07 119.69,31.26 119.69,31.74 119.83,31.88 120.66,31.88 120.85,32.07 120.85,32.34 120.66,32.53 119.7,32.53 119.51,32.72 119.51,35.28 117.66,37.13
  BOTTOM w0.076: v1(114.53,45.2) 114.08,45.66 114.08,47.05 UC1.BB42
  BOTTOM w0.168: JDIMM2.149 159.28,11.07 v1(160.61,9.74)
DDR_B_CS#1: length 88.1
  IN4 w0.076: 120.82,36.62 118.93,38.5 117.98,38.5 116.81,39.67 116.22,39.67 115.67,40.21 115.67,44.74 v1(114.54,45.87)
  IN4 w0.142: v1(163.33,10.74) 162.99,10.74 162.84,10.88 162.84,13.59 163.09,13.84 163.76,13.84 163.9,13.98 163.9,14.43 163.55,14.77 163.55,15.53 163.9,15.88 163.9,16.24 163.68,16.46 162.86,16.46 162.72,16.6 162.72,16.94 162.86,17.08 163.71,17.08 163.89,17.27 163.89,17.47 162.83,18.53 162.63,18.53 161.78,17.67 161.48,17.67 161.33,17.82 161.33,18.12 162.17,18.96 162.17,19.18 161.96,19.4 161.7,19.4 160.86,18.56 160.56,18.56 160.42,18.7 160.42,19.08 161.24,19.89 161.24,20.1 155.85,25.48 151.63,25.48 151.41,25.7 130.16,25.7 126.21,29.65 126.21,29.92 126.65,30.36 126.65,30.63 126.46,30.82 126.19,30.82 125.75,30.38 125.48,30.38 124.59,31.27 124.59,32.74 122.47,34.87 122.47,34.97 120.82,36.62
  BOTTOM w0.076: v1(114.54,45.87) 114.24,46.17 114.24,46.8 114.34,46.89 114.34,48.09 UC1.AY42
  BOTTOM w0.168: v1(163.33,10.74) 163.23,10.84 162.59,10.84 161.28,12.15 JDIMM2.157
DDR_B_D0: length 47.7
  IN1 w0.076: v1(116.14,40.32) 116.14,39.64 116.16,39.62 116.16,39.01
  IN1 w0.089: v1(122.51,7.18) 120.96,8.72 120.96,10.34 120.44,10.86 120.44,11.62 119.45,12.6 118.59,12.6 116.16,15.03 116.16,39.01
  BOTTOM w0.076: UC1.AY39 115.32,48.18 115.05,47.92 115.05,47.63 114.95,47.38 114.95,47.36 114.88,47.23 114.88,46.91 114.88,46.91 114.88,46.87 114.88,46.87 114.88,46.82 114.98,46.73 114.98,41.35 116.01,40.32 v1(116.14,40.32)
  BOTTOM w0.102: v1(122.51,7.18) 122.51,7.12 122.03,6.64 JDIMM2.8
DDR_B_D1: length 45.6
  IN1 w0.076: v1(116.17,45.83) 115.53,45.19 115.53,41.88 115.26,41.61 115.26,41.33 114.99,41.06 114.99,39.45 115.14,39.3 115.14,38.92
  IN1 w0.089: v1(118.7,10.44) 118.51,10.44 115.14,13.81 115.14,38.92
  BOTTOM w0.076: UC1.AW39 115.97,49.04 116.23,48.77 116.23,48.2 116.25,48.16 116.25,47.98 116.19,47.82 116.19,47.68 116.26,47.46 116.26,47.34 116.21,47.23 116.21,46.85 116.39,46.67 116.39,46.05 v1(116.17,45.83)
  BOTTOM w0.102: v1(118.7,10.44) 119.42,11.16 120.2,11.16 120.78,11.74 JDIMM2.3
DDR_B_D2: length 47.5
  IN1 w0.076: v1(116.3,45.24) 116.3,45.15 117.02,44.42 117.02,37.03 117.21,36.84
  IN1 w0.089: v1(123.52,7.18) 123.52,8.05 123.39,8.18 122.85,8.18 122.74,8.29 122.74,11.52 122.21,12.05 121.95,12.05 117.51,16.49 117.51,36.54 117.21,36.84
  BOTTOM w0.076: UC1.AY37 116.44,48.28 116.44,48.03 116.37,47.81 116.37,47.68 116.43,47.45 116.43,47.31 116.38,47.19 116.38,46.92 116.56,46.74 116.56,45.59 116.3,45.33 v1(116.3,45.24)
  BOTTOM w0.102: JDIMM2.16 124.03,6.67 v1(123.52,7.18)
DDR_B_D3: length 48.4
  IN1 w0.076: 117.51,36.89 117.25,37.15 117.25,40.44 v1(117.81,41)
  IN1 w0.089: v1(124.82,6.77) 124.82,7.46 123.07,9.21 123.07,11.63 122.31,12.38 122.05,12.38 117.81,16.62 117.81,36.59 117.51,36.89
  BOTTOM w0.076: v1(117.81,41) v2(117.37,41.44) 117.07,41.74 117.07,47.74 116.85,47.96 116.85,48.51 116.54,48.82 UC1.AW37
  BOTTOM w0.102: JDIMM2.20 125.03,6.31 124.82,6.51 v1(124.82,6.77)
DDR_B_D4: length 46.4
  IN1 w0.076: 115.52,38.86 115.52,39.42 115.3,39.65 115.3,41 115.56,41.26 115.56,41.56 v1(116.13,42.13)
  IN1 w0.089: 115.52,38.86 115.52,14.8 117.21,13.12 117.21,12.99 116.98,12.76 116.98,12.52 117.13,12.36 117.32,12.36 117.55,12.59 117.74,12.59 117.88,12.45 117.88,12.25 117.66,12.03 117.66,11.84 117.79,11.7 117.99,11.7 118.21,11.92 118.4,11.92 118.54,11.78 118.54,11.59 118.32,11.37 118.32,11.17 118.46,11.03 118.65,11.03 118.88,11.26 119.07,11.26 119.79,10.53 119.79,10.23 v1(120.02,10)
  BOTTOM w0.076: UC1.BB39 115.32,47.08 115.32,45.11 115.37,45.06 115.37,42.89 v1(116.13,42.13)
  BOTTOM w0.102: JDIMM2.7 121.67,12.9 121.67,11.89 121.48,11.7 121.48,11 121.36,10.88 121.36,10.66 120.71,10 v1(120.02,10)
DDR_B_D5: length 46.4
  IN1 w0.076: v1(116.06,41.5) 115.58,41.02 115.58,39.86 115.83,39.61 115.83,39.08
  IN1 w0.089: 115.83,39.08 115.83,14.93 120.66,10.1 120.66,8.6 121.24,8.02 121.24,7.56 v1(120.86,7.18)
  BOTTOM w0.076: UC1.BA39 115.32,47.59 115.18,47.45 115.17,47.44 115.17,47.44 115.05,47.19 115.05,46.89 115.16,46.79 115.16,42.4 v1(116.06,41.5)
  BOTTOM w0.102: v1(120.86,7.18) 121.24,6.8 121.24,6.03 121.03,5.82 JDIMM2.4
DDR_B_D6: length 47.2
  IN1 w0.076: 117.7,37.06 117.56,37.2 117.56,38.64 117.42,38.78 117.42,40.02 117.76,40.37 117.79,40.37 v1(117.81,40.39)
  IN1 w0.089: v1(123.47,9.72) 123.37,9.82 123.37,11.75 122.42,12.7 122.16,12.7 120.64,14.22 120.64,14.34 120.85,14.55 120.85,14.75 120.68,14.93 120.55,14.93 120.38,14.77 120.1,14.77 119.96,14.9 119.96,15.09 120.14,15.27 120.14,15.47 119.93,15.67 119.75,15.67 119.53,15.46 119.41,15.46 118.12,16.75 118.12,36.64 117.7,37.06
  BOTTOM w0.076: UC1.BA37 116.91,47.47 116.91,41.29 v1(117.81,40.39)
  BOTTOM w0.102: v1(123.47,9.72) 124.03,9.72 125.09,10.78 125.09,11.28 125.28,11.46 JDIMM2.21
DDR_B_D7: length 46.1
  IN1 w0.076: 118.04,37.07 117.79,37.32 v1(117.79,39.22)
  IN1 w0.089: 118.04,37.07 118.47,36.64 118.47,17.67 118.73,17.41 118.92,17.41 119.36,17.85 119.55,17.85 119.69,17.71 119.69,17.52 119.26,17.08 119.26,16.88 119.39,16.75 119.59,16.75 120.02,17.18 120.22,17.18 120.36,17.05 120.36,16.85 119.92,16.41 119.92,16.22 120.06,16.08 120.25,16.08 120.69,16.52 120.88,16.52 121.02,16.38 121.02,16.19 120.59,15.75 120.59,15.55 124.16,11.98 124.16,11.37 v1(123.78,10.99)
  BOTTOM w0.076: UC1.BB37 116.64,46.89 116.72,46.81 116.72,40.29 v1(117.79,39.22)
  BOTTOM w0.102: v1(123.78,10.99) 123.91,10.99 124.29,11.37 124.29,11.78 124.28,11.79 JDIMM2.17
DDR_B_D8: length 51.4
  IN1 w0.076: v1(117.83,42.87) 118.39,42.31 118.39,38.24 118.54,38.09 118.54,37.5
  IN1 w0.089: 118.54,37.5 119.39,36.66 119.39,20.49 122.41,17.47 122.41,17.35 122.05,16.99 122.05,16.84 122.26,16.62 122.45,16.62 122.76,16.93 122.95,16.93 123.27,16.61 123.27,16.13 123.13,15.99 122.5,15.99 122.36,15.85 122.36,15.66 122.5,15.52 123.13,15.52 123.27,15.38 123.27,14.27 125.07,12.46 125.07,8.82 125.29,8.61 125.43,8.61 125.62,8.8 125.85,8.8 126.03,8.63 126.03,8.46 125.81,8.24 125.81,8.09 126.44,7.45 v1(126.44,6.92)
  BOTTOM w0.076: UC1.AY35 117.87,48.28 117.87,48.02 117.91,47.92 117.91,47.92 117.94,47.84 117.94,47.63 117.9,47.54 117.9,47.28 117.94,47.19 117.94,46.92 117.75,46.74 117.75,45.66 118.36,45.05 118.36,43.41 v1(117.83,42.87)
  BOTTOM w0.102: JDIMM2.28 127.03,6.34 v1(126.44,6.92)
DDR_B_D9: length 52.1
  IN1 w0.076: 118.21,37.67 118.21,41.23 v1(117.82,41.62)
  IN1 w0.089: v1(125.43,6.8) 125.43,8 124.77,8.65 124.77,12.34 121.62,15.49 121.62,17.79 121.53,17.88 121.35,17.88 120.96,17.48 120.76,17.48 120.63,17.62 120.63,17.82 121.02,18.21 121.02,18.41 120.88,18.55 120.69,18.55 120.29,18.15 120.1,18.15 119.96,18.29 119.96,18.48 120.36,18.88 120.36,19.07 120.22,19.21 120.02,19.21 119.63,18.81 119.43,18.81 119.3,18.95 119.3,19.15 119.69,19.54 119.69,19.74 119.08,20.35 119.08,36.52 118.21,37.39 118.21,37.67
  BOTTOM w0.076: UC1.AW35 117.77,48.85 117.45,48.52 117.45,47.98 117.35,47.87 117.35,47.42 117.24,47.32 117.24,45.36 117.26,45.34 117.26,42.18 v1(117.82,41.62)
  BOTTOM w0.102: v1(125.43,6.8) 126.03,6.2 JDIMM2.24
DDR_B_D10: length 51.4
  IN1 w0.076: 121.65,35.66 121.65,36.38 120.23,37.81 120.23,40.29 v1(119.66,40.86)
  IN1 w0.089: v1(130.83,6.93) 131.09,7.19 131.09,7.75 130.45,8.39 130.2,8.39 129.8,7.99 129.56,7.99 129.38,8.17 129.38,8.41 129.78,8.81 129.78,9.06 129.69,9.14 128.29,9.14 127.87,9.57 127.87,13.17 125.89,15.16 125.89,19.34 124.15,21.08 124.15,22.12 121.84,24.43 121.84,31.76 121.65,31.95 121.65,35.66
  BOTTOM w0.076: v1(119.66,40.86) 120,41.2 120,44.68 119.67,45.01 119.67,45.97 119.28,46.37 119.28,46.71 119.3,46.74 119.3,46.74 119.43,46.86 119.43,47.25 119.34,47.44 119.27,47.59 119.27,47.91 119,48.18 UC1.AY33
  BOTTOM w0.102: v1(130.83,6.93) 130.53,6.63 JDIMM2.42
DDR_B_D11: length 50.3
  IN1 w0.076: 121.35,36 121.35,36.44 120.02,37.77 120.02,39.88 v1(119.61,40.28)
  IN1 w0.089: 121.35,36 121.35,31.82 121.53,31.63 121.53,24.31 123.84,22 123.84,20.95 125.58,19.22 125.58,14.95 127.56,12.97 127.56,9.36 v1(130,6.92)
  BOTTOM w0.076: v1(119.61,40.28) 118.53,41.36 118.53,45.11 117.92,45.72 117.92,46.37 118.1,46.55 118.1,46.85 118.1,46.85 118.1,47.22 118.1,47.22 118.07,47.31 118.07,47.51 118.1,47.6 118.1,47.6 118.11,47.6 118.11,47.61 118.11,47.84 118.07,47.97 118.07,48.22 118.14,48.32 118.14,48.83 118.35,49.04 UC1.AW33
  BOTTOM w0.102: JDIMM2.38 129.53,6.45 v1(130,6.92)
DDR_B_D12: length 50.1
  IN1 w0.076: v1(117.83,43.52) 118.6,42.75 118.6,38.52 118.86,38.25 118.86,37.57
  IN1 w0.089: 118.86,37.57 119.72,36.72 119.72,21.02 119.72,21.02 119.72,20.64 119.83,20.53 120.03,20.53 120.83,21.33 121.03,21.33 121.16,21.19 121.16,21 120.36,20.19 120.36,20 120.5,19.86 120.69,19.86 121.5,20.66 121.69,20.66 121.83,20.53 121.83,20.33 121.03,19.53 121.03,19.33 123.83,16.53 123.83,14.18 125.39,12.62 125.39,10.14 v1(125.81,9.72)
  BOTTOM w0.076: UC1.BB35 117.59,47 117.59,45.59 118.2,44.98 118.2,43.89 v1(117.83,43.52)
  BOTTOM w0.102: v1(125.81,9.72) 125.94,9.72 127.28,11.06 JDIMM2.29
DDR_B_D13: length 50.8
  IN1 w0.076: 119.13,37.69 119.13,38.55 118.79,38.89 118.79,44.35 118.39,44.75 v1(117.71,44.75)
  IN1 w0.089: v1(125.81,10.99) 126.17,11.34 126.17,12.44 124.18,14.43 124.18,17.56 124.04,17.7 123.25,17.7 123.11,17.84 123.11,18.03 123.25,18.17 124.04,18.17 124.18,18.31 124.18,18.75 123.62,19.3 123.42,19.3 122.59,18.46 122.39,18.46 122.25,18.6 122.25,18.8 123.09,19.63 123.09,19.83 122.95,19.97 122.76,19.97 121.92,19.13 121.73,19.13 121.59,19.27 121.59,19.46 122.43,20.3 122.43,20.49 120.93,21.99 120.73,21.99 120.61,21.87 120.41,21.87 120.28,22.01 120.28,22.2 120.4,22.33 120.4,22.52 120.02,22.9 120.02,36.8 119.13,37.69
  BOTTOM w0.076: UC1.BA35 117.67,47.51 117.4,47.25 117.4,45.43 117.71,45.12 v1(117.71,44.75)
  BOTTOM w0.102: v1(125.81,10.99) 126.28,11.45 JDIMM2.25
DDR_B_D14: length 50.6
  IN1 w0.076: 122.26,35.81 122.26,36.36 120.63,37.99 120.63,41.04 120.34,41.33 120.34,43.78 v1(119.6,44.53)
  IN1 w0.089: 122.26,35.81 122.26,32.2 122.45,32.01 122.45,24.69 127.16,19.97 127.16,18.21 127.02,18.08 126.71,18.08 126.57,17.94 126.57,17.74 126.71,17.61 127.02,17.61 127.16,17.47 127.16,17.27 127.02,17.14 126.71,17.14 126.57,17 126.57,16.8 126.71,16.67 127.02,16.67 127.16,16.53 127.16,16.22 128.57,14.82 128.57,14.62 128.43,14.48 128.23,14.48 127.04,15.68 126.85,15.68 126.71,15.54 126.71,15.34 128.75,13.3 128.75,13.1 128.57,12.92 128.57,12.73 128.71,12.59 128.9,12.59 129.23,12.92 129.36,12.92 129.5,12.79 129.5,11.29 v1(129.11,10.91)
  BOTTOM w0.076: UC1.BA33 119,47.71 119.18,47.4 119.26,47.21 119.26,46.93 119.12,46.79 119.12,46.79 119.11,46.78 119.11,46.3 119.46,45.95 119.46,44.66 v1(119.6,44.53)
  BOTTOM w0.102: v1(129.11,10.91) 129.49,11.29 129.49,11.76 129.28,11.98 JDIMM2.37
DDR_B_D15: length 50.1
  IN1 w0.076: 121.96,35.79 121.96,36.36 120.45,37.87 120.45,40.7 120.06,41.09 120.06,43.39 v1(119.51,43.93)
  IN1 w0.089: v1(129.06,9.57) 128.39,9.57 128.22,9.74 128.22,10.32 128.33,10.43 128.59,10.43 128.68,10.52 128.68,11.9 128.2,12.38 128.2,13.33 126.22,15.31 126.22,19.03 126.82,19.62 126.82,19.81 126.68,19.95 126.48,19.95 126.19,19.66 126,19.66 125.86,19.8 125.86,19.99 126.15,20.28 126.15,20.48 126.01,20.62 125.82,20.62 125.53,20.33 125.33,20.33 125.2,20.46 125.2,20.66 125.49,20.95 125.49,21.14 125.35,21.28 125.15,21.28 124.86,20.99 124.67,20.99 124.45,21.21 124.45,22.25 122.14,24.56 122.14,31.89 121.96,32.07 121.96,35.79
  BOTTOM w0.076: UC1.BB33 118.95,47.03 118.95,46.23 119.21,45.96 119.21,44.23 v1(119.51,43.93)
  BOTTOM w0.102: JDIMM2.41 130.28,12.09 130.02,11.83 130.02,10.92 129.74,10.64 129.74,10.14 129.16,9.57 v1(129.06,9.57)
DDR_B_D16: length 85.6
  IN4 w0.076: v1(114.14,49.81) 114.29,49.66 114.29,48.7 114.65,48.34 115.41,48.34 116.73,47.02 117.06,47.02 117.67,46.41 118.63,46.41 119.51,45.53 119.89,45.53 120.23,45.19 121.65,45.19 122.08,44.76
  IN4 w0.089: 122.08,44.76 122.41,44.43 122.41,37.89 124.42,35.88 124.42,34.95 127.64,31.73 128.54,31.73 129.14,31.13 129.14,30.48 130.4,29.22 130.4,27.89 131.06,27.22 150.42,27.22 150.65,27.45 152.89,27.45 153.25,27.08 156.22,27.08 165.28,18.02 165.28,13.18 164.37,12.26 164.37,8.23 164.66,7.94 v1(165.05,7.94)
  BOTTOM w0.076: v1(114.14,49.81) UC1.AU40
  BOTTOM w0.102: v1(165.05,7.94) 164.6,7.48 164.6,6.57 164.53,6.5 JDIMM2.170
DDR_B_D17: length 86.3
  IN4 w0.076: 121.78,44.77 121.53,45.03 119.68,45.03 118.51,46.19 117.54,46.19 116.95,46.78 116.71,46.78 115.32,48.17 114.52,48.17 113.76,48.94 113.76,50.15 114.11,50.5 v1(114.14,50.5)
  IN4 w0.089: 121.78,44.77 122.01,44.54 122.01,37.76 123.75,36.02 123.75,35.15 127.04,31.87 127.04,31.78 128.41,30.4 128.69,30.4 129.53,29.56 129.53,28.12 130.73,26.92 150.66,26.92 150.89,27.14 152.72,27.14 153.11,26.75 156.12,26.75 164.98,17.89 164.98,13.3 164.04,12.36 164.04,7.75 165.12,6.67 v1(165.33,6.67)
  BOTTOM w0.076: UC1.AT40 114.27,50.5 v1(114.14,50.5)
  BOTTOM w0.102: JDIMM2.174 165.53,6.48 v1(165.33,6.67)
DDR_B_D18: length 87.4
  IN4 w0.076: 125.69,42.56 125.51,42.74 125.51,43.93 123.86,45.58 122.78,45.58 121.58,46.78 120.96,46.78 120.23,47.5 118.32,47.5 117.56,48.26 116.99,48.26 116.45,48.8 116.45,49.98 116.06,50.38 v1(116.06,50.5)
  IN4 w0.089: 125.69,42.56 125.69,39.23 126.39,38.53 126.39,37.16 127.72,35.83 128.17,35.83 132.14,31.87 132.14,31.44 133.99,29.59 138.15,29.59 138.77,30.21 140.71,30.21 141.19,29.74 156.73,29.74 161.27,25.2 162.58,25.2 164.45,23.33 164.45,22.99 168.43,19.01 168.43,15.41 167.98,14.95 167.98,13.32 167.7,13.04 167.7,9.59 167.54,9.43 167.03,9.43 166.86,9.26 166.86,9.04 167.01,8.89 167.54,8.89 167.7,8.73 167.7,8.27 v1(168,7.97)
  BOTTOM w0.076: v1(116.06,50.5) UC1.AT37
  BOTTOM w0.102: v1(168,7.97) 167.37,7.34 167.37,6.4 167.53,6.24 JDIMM2.182
DDR_B_D19: length 86.7
  IN4 w0.076: 125.34,42.61 125.34,43.82 123.74,45.41 122.71,45.41 121.51,46.61 120.89,46.61 120.17,47.34 118.17,47.34 117.46,48.05 116.97,48.05 116.06,48.96 v1(116.06,49.85)
  IN4 w0.089: 125.34,42.61 125.4,42.54 125.4,37.65 128.15,34.9 128.62,34.9 131.66,31.86 131.66,31.49 133.9,29.24 138.25,29.24 138.9,29.9 140.6,29.9 141.06,29.43 156.61,29.43 161.17,24.87 162.48,24.87 164.04,23.31 164.04,22.95 168.13,18.87 168.13,15.54 167.67,15.08 167.67,13.82 167.34,13.49 167.34,10.43 166.12,9.21 166.12,8.52 166.4,8.25 166.8,8.25 167.25,7.79 167.25,7.39 v1(167.97,6.67)
  BOTTOM w0.076: v1(116.06,49.85) UC1.AU37
  BOTTOM w0.102: JDIMM2.186 168.53,6.12 v1(167.97,6.67)
DDR_B_D20: length 86.9
  IN4 w0.076: v1(114.23,51.14) 114.34,51.14 114.53,50.95 114.53,49.71 115.08,49.17 115.08,48.95 116.78,47.25 117.12,47.25 117.75,46.61 118.76,46.61 119.6,45.77 119.95,45.77 120.36,45.36 121.84,45.36 122.48,44.71 123.23,44.71 123.52,44.42 123.52,44.06
  IN4 w0.089: 123.52,44.06 123.52,37.34 125.49,35.36 125.49,34.65 128.11,32.03 128.78,32.03 129.57,31.24 129.57,30.98 131.13,29.42 131.13,28.64 130.76,28.26 130.76,28.07 130.89,27.93 131.09,27.93 131.46,28.3 131.66,28.3 132.43,27.53 150.3,27.53 150.52,27.75 153.1,27.75 153.47,27.39 153.84,27.39 154,27.55 154,27.59 154.16,27.75 154.39,27.75 154.55,27.59 154.55,27.55 154.71,27.39 154.93,27.39 155.09,27.55 155.09,27.59 155.25,27.75 155.48,27.75 155.64,27.59 155.64,27.55 155.8,27.39 156.35,27.39 163.69,20.04 163.92,20.04 164.13,20.26 164.37,20.26 164.53,20.1 164.53,19.89 164.3,19.65 164.3,19.43 164.46,19.27 164.69,19.27 164.91,19.49 165.14,19.49 165.3,19.33 165.3,19.1 165.07,18.88 165.07,18.66 165.59,18.14 165.59,17.93 165.73,17.79 166.04,17.79 166.18,17.65 166.18,17.46 166.04,17.32 165.73,17.32 165.59,17.18 165.59,16.99 165.73,16.85 166.24,16.85 166.38,16.71 166.38,16.52 166.24,16.38 165.73,16.38 165.59,16.24 165.59,12.67 165.2,12.28 165.2,11.43 v1(164.93,11.15)
  BOTTOM w0.076: v1(114.23,51.14) UC1.AR40
  BOTTOM w0.102: v1(164.93,11.15) 165.28,11.5 JDIMM2.173
DDR_B_D21: length 87.9
  IN4 w0.076: 123.84,43.96 123.84,44.43 123.38,44.89 122.54,44.89 121.9,45.52 120.54,45.52 120.01,46.05 119.55,46.05 118.81,46.8 117.82,46.8 117.17,47.45 116.81,47.45 115.24,49.02 115.24,49.24 114.7,49.78 114.7,51.41 114.33,51.77 v1(114.23,51.77)
  IN4 w0.089: 123.84,43.96 123.84,37.52 125.82,35.54 125.82,34.81 127.15,33.48 128.09,33.48 130.16,31.41 130.16,31.11 133.44,27.83 150.17,27.83 150.39,28.06 156.11,28.06 163.44,20.72 164.35,20.72 166.79,18.27 166.79,16.16 165.94,15.31 165.94,12.47 165.53,12.05 165.53,11.32 165.45,11.24 165.45,8.89 165.35,8.79 165.01,8.79 164.93,8.88 v1(164.93,9.84)
  BOTTOM w0.076: v1(114.23,51.77) UC1.AP40
  BOTTOM w0.102: JDIMM2.169 164.28,10.49 v1(164.93,9.84)
DDR_B_D22: length 88.7
  IN4 w0.076: v1(116.06,51.77) 116.6,51.24 116.6,50.31 116.78,50.12 116.78,49.75 118.7,47.83 120.37,47.83 121.09,47.11 121.72,47.11 122.92,45.91 124,45.91 125.99,43.91 125.99,42.91 126.35,42.56
  IN4 w0.089: v1(168.48,10.73) 168.48,12.83 168.75,13.1 169.13,13.1 169.22,13.19 169.22,13.47 169.12,13.57 168.75,13.57 168.61,13.71 168.61,14.72 169.04,15.16 169.04,19.32 166.79,21.58 166.79,21.8 166.89,21.91 166.89,22.13 166.73,22.29 166.5,22.29 166.4,22.19 166.17,22.19 166.01,22.35 166.01,22.58 166.11,22.68 166.11,22.91 165.95,23.07 165.73,23.07 165.63,22.96 165.4,22.96 165.25,23.12 165.25,23.4 162.2,26.44 161.98,26.44 161.64,26.1 161.41,26.1 161.25,26.26 161.25,26.49 161.59,26.83 161.59,27.05 161.4,27.25 160.26,27.25 159.53,27.97 159.53,28.2 159.55,28.21 159.55,28.44 159.39,28.6 159.16,28.6 159.15,28.58 158.92,28.58 158.76,28.74 158.76,28.97 158.78,28.99 158.78,29.21 158.62,29.37 158.39,29.37 158.38,29.36 158.15,29.36 157.99,29.52 157.99,29.74 158,29.76 158,29.98 157.84,30.14 157.62,30.14 157.6,30.13 157.38,30.13 157.14,30.37 141.67,30.37 141.4,30.64 141.4,31.27 141.24,31.43 141.02,31.43 140.86,31.26 140.86,31.02 140.7,30.86 140.47,30.86 140.31,31.02 140.31,31.27 140.15,31.43 139.92,31.43 139.76,31.27 139.76,31.02 139.6,30.86 139.38,30.86 139.22,31.02 139.22,31.27 139.06,31.43 138.83,31.43 138.67,31.27 138.67,31.02 138.51,30.86 135.57,30.86 135.21,31.22 134.78,31.22 134.2,31.8 133.89,31.8 130.43,35.27 129.88,35.27 127.63,37.51 127.63,38.72 127,39.35 127,41.9 126.35,42.56
  BOTTOM w0.076: v1(116.06,51.77) UC1.AP37
  BOTTOM w0.102: JDIMM2.187 168.78,11.88 168.86,11.79 168.86,11.11 v1(168.48,10.73)
DDR_B_D23: length 88.7
  IN4 w0.076: v1(116.06,51.14) 116.43,50.77 116.43,50.24 116.61,50.05 116.61,48.87 117.05,48.44 117.72,48.44 118.49,47.67 120.3,47.67 121.03,46.94 121.65,46.94 122.85,45.74 123.93,45.74 125.69,43.98 125.69,42.81 126.21,42.29
  IN4 w0.089: v1(168.48,9.46) 168.55,9.39 168.55,8.43 168.46,8.34 168.14,8.34 168.05,8.44 168.05,12.85 168.28,13.07 168.28,14.83 168.74,15.28 168.74,19.18 164.85,23.07 164.85,23.36 162.64,25.57 161.5,25.57 157.01,30.07 141.38,30.07 140.89,30.55 136.05,30.55 135.89,30.39 135.89,30.1 135.73,29.94 135.5,29.94 135.35,30.09 135.35,30.39 135.05,30.69 133.64,30.69 133.19,31.15 133.19,31.63 132.81,32.01 132.61,32.01 127.97,36.64 127.26,36.64 126.78,37.13 126.78,38.97 126.58,39.17 126.58,41.92 126.21,42.29
  BOTTOM w0.076: v1(116.06,51.14) UC1.AR37
  BOTTOM w0.102: v1(168.48,9.46) 167.78,10.17 JDIMM2.183
DDR_B_D24: length 87.3
  IN4 w0.076: 127.04,43.85 127.04,44.51 124.8,46.75 123.82,46.75 123.47,47.1 122.82,47.1 122.32,47.6 121.3,47.6 120.58,48.33 118.91,48.33 117.52,49.71 117.52,50.02 117.89,50.39 v1(117.89,50.5)
  IN4 w0.089: v1(170.26,9.59) 169.85,9.99 169.85,11.76 170.5,12.4 170.5,20.26 161.21,29.55 160.36,29.55 158.27,31.64 156.12,31.64 155.96,31.8 155.96,32.23 155.8,32.39 155.57,32.39 155.41,32.23 155.41,31.8 155.25,31.64 155.03,31.64 154.87,31.8 154.87,32.23 154.71,32.39 154.48,32.39 154.32,32.23 154.32,31.8 154.16,31.64 153.94,31.64 153.78,31.8 153.78,32.23 153.62,32.39 153.39,32.39 153.23,32.23 153.23,31.8 153.07,31.64 143.51,31.64 142.47,32.68 137.84,32.68 136.74,33.78 133.68,33.78 130.56,36.89 130.56,37.68 128.8,39.44 128.8,41.67 127.04,43.44 127.04,43.85
  BOTTOM w0.076: UC1.AT33 118.07,50.64 v1(117.89,50.5)
  BOTTOM w0.102: v1(170.26,9.59) 169.67,10.17 169.67,11.1 169.78,11.2 JDIMM2.191
DDR_B_D25: length 86.9
  IN4 w0.076: 127.6,43.94 127.6,44.29 124.97,46.92 123.89,46.92 123.03,47.78 121.36,47.78 120.65,48.49 119.27,48.49 v1(117.89,49.87)
  IN4 w0.089: v1(170.26,10.86) 170.44,10.68 171,10.68 171.06,10.74 171.06,11.21 171,11.27 170.75,11.27 170.65,11.38 170.65,11.86 170.84,12.05 170.84,13.17 171,13.33 171.85,13.33 172.01,13.49 172.01,13.72 171.85,13.88 171,13.88 170.84,14.04 170.84,15.83 171,15.99 171.03,15.99 171.19,16.15 171.19,16.37 171.03,16.53 171,16.53 170.84,16.69 170.84,16.92 171,17.08 171.03,17.08 171.19,17.24 171.19,17.46 171.03,17.62 171,17.62 170.84,17.78 170.84,18.01 171,18.17 171.03,18.17 171.19,18.33 171.19,18.56 171.03,18.72 171,18.72 170.84,18.88 170.84,19.1 171,19.26 171.03,19.26 171.19,19.42 171.19,19.65 171.03,19.81 171,19.81 170.84,19.97 170.84,20.41 161.16,30.08 160.26,30.08 157.65,32.69 157.42,32.69 157.26,32.53 157.26,32.11 157.1,31.95 156.88,31.95 156.72,32.11 156.72,32.53 156.56,32.69 151.39,32.69 151.06,33.02 148.1,33.02 147.94,32.86 147.94,32.47 147.78,32.31 147.55,32.31 147.39,32.47 147.39,32.86 147.23,33.02 137.93,33.02 136.87,34.08 133.84,34.08 131.08,36.84 131.08,37.92 129.14,39.86 129.14,42.04 127.6,43.58 127.6,43.94
  BOTTOM w0.076: v1(117.89,49.87) 118.07,50 UC1.AU33
  BOTTOM w0.102: JDIMM2.195 170.78,12.2 170.65,12.08 170.65,11.25 v1(170.26,10.86)
DDR_B_D26: length 86.3
  IN4 w0.076: v1(119.72,49.87) 120.02,49.87 121.6,48.28 123.24,48.28 124.08,47.45 125.24,47.45 126.98,45.72 127.45,45.72
  IN4 w0.089: 127.45,45.72 131.49,41.69 131.49,39.51 134.37,36.63 134.37,35.9 134.84,35.43 135.6,35.43 136.3,36.13 139.36,36.13 140.42,35.06 143.89,35.06 144.6,35.78 148.06,35.78 149.04,34.79 149.52,34.79 149.64,34.92 151.04,34.92 151.82,34.14 159.01,34.14 172.52,20.62 172.52,18.3 172.68,18.14 172.9,18.14 173.05,17.98 173.05,17.75 172.9,17.59 172.68,17.59 172.52,17.43 172.52,15.98 173.43,15.07 173.43,12.96 172.85,12.38 172.85,8.91 172.74,8.8 172.52,8.8 172.39,8.93 v1(172.39,11.16)
  BOTTOM w0.076: v1(119.72,49.87) UC1.AU30
  BOTTOM w0.102: JDIMM2.203 172.78,11.55 v1(172.39,11.16)
DDR_B_D27: length 87
  IN4 w0.076: 127.75,46.1 126.83,46.1 125.31,47.62 124.14,47.62 123.31,48.45 121.67,48.45 120.09,50.03 119.72,50.4 v1(119.72,50.5)
  IN4 w0.089: v1(173.33,11.17) 173.77,11.17 173.91,11.3 173.91,18.55 173.75,18.71 172.99,18.71 172.83,18.87 172.83,19.1 172.99,19.26 173.75,19.26 173.91,19.42 173.91,19.77 158.61,35.06 157.91,35.06 157.75,34.9 157.75,34.6 157.59,34.44 157.37,34.44 157.21,34.6 157.21,34.9 157.05,35.06 156.82,35.06 156.66,34.9 156.66,34.6 156.5,34.44 156.28,34.44 156.12,34.6 156.12,34.9 155.96,35.06 155.73,35.06 155.57,34.9 155.57,34.6 155.41,34.44 155.18,34.44 155.02,34.6 155.02,34.9 154.86,35.06 154.64,35.06 154.48,34.9 154.48,34.6 154.32,34.44 154.09,34.44 153.93,34.6 153.93,34.9 153.77,35.06 153.55,35.06 153.39,34.9 153.39,34.6 153.23,34.44 153,34.44 152.84,34.6 152.84,34.9 152.68,35.06 152.3,35.06 151.83,35.53 149.62,35.53 149.25,35.9 148.46,35.9 147.87,36.49 143.12,36.49 142.13,35.5 140.64,35.5 139.62,36.53 135.7,36.53 134.89,37.34 134.09,37.34 131.93,39.5 131.93,41.92 127.75,46.1
  BOTTOM w0.076: v1(119.72,50.5) UC1.AT30
  BOTTOM w0.102: v1(173.33,11.17) 173.78,11.61 JDIMM2.207
DDR_B_D28: length 88.2
  IN4 w0.076: 126.61,43.34 126.61,43.83 124.05,46.38 123.95,46.38 123.46,46.88 122.74,46.88 122.19,47.44 121.23,47.44 120.51,48.16 118.84,48.16 117.35,49.65 117.35,50.09 117.52,50.26 117.52,50.77 v1(117.89,51.14)
  IN4 w0.089: 126.61,43.34 128.43,41.51 128.43,37.8 129.85,36.38 130.63,36.38 133.61,33.41 136.68,33.41 137.74,32.35 142.37,32.35 143.45,31.27 158.21,31.27 160.23,29.25 161.07,29.25 170.18,20.13 170.18,12.61 169.55,11.98 169.55,9.19 169.71,9.02 170.7,9.02 170.82,8.91 170.82,8.59 170.69,8.46 169.69,8.46 169.6,8.37 169.6,8.04 169.7,7.94 v1(170.01,7.94)
  BOTTOM w0.076: v1(117.89,51.14) 118.07,51.28 UC1.AR33
  BOTTOM w0.102: v1(170.01,7.94) 169.53,7.46 JDIMM2.190
DDR_B_D29: length 88.8
  IN4 w0.076: v1(117.89,51.77) 117.35,51.24 117.35,50.32 117.19,50.16 117.19,49.58 118.77,48 120.44,48 121.16,47.27 121.79,47.27 122.99,46.07 124.07,46.07 126.3,43.84 126.3,43.01
  IN4 w0.089: v1(170.49,6.79) 168.71,6.79 168.62,6.88 168.62,7.18 168.71,7.27 169.13,7.27 169.22,7.36 169.22,12.12 169.83,12.73 169.83,20.03 160.92,28.94 160.11,28.94 158.08,30.97 143.28,30.97 142.22,32.03 137.63,32.03 137.08,32.58 136.49,32.58 135.91,32 134.9,32 134.35,32.55 134.03,32.55 130.72,35.86 129.88,35.86 128.08,37.66 128.08,41.23 126.3,43.01
  BOTTOM w0.076: UC1.AP33 118.07,51.92 v1(117.89,51.77)
  BOTTOM w0.102: JDIMM2.194 170.53,6.75 v1(170.49,6.79)
DDR_B_D30: length 86.9
  IN4 w0.076: 128.15,46.23 127.52,46.87 126.3,46.87 125.38,47.78 124.21,47.78 122.7,49.29 121.08,49.29 120.08,50.29 120.08,50.66 120.08,51.29 120.08,51.29 120.08,51.41 v1(119.72,51.77)
  IN4 w0.089: v1(174.45,6.67) 173.7,6.67 173.61,6.76 173.61,7.07 173.7,7.16 173.84,7.16 173.93,7.25 173.93,8.26 174.81,9.14 174.81,12.49 174.37,12.93 174.37,19.75 158.73,35.4 152.39,35.4 151.96,35.84 149.75,35.84 149.38,36.21 148.58,36.21 147.92,36.87 136.11,36.87 135.77,37.22 135.77,38.69 135.58,38.88 135.03,38.88 132.89,41.01 132.89,41.49 128.15,46.23
  BOTTOM w0.076: v1(119.72,51.77) UC1.AR30
  BOTTOM w0.102: JDIMM2.208 174.03,6.24 v1(174.45,6.67)
DDR_B_D31: length 88.4
  IN4 w0.076: v1(119.72,52.41) 120.25,51.88 120.25,50.4 121.19,49.46 122.77,49.46 124.28,47.95 125.45,47.95 126.36,47.03 127.78,47.03 128.53,46.28
  IN4 w0.089: 128.53,46.28 133.46,41.36 133.76,41.36 134.5,40.62 134.5,39.84 135.07,39.27 136.44,39.27 136.98,38.73 138.26,38.73 138.93,38.06 143.13,38.06 143.39,37.8 147.06,37.8 147.42,37.44 147.79,37.44 148.67,36.56 149.56,36.56 149.98,36.14 152.32,36.14 152.44,36.26 153.25,36.26 153.81,35.71 158.9,35.71 174.68,19.93 174.68,13.05 175.46,12.27 175.46,9.67 175.87,9.26 175.87,9.13 175.65,8.91 175.52,8.91 175.33,9.1 175.2,9.1 174.98,8.88 174.98,8.75 175.17,8.56 175.17,8.43 175.01,8.27 174.88,8.27 174.69,8.46 174.57,8.46 174.45,8.35 v1(174.45,7.94)
  BOTTOM w0.076: v1(119.72,52.41) UC1.AP30
  BOTTOM w0.102: v1(174.45,7.94) 173.22,6.7 173.22,6.35 173.03,6.16 173.03,4.8 JDIMM2.204
DDR_B_D32: length 50.4
  IN1 w0.076: v1(121.39,39.04) 121.77,38.65 121.77,37.78 123.47,36.09 123.47,35.5
  IN1 w0.089: 123.47,35.5 123.47,32.7 123.73,32.44 123.73,26.72 128.71,21.74 128.71,16.56 130.84,14.43 130.84,12.53 131.3,12.08 131.3,9.82 132.08,9.04 132.08,8.81 131.93,8.67 131.68,8.67 131.55,8.54 131.55,8.3 131.66,8.19 132.23,8.19 132.37,8.06 132.37,7.77 132.28,7.68 132.13,7.68 132.04,7.59 132.04,7.25 132.11,7.18 v1(132.34,7.18)
  BOTTOM w0.076: v1(121.39,39.04) 120.18,40.25 120.18,44.97 v2(120.01,45.14) 120.01,46.71 119.87,46.86 119.87,47.22 120.03,47.63 120.03,47.92 120.3,48.18 UC1.AY31
  BOTTOM w0.102: v1(132.34,7.18) 132.53,7 JDIMM2.50
DDR_B_D33: length 50.9
  IN1 w0.076: 122.86,35.31 122.86,36.04 120.81,38.09 120.81,44.07 v1(121.37,44.63)
  IN1 w0.089: v1(130.51,10.99) 130.12,11.38 130.12,13.32 129.39,14.05 129.39,14.91 127.9,16.41 127.9,20.08 125.27,22.71 125.27,22.9 125.82,23.45 125.82,23.65 125.68,23.79 125.49,23.79 124.94,23.24 124.74,23.24 124.61,23.37 124.61,23.57 125.16,24.12 125.16,24.31 125.02,24.45 124.82,24.45 124.27,23.9 124.08,23.9 123.94,24.04 123.94,24.23 124.49,24.78 124.49,24.98 124.35,25.12 124.16,25.12 123.61,24.57 123.41,24.57 123.04,24.94 123.04,32.26 122.86,32.45 122.86,35.31
  BOTTOM w0.076: v1(121.37,44.63) 121.49,44.74 121.49,46.41 121.19,46.7 121.19,47.23 121.2,47.26 121.24,47.34 121.24,47.46 121.17,47.68 121.17,47.82 121.23,47.98 121.23,48.16 121.21,48.21 121.21,48.78 120.95,49.04 UC1.AW31
  BOTTOM w0.102: v1(130.51,10.99) 131.28,11.75 JDIMM2.45
DDR_B_D34: length 50
  IN1 w0.076: 125.47,35.24 122.51,38.19 122.51,42.92 v1(121.39,44.04)
  IN1 w0.089: v1(134.53,6.67) 134.53,7.34 134.2,7.66 134.08,7.66 134,7.59 133.88,7.59 133.72,7.75 133.72,7.97 133.79,8.05 133.79,8.24 133.37,8.66 133.37,9.08 133.61,9.32 133.61,10.83 133.3,11.14 133.3,14.31 132.07,15.55 132.07,17.02 130.34,18.75 130.34,22.42 125.82,26.93 125.82,32.32 125.47,32.67 125.47,33.31 125.47,33.31 125.47,35.24
  BOTTOM w0.076: UC1.AY29 121.42,48.28 121.42,48.03 121.35,47.81 121.35,47.68 121.41,47.45 121.41,47.31 121.36,47.19 121.36,46.77 121.65,46.48 121.65,44.91 121.75,44.81 121.75,44.41 v1(121.39,44.04)
  BOTTOM w0.102: JDIMM2.58 v1(134.53,6.67)
DDR_B_D35: length 50.6
  IN1 w0.076: v1(123.08,40.53) 122.68,40.13 122.68,38.38 125.79,35.27
  IN1 w0.089: 125.79,35.27 125.79,32.8 126.13,32.46 126.13,27.06 130.64,22.55 130.64,18.89 132.45,17.08 132.45,15.6 133.61,14.44 133.61,11.27 133.92,10.96 133.92,8.89 134.83,7.98 134.83,7.19 135.19,6.83 v1(135.53,6.83)
  BOTTOM w0.076: v1(123.08,40.53) 122.3,41.31 v2(122.3,45.2) 122.15,45.36 122.15,46.7 122.06,46.79 122.06,47.74 121.83,47.96 121.83,48.51 121.52,48.82 UC1.AW29
  BOTTOM w0.102: v1(135.53,6.83) JDIMM2.62
DDR_B_D36: length 48.9
  IN1 w0.076: 123.16,35 123.16,36.02 120.99,38.19 120.99,40.44 v1(121.39,40.84)
  IN1 w0.089: 123.16,35 123.16,32.57 123.4,32.34 123.4,26.62 126.92,23.09 126.92,22.9 126.55,22.53 126.55,22.33 126.69,22.19 126.88,22.19 127.26,22.57 127.45,22.57 127.59,22.43 127.59,22.23 127.22,21.86 127.22,21.67 127.35,21.53 127.55,21.53 127.92,21.9 128.12,21.9 128.4,21.62 128.4,16.43 130.42,14.41 130.42,12.52 130.97,11.98 130.97,10.18 v1(130.51,9.72)
  BOTTOM w0.076: UC1.BB31 120.3,46.91 120.34,46.86 120.34,45.55 120.51,45.38 120.51,41.73 v1(121.39,40.84)
  BOTTOM w0.102: v1(130.51,9.72) 132.28,11.48 JDIMM2.49
DDR_B_D37: length 49.5
  IN1 w0.076: v1(121.59,40.25) 121.99,39.86 121.99,37.91 123.77,36.12 123.77,35.43
  IN1 w0.089: 123.77,35.43 123.77,32.82 124.03,32.56 124.03,26.85 129.01,21.87 129.01,16.69 131.15,14.55 131.15,12.66 131.6,12.2 131.6,10.12 132.75,8.98 132.75,6.88 132.53,6.67 v1(131.65,6.67)
  BOTTOM w0.076: UC1.BA31 120.3,47.59 120.16,47.45 120.15,47.44 120.15,47.44 120.03,47.19 120.03,46.93 120.18,46.78 120.18,45.45 120.34,45.28 120.34,41.24 121.33,40.25 v1(121.59,40.25)
  BOTTOM w0.102: v1(131.65,6.67) 131.53,6.54 JDIMM2.46
DDR_B_D38: length 49.2
  IN1 w0.076: 126.94,34.38 126.94,34.89 123.5,38.33 123.5,38.72 v1(123.07,39.16)
  IN1 w0.089: v1(134.32,9.72) 134.73,10.12 134.73,11.84 134.22,12.35 134.22,14.69 133.11,15.8 133.11,16.54 133.11,16.54 133.11,17.28 131.25,19.14 131.25,24.28 130.78,24.75 130.58,24.75 130.24,24.41 130.04,24.41 129.91,24.55 129.91,24.74 130.25,25.08 130.25,25.28 126.94,28.58 126.94,33.4 126.81,33.54 126.69,33.54 126.55,33.67 126.55,33.87 126.69,34.01 126.81,34.01 126.94,34.14 126.94,34.38
  BOTTOM w0.076: UC1.BA29 121.62,47.51 121.89,47.24 121.89,46.7 121.98,46.61 121.98,45.06 122.14,44.91 122.14,40.09 v1(123.07,39.16)
  BOTTOM w0.102: v1(134.32,9.72) 134.32,9.81 135.78,11.26 JDIMM2.63
DDR_B_D39: length 48.3
  IN1 w0.076: v1(123.06,38.56) 123.06,38.28 126.09,35.25
  IN1 w0.089: 126.09,35.25 126.09,33.11 126.46,32.74 126.46,28.64 127.15,27.95 127.15,27.76 126.63,27.24 126.63,27.04 126.77,26.91 126.96,26.91 127.48,27.42 127.67,27.42 127.81,27.29 127.81,27.09 127.29,26.57 127.29,26.38 127.43,26.24 127.63,26.24 128.14,26.76 128.34,26.76 128.47,26.62 128.47,26.43 128.07,26.02 128.07,25.81 128.2,25.67 128.39,25.67 128.81,26.09 129,26.09 129.38,25.72 129.38,24.24 130.95,22.67 130.95,19.02 132.75,17.21 132.75,15.73 133.91,14.57 133.91,11.39 v1(134.32,10.99)
  BOTTOM w0.076: v1(123.06,38.56) 121.97,39.66 121.97,44.84 121.82,44.99 121.82,46.54 121.62,46.74 UC1.BB29
  BOTTOM w0.102: v1(134.32,10.99) 134.78,11.44 JDIMM2.59
DDR_B_D40: length 53.3
  IN1 w0.089: v1(123.08,42.52) 124.24,41.36 124.24,38.78 127.85,35.18 127.85,30.84 129.1,29.58 129.1,27.7 132.15,24.65 132.15,19.81 132.84,19.12 133.07,19.12 133.21,19.26 133.21,19.42 132.54,20.08 132.54,20.3 132.68,20.44 132.85,20.44 135.74,17.55 135.74,9.18 136.63,8.29 v1(136.63,7.46)
  BOTTOM w0.076: UC1.AY27 122.85,48.28 122.85,48.02 122.89,47.92 122.89,47.92 122.92,47.84 122.92,47.63 122.88,47.54 122.88,47.28 122.92,47.19 122.92,46.93 122.81,46.82 122.81,46.08 123.3,45.59 123.3,45.18 123.6,44.88 123.6,43.04 v1(123.08,42.52)
  BOTTOM w0.102: v1(136.63,7.46) 136.52,7.35 JDIMM2.66
DDR_B_D41: length 53.8
  IN1 w0.089: v1(137.39,6.63) 136.86,6.63 135.92,7.56 135.92,8.31 135.32,8.91 135.32,17.35 134.11,18.56 133.96,18.56 133.82,18.42 133.82,18.19 134.21,17.8 134.21,17.61 134.09,17.49 133.85,17.49 131.85,19.49 131.85,24.52 128.8,27.57 128.8,29.45 127.54,30.71 127.54,35.04 123.89,38.69 123.89,40.45 v1(123.06,41.28)
  BOTTOM w0.076: v1(123.06,41.28) 122.64,41.7 v2(122.64,42.21) 122.64,45.38 122.31,45.71 122.31,46.77 122.22,46.86 122.22,47.77 122.43,47.98 122.43,48.52 122.75,48.85 UC1.AW27
  BOTTOM w0.102: v1(137.39,6.63) 137.52,6.49 JDIMM2.70
DDR_B_D42: length 53
  IN1 w0.076: v1(125.01,38.68) 125.51,38.17 126.18,38.17 126.38,37.98 126.38,37.09
  IN1 w0.089: v1(136.22,10.86) 136.68,11.32 136.68,12.03 136.12,12.59 136.12,19.11 134.1,21.14 133.9,21.14 133.77,21 133.77,20.81 135.66,18.92 135.66,18.72 135.52,18.58 135.33,18.58 132.46,21.45 132.46,24.78 129.61,27.62 129.61,29.6 129.01,30.2 129.01,32.97 128.23,33.76 128.23,35.24 126.38,37.09
  BOTTOM w0.076: UC1.AY25 123.98,48.18 124.25,47.91 124.25,47.57 124.3,47.46 124.42,47.21 124.42,45.68 124.74,45.36 124.74,44.55 125.48,43.81 125.48,39.15 v1(125.01,38.68)
  BOTTOM w0.102: v1(136.22,10.86) 136.78,11.41 JDIMM2.67
DDR_B_D43: length 53.5
  IN1 w0.076: 127.29,36.65 126.78,37.16 126.78,38.03 126.23,38.58 125.7,38.58 v1(125.01,39.27)
  IN1 w0.089: v1(136.22,9.59) 137.07,10.44 137.07,18.81 133.55,22.34 133.34,22.34 133.2,22.2 133.2,22.02 133.62,21.6 133.62,21.41 133.48,21.27 133.28,21.27 132.76,21.8 132.76,24.9 130.55,27.12 130.55,29.34 129.33,30.56 129.33,33.18 128.62,33.89 128.62,35.32 127.29,36.65
  BOTTOM w0.076: v1(125.01,39.27) 123.8,40.48 123.8,44.91 123.47,45.23 123.47,45.69 122.97,46.19 122.97,46.75 123.08,46.86 123.08,47.22 123.08,47.22 123.05,47.31 123.05,47.51 123.08,47.6 123.08,47.6 123.09,47.6 123.09,47.61 123.09,47.84 123.05,47.97 123.05,48.22 123.12,48.49 123.12,48.83 123.33,49.04 UC1.AW25
  BOTTOM w0.102: JDIMM2.71 137.78,11.14 v1(136.22,9.59)
DDR_B_D44: length 51.4
  IN1 w0.076: 128.41,39.28 127.56,39.28 127.02,39.83 127.02,41.63 125.54,43.1 125.54,43.58 125.1,44.02 123.96,44.02 v1(123.06,43.13)
  IN1 w0.089: v1(139.43,10.25) 139.88,10.71 139.88,18.82 136.24,22.46 136.24,22.61 136.31,22.68 136.31,22.84 136.14,23.01 135.99,23.01 135.94,22.96 135.74,22.96 135.61,23.09 135.61,23.29 135.71,23.39 135.71,23.52 135.53,23.7 135.4,23.7 135.27,23.57 135.13,23.57 134.74,23.96 134.74,25.68 133.56,26.86 133.56,29.52 131.43,31.64 131.43,34.47 131.25,34.65 131.25,35.14 130.47,35.92 130.47,37.63 128.81,39.28 128.41,39.28
  BOTTOM w0.076: UC1.BB27 122.64,47.08 122.64,45.99 123.12,45.51 123.12,45.12 123.43,44.81 123.43,43.5 v1(123.06,43.13)
  BOTTOM w0.102: JDIMM2.79 139.78,10.6 v1(139.43,10.25)
DDR_B_D45: length 52.1
  IN1 w0.076: v1(123.06,44.33) 125.15,44.33 125.88,43.6 125.88,43.4 128.01,41.27 128.01,40.6 129.37,39.25
  IN1 w0.089: 129.37,39.25 130.77,37.84 130.77,36.12 131.56,35.34 131.56,34.81 131.91,34.46 131.91,31.6 134.04,29.47 134.04,26.87 135.13,25.77 135.13,24.99 137.58,22.54 137.58,22.35 137.28,22.05 137.28,21.85 137.42,21.72 137.61,21.72 137.91,22.02 138.11,22.02 138.25,21.88 138.25,21.69 137.94,21.38 137.94,21.19 138.08,21.05 138.28,21.05 138.58,21.35 138.77,21.35 138.91,21.21 138.91,21.02 138.61,20.72 138.61,20.52 138.75,20.39 138.94,20.39 139.24,20.68 139.45,20.68 139.58,20.54 139.58,20.36 139.27,20.05 139.27,19.86 139.41,19.72 139.61,19.72 139.91,20.02 140.1,20.02 140.67,19.46 140.67,11.26 v1(140.45,11.04)
  BOTTOM w0.076: UC1.BA27 122.65,47.51 122.39,47.25 122.39,46.93 122.48,46.84 122.48,45.87 122.89,45.46 122.89,44.93 123.06,44.75 v1(123.06,44.33)
  BOTTOM w0.102: v1(140.45,11.04) 140.78,11.36 JDIMM2.83
