# Allegro board LAF401PR30-0829.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
LCN_DAN05-67356-0103_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LCN_DAN05-Q0406-0103_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
LED_LTW-C193DC-C_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_AUSB0014-P003A_9P
  round 1.118 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.549x2.769 hole 0.787x2.007: 10(-11.35,-1.59) 11(4.35,-1.59)
  oval 1.549x2.565 hole 0.787x1.803: 12(-11.35,-9.09) 13(4.35,-9.09)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLV-FY12N1R0M-O1L_2P
  rect 0.889x2.489 smd: 1(0,0) 2(2.6,0)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAGLA_MMD-05CZ-1R0M-M7L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB470SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PD800SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
NCP302045MNTWG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  custom 0.32x0.32 smd: 9(3.135,1.266)
  custom 0.543x0.543 smd: 10(2.225,3.266)
  rect 3.81x0.711 smd: 11(1.75,4.902)
  rect 0.711x1.295 smd: 12(-0.701,3.701)
  oval 0.711x0.305 smd: 13(-0.701,2.701) 14(-0.701,2.201) 15(-0.701,1.701) 16(-0.701,1.201) 17(-0.701,0.701)
  rect 1.422x1.118 smd: 18(0.7,1.266)
  rect 0.584x0.356 smd: 19(0.09,2.676)
NPCT650JB2YX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PANAS_EXC24CQ900U_4P
  rect 0.356x0.559 smd: 1(0,0) 2(0,-1.25) 3(-0.6,-1.25) 4(-0.6,0)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI3EQX6741STZDEX_TQFN20_4X4-S
  oval 1.041x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 11(3.95,-2) 12(3.95,-1.5) 13(3.95,-1) 14(3.95,-0.5) 15(3.95,0)
  oval 0.254x1.041 smd: 6(0.975,-2.975) 7(1.475,-2.975) 8(1.975,-2.975) 9(2.475,-2.975) 10(2.975,-2.975) 16(2.975,0.975) 17(2.475,0.975) 18(1.975,0.975) 19(1.475,0.975) 20(0.975,0.975)
  rect 2.108x2.108 smd: 21(1.975,-1)
PJDLC05C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8338BQFN60GTR-A0_QFN60_5X9-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8558BTQFN24_TQFN24_4X4-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.692x2.692 smd: 25(2.05,-1.25)
PS8713BTQFN24GTR2_TQFN24_4X4-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.692x2.692 smd: 25(1.25,2.05)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8097ALGE_SOT23-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
RTD2166-CG_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
RTS5242-GR_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130456-831_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(-5.955,-6.42) 15(13.095,-6.42)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SHORTPADS-NPM
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SINGA_2SJ3095-136111F_7P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(-9.5,5.5) 3(0,5.2) 4(0,7.8) 5(-9.5,0) 6(-9.5,2.75) 7(0,2.65)
SLGC55544CVTR_TQFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
SMF22A-SOD123FL-2-S
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
SOLDER_PREFORMS_0603
  rect 1.118x1.397 smd: 1(0,0) 2(1.422,0)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SS3-CMFTQR9_3P
  oval 0.991x2.489 smd: 1(0,0) 2(2,0) 3(4,0)
  round 1.651 hole 0.889: 4(-0.15,-3.75) 5(6.15,-3.75)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8057QDC_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.6x1.6 smd: 17(1.55,-0.75)
SY8210AQVC_QFN19_4X3
  oval 0.787x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 6(0,-2.25) 7(0,-2.7) 8(0,-3.15) 12(2.8,-3.15) 13(2.8,-2.7) 14(2.8,-2.25) 15(2.8,-1.8) 16(2.8,-1.35) 17(2.8,-0.9) 18(2.8,-0.45) 19(2.8,0)
  rect 0.94x2.108 smd: 9(1.07,-0.43)
  rect 0.406x2.108 smd: 10(2,-0.43)
  rect 1.295x2.007 smd: 11(1.25,-2.78)
SY8288BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_5-991503004000-6_8P-T
  round 0.787 hole 0.787 unplated: (-1.39,-11.52)
  round 1.092 hole 1.092 unplated: (10.31,0.48)
  oval 0.889x1.092 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(0,-13.48) 6(2.54,-13.48) 7(5.08,-13.48) 8(7.62,-13.48)
  rect 0.889x0.813 smd: 9(-2.94,3.44)
  rect 1.245x1.803 smd: 10(-3.39,-13.33)
  rect 1.245x1.397 smd: 11(-3.39,-5.33)
  rect 1.295x1.016 smd: 12(-0.715,3.56) 13(9.535,3.56)
  rect 1.041x1.397 smd: 14(12.105,0.87)
  rect 0.94x1.397 smd: 15(12.555,-6.62)
  rect 1.219x1.143 smd: 16(10.8,-13.65)
T-SOL_156-2000302608_19P_NR
  round 0.889 hole 0.889 unplated: (-7.075,-28.925) (13.425,-1.825)
  oval 0.787x1.651 smd: 1(0,0) 2(1.4,0) 3(2.8,0) 4(4.2,0) 5(7.1,0) 6(9.9,0) 7(11.3,0) 8(12.7,0) 9(-1.4,0) 18(8.5,0) 19(14.1,0)
  oval 1.346x0.787 smd: 10(-9.2,-22.975) 11(-9.2,-24.075) 12(-9.2,-25.175) 13(-9.2,-26.275) 14(20.05,-26.275) 15(20.05,-25.175) 16(20.05,-24.075) 17(20.05,-22.975)
  rect 1.397x1.448 smd: 20(17.2,0.6) 21(5.65,0.6) 22(-6.35,0.6)
  rect 1.448x1.397 smd: 23(19.525,-6.575) 24(-8.675,-6.575) 25(19.525,-20.675) 26(-8.675,-18.825)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAIMA_IH-160_24P
  oval 0.61x2.362 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(11,8.35) 14(10,8.35) 15(9,8.35) 16(8,8.35) 17(7,8.35) 18(6,8.35) 19(5,8.35) 20(4,8.35) 21(3,8.35) 22(2,8.35) 23(1,8.35) 24(0,8.35)
TAIYO_BRC2012T4R7MD_2P
  rect 0.61x1.448 smd: 1(0,0) 2(1.6,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_MCF12102G900-T_4P-NPM
  rect 0.508x0.305 smd: 1(0,0) 2(0,-0.55) 3(1.25,-0.55) 4(1.25,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3-S
  oval 0.254x0.813 smd: 1(0,0) 2(0.4,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 13(0.4,2.05) 14(0,2.05)
  oval 0.203x0.762 smd: 3(0.8,0) 4(1.2,0) 5(1.6,0) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TUSB546_QFN40_4X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 21(6.1,-2.8) 22(6.1,-2.4) 23(6.1,-2) 24(6.1,-1.6) 25(6.1,-1.2) 26(6.1,-0.8) 27(6.1,-0.4) 28(6.1,0)
  oval 0.203x0.889 smd: 9(0.85,-3.45) 10(1.25,-3.45) 11(1.65,-3.45) 12(2.05,-3.45) 13(2.45,-3.45) 14(2.85,-3.45) 15(3.25,-3.45) 16(3.65,-3.45) 17(4.05,-3.45) 18(4.45,-3.45) 19(4.85,-3.45) 20(5.25,-3.45) 29(5.25,0.65) 30(4.85,0.65) 31(4.45,0.65) 32(4.05,0.65) 33(3.65,0.65) 34(3.25,0.65) 35(2.85,0.65) 36(2.45,0.65) 37(2.05,0.65) 38(1.65,0.65) 39(1.25,0.65) 40(0.85,0.65)
  rect 4.699x2.692 smd: 41(3.05,-1.4)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI217LM-QPN9-A2_QFN48_6X6-S
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V25000034_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.8) 4(0,1.8)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.6V_DDR_VTT_ON: PR210.1 RD19.1 UD1.4
1.8V_PRIM_PWRGD: PR517.1 PU501.5 RE361.2 UE1.L7
2.5VSP: PC515.1 PC516.1 PJP506.1 PR515.1 PU503.1
3.3V_CAM_EN#: RC311.1 RZ380.1 UC1.AT15
3.3V_TS_EN: RE547.1 RV323.1 UE1.J7
3.3V_WWAN_EN: RZ40.2 UE1.C6 UZ2.3
3V5V_EN: PC128.1 PR114.2 PR116.1 PU100.12 PU102.12
3V_FB: PC113.1 PU100.13
3V_SN: PC112.1 PR106.2
3V_VIN: PC100.1 PC103.1 PC104.1 PC105.1 PC143.1 PJP100.2 PU100.2 PU100.3 PU100.4 PU100.5
5V_FB: PC127.1 PU102.13
5V_SN: PC125.1 PR112.2
5V_VIN: PC115.1 PC116.1 PC117.1 PC118.1 PC131.1 PJP101.2 PU102.2 PU102.3 PU102.4 PU102.5
+0.6V_DDR_VTT: CD22.1 CD54.1 CD80.1 CD81.1 CD82.1 CD83.1 CD104.1 CD105.1 CD106.1 CD107.1 JDIMM1.258 JDIMM2.258 PJP201.2
+0.6VSP: PC219.1 PC224.1 PJP201.1 PU200.5 PU200.6
+0.9V_LAN: CL3.1 CL4.1 CL8.1 CL9.1 CL10.1 CL11.1 CL12.1 LL1.2 UL1.8 UL1.11 UL1.16 UL1.22 UL1.37 UL1.40 UL1.43 UL1.46 UL1.47
+1.0V_AMPHYPLL: CC128.1 CC129.1 CC219.1 RC169.2 UC1.K15 UC1.L15
+1.0V_APLL: CC314.1 CC323.1 LC2.2 UC1.V15
+1.0V_APLLEBB: CC110.1 CC111.1 CC325.1 RC310.2 UC1.N18
+1.0V_CLK1: RC302.2 UC1.A14
+1.0V_CLK2: CC220.1 RC170.2 UC1.K19
+1.0V_CLK3: RC303.2 UC1.L21
+1.0V_CLK4: CC226.1 RC173.2 UC1.N20
+1.0V_CLK5: CC221.1 RC52.2 RC171.2 UC1.L19
+1.0V_CLK6: CC106.1 CC107.1 RC300.2 UC1.A10
+1.0V_DTS: RC301.2 UC1.T1
+1.0V_MPHYAON: CC86.1 CC87.1 RC299.2 UC1.K17 UC1.L1
+1.0V_MPHYGT: CC98.1 CC99.1 CC210.1 CC281.1 PJP3.2 RC169.1 RC309.1 RC310.1 UC1.N15 UC1.N16 UC1.N17 UC1.P15 UC1.P16
+1.0V_PRIM: CC92.1 CC93.1 CC225.1 CZ1000.1 CZ1001.1 CZ1004.1 CZ1005.1 LC2.1 PJP3.1 PJP302.2 RC170.1 RC171.1 RC173.1 RC216.1 RC299.1 RC300.1 RC301.1 RC302.1 RC303.1 UC1.AB17 UC1.AB19 UC1.AB20 UC1.AK20 UC1.P18 UC1.Y18 UZ19.1 UZ19.2 UZ19.7 UZ21.1 UZ21.2 UZ21.7
+1.0V_PRIM_CORE: CC90.1 CC91.1 PJP402.2 UC1.AF18 UC1.AF19 UC1.V20 UC1.V21
+1.0V_PRIM_COREP: PC415.1 PC416.1 PC424.1 PJP402.1 PL404.2 PR423.2 PU402.1
+1.0V_PRIM_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.2 RC216.2
+1.0V_SRAM: CC108.1 CC109.1 RC309.2 UC1.AF20 UC1.AF21 UC1.T19 UC1.T20
+1.0V_VCCST: CC195.1 CC202.1 PC602.1 PJP1.1 PR601.1 PR604.1 PR605.1 RC71.2 RC79.2 RC80.2 RC120.2 RC152.2 RC157.2 RC218.2 RE59.1 RE90.1 RZ151.2 UC1.A18 UC1.K20 UC1.K21
+1.0V_VCCST_C: CZ101.1 PJP1.2 UZ21.6
+1.0V_VCCSTG: CC84.1 CC85.1 PJP2.1 RC81.2 RC82.2 RC83.2 RC87.2 RC130.2 RC131.2 RC134.2 RC135.2 RC143.2 RZ151.1 UC1.A22
+1.0V_VCCSTG_C: CZ106.1 PJP2.2 UZ19.6
+1.0V_VCCSTG_R: RC143.1 UC1.G20
+1.0VO_DSW: CC88.1 CC89.1 UC1.AL1
+1.0VS_VCCIO: CC118.1 CC119.1 CC122.1 CC123.1 CC250.1 CC252.1 PJP401.2 QE11.1 RC2.2 RC132.2 RC165.2 UC1.AK28 UC1.AK30 UC1.AL30 UC1.AL42 UC1.AM28 UC1.AM30 UC1.AM42
+1.2V_DDR_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP202.2 PU200.10
+1.2V_DDRP: PC208.1 PC209.1 PC210.1 PC211.1 PC212.1 PC213.1 PC214.1 PC216.1 PC217.1 PC223.1 PJP200.1 PL201.2 PR204.1 PU200.7 PU200.8
+1.2V_LDO: CR5.1 CR6.1 CR7.1 UR1.10 UR1.14
+1.2V_MEM: CC176.1 CC177.1 CC178.1 CC179.1 CC294.1 CC295.1 CC296.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD17.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD49.1 CD64.1 CD65.1 CD66.1 CD67.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD90.1 CD91.1 CD92.1 CD93.1 CD94.1 CD95.1 CD96.1 CD97.1 CD98.1 CD99.1 CD108.1 CD109.1 CD110.1 CD111.1 CZ1002.1 CZ1003.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP200.2 RC231.2 RD11.1 RD15.1 RD28.1 RZ119.1 UC1.AU23 UC1.AU28 UC1.AU35 UC1.AU42 UC1.BB23 UC1.BB32 UC1.BB41 UC1.BB47 UC1.BB51 UD1.5 UZ26.1 UZ26.2 UZ26.7
+1.2V_MEM_CPUCLK: CC297.1 RC231.1 UC1.AM40
+1.8V_3.3V_ALW_VTR3: CE21.1 PJP20.2 PJP21.2 RE340.2 RE549.1 UE1.N5
+1.8V_PGPPF: RC304.2 UC1.AF16
+1.8V_PRIM: CC100.1 CC101.1 CE22.1 PJP20.1 PJP502.2 RC212.1 RC234.1 RC304.1 RC313.1 UC1.AA1 UZ8.1 UZ8.2
+1.8V_RUN: CA65.1 CA66.1 PJP42.2 RA3.2 RC362.2 RC363.2
+1.8V_RUN_AUDIO: CA57.1 CA58.1 CA69.1 RA3.1 UA1.36 UA1.40
+1.8V_RUN_CARD: CR19.2 CR20.2 JSD1.14 UR1.13
+1.8V_RUN_UZ8: CZ120.1 PJP42.1 UZ8.7 UZ8.8
+1.8VALWP: PC501.1 PC503.1 PC504.1 PJP502.1 PL501.2 PR501.1
+1VALWP: PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PC314.1 PC315.1 PC316.1 PJP302.1 PL301.2 PR306.1
+1VALWP_B+: PC301.1 PC303.1 PC305.1 PC306.1 PC317.1 PC318.1 PJP301.2 PU301.2 PU301.3 PU301.4 PU301.5
+1VS_VCCIOP: PC406.1 PC407.1 PC425.1 PC426.1 PJP401.1 PL402.2 PR421.1 PU401.1
+2.5V_MEM: CD20.1 CD21.1 CD52.1 CD53.1 CD76.1 CD77.1 CD78.1 CD79.1 CD100.1 CD101.1 CD102.1 CD103.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP506.2
+2.5V_VIN: PC514.1 PJP505.2 PU503.8
+3.3V_1.8V_ESPI: CC341.1 PJP4.2 RC21.2
+3.3V_1.8V_PGPPA: PJP4.1 RC211.2 RC212.2 RC551.2 UC1.AK15
+3.3V_1.8V_PGPPG: CC126.1 CC127.1 RC234.2 RC235.2 UC1.AD15
+3.3V_ALW: CE16.1 CE52.1 CE53.1 CE59.1 CE60.1 CE61.1 CV17.1 CZ57.1 CZ58.1 CZ68.1 CZ73.1 CZ82.1 CZ91.1 CZ93.1 CZ104.1 JAPS1.3 JAPS1.7 JKBTP1.15 JLED1.6 JUSH1.14 JUSH1.15 JUSH1.16 PC206.1 PC312.1 PJP21.1 PJP22.1 PJP102.2 PJP391.2 PJP501.1 PJP505.1 PL502.1 PR1.1 PR4.2 PR28.2 PR29.1 PR107.1 PR113.1 PR205.2 PR307.1 PR404.1 PR410.1 PR413.1 PR414.1 PR417.1 PR418.1 PR517.2 PR933.1 PR1224.2 PR1225.1 PR1230.2 PR1231.2 PR1232.2 PR1233.2 PR1234.2 PR1235.2 PR1259.2 PU200.13 PU301.15 QC7.3 QZ2.2 RC68.2 RC214.2 RC431.2 RC432.1 RE5.2 RE8.2 RE10.2 RE11.2 RE12.2 RE21.2 RE25.1 RE35.2 RE37.2 RE38.2 RE43.2 RE63.2 RE68.2 RE69.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE79.2 RE83.2 RE84.2 RE91.2 RE92.2 RE300.2 RE301.2 RE302.2 RE303.2 RE343.1 RE362.2 RE365.2 RE505.2 RE524.2 RE525.2 RE526.2 RE532.2 RE561.2 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RPE9.5 RPE9.6 RPE9.7 RPE9.8 RPE11.5 RPE11.6 RPE11.7 RPE11.8 RPE12.5 RPE12.6 RT68.2 RZ8.1 RZ9.1 RZ369.1 RZ518.1 UE3.5 UE4.5 UE5.5 UE6.5 UV24.5 UZ2.1 UZ2.2 UZ2.6 UZ2.7 UZ3.1 UZ3.2 UZ3.6 UZ3.7 UZ4.6 UZ4.7 UZ6.5 UZ10.5 UZ34.5 UZ35.5
+3.3V_ALW2: PR104.2 RE57.2
+3.3V_ALW_DSW: CC279.1 CC280.1 RC67.2 RC72.2 RC214.1 RC241.2 RC243.2 RC323.2 RC439.1 RC440.1 UC1.AD17 UC1.AD18 UC1.AJ17
+3.3V_ALW_DSW_R: QC7.1 RC439.2
+3.3V_ALW_PCH: CC104.1 CC105.1 CC223.1 CC224.1 CC337.1 JAPS1.1 JSPI1.16 LC1.1 PJP38.2 RC12.2 RC14.2 RC15.2 RC17.2 RC23.2 RC25.2 RC41.1 RC73.2 RC74.2 RC133.2 RC183.2 RC184.2 RC187.2 RC211.1 RC222.2 RC235.1 RC283.2 RC288.2 RC305.1 RC306.1 RC307.1 RC308.1 RC317.2 RC330.2 RC331.2 RC344.2 RC346.2 RC347.2 RC348.2 RC371.2 RC387.2 RC400.2 RC440.2 RC553.2 RC555.2 RI34.1 RI38.2 RI40.2 RI42.2 RI44.2 RI51.2 RI53.2 RI55.2 RI57.2 RI80.1 RPC3.5 RPC3.6 RPC3.7 RPC3.8 RZ69.1 RZ368.1 UC1.AJ21 UC1.AK17 UC1.V19 UC7.5
+3.3V_ALW_PCH_UZ3: CZ112.1 CZ210.1 PJP38.1 UZ3.13 UZ3.14
+3.3V_ALW_UE1: CE13.1 CE15.1 CE19.1 CE20.1 CE23.1 CE141.1 CE142.1 PJP22.2 RE314.2 UE1.B7 UE1.G8 UE1.H1 UE1.K2 UE1.M9
+3.3V_ALW_UZ12: CZ51.1 CZ52.1 PJP391.1 UZ12.1
+3.3V_ALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PC129.1 PC141.1 PC145.1 PJP102.1 PL100.2 PR108.2 PU100.14
+3.3V_CAM: CV22.1 CV23.1 CZ1.1 JEDP1.11 QZ1.1
+3.3V_CPS: CT117.1 CT118.1 CT119.1 CT120.1 CT121.1 LT11.2 RT246.1 UT9.6 UT9.20 UT9.28
+3.3V_CPS_R1: CT122.1 RT246.2 UT9.1
+3.3V_EC_PLL: CE17.1 CE18.1 RE314.1 UE1.F1
+3.3V_HDD: CN10.1 CN11.1 CN16.1 CN17.1 JSATA1.9 JSATA1.10 PJP34.2 RN3.1 RN6.1 RN8.2 RN10.2 RN12.1 RN14.1 RN16.1 RN18.1 RN20.1 UN7.10 UN7.20
+3.3V_HDD_M2: CN60.1 CN61.1 CN62.1 CN63.1 CN64.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.70 JNGFF3.72 JNGFF3.74 PJP31.2 RN37.1
+3.3V_LAN: CL15.1 CL18.1 CL19.1 JLOM1.9 JLOM1.12 PJP37.2 RC19.2 RC20.2 RL1.2 RL2.2 RL4.2 RL5.2 RL6.2 RL8.2 RL29.1 RL30.1 RL70.2 UL2.5
+3.3V_LAN_OUT: CL7.1 CL28.1 CL29.1 CL30.1 RL8.1 UL1.4 UL1.5 UL1.15 UL1.19 UL1.29
+3.3V_LAN_UZ2: CZ111.1 PJP37.1 UZ2.8 UZ2.9
+3.3V_M_TPM: CZ59.1 CZ60.1 RZ366.2 RZ367.1 RZ368.2 RZ369.2
+3.3V_MMI_AUX: CR1.1 CR2.1 CR27.1 CR28.1 R274.2 RR3.1 RR19.2 UR1.27
+3.3V_MMI_IN: CR3.1 CR4.1 CR25.1 CR26.1 PJP14.2 R274.1 UR1.11
+3.3V_PDA_VOUT: CT83.1 UT5.H2
+3.3V_PGPPB: CC124.1 CC125.1 RC305.2 UC1.AG15
+3.3V_PGPPC: CC94.1 CC95.1 RC306.2 UC1.Y16
+3.3V_PGPPD: RC307.2 UC1.Y15
+3.3V_PGPPE: CC96.1 CC97.1 RC308.2 UC1.T16
+3.3V_RTC_LDO: PD3.3 PR105.2
+3.3V_RUN: CA7.1 CC30.1 CN1.1 CN2.1 CN3.1 CN20.1 CN21.1 CN30.1 CN31.1 CV81.1 CV82.1 CV83.1 CV84.1 CV85.1 CV100.1 CV106.1 CZ67.1 CZ72.1 JEDP1.10 JESPI.1 JESPI.2 JUSH1.19 LGA1.2 LGA1.3 LGA1.9 LGA1.10 LV14.1 LV30.1 PJP14.1 PJP18.1 PJP31.1 PJP34.1 PJP35.1 PJP39.2 PR612.1 QC2.2 QC2.5 QV3.2 QV3.5 QV5.2 QZ1.3 RC47.2 RC50.2 RC51.2 RC59.2 RC137.2 RC175.2 RC176.2 RC177.2 RC178.2 RC186.2 RC189.2 RC190.2 RC225.2 RC237.2 RC267.2 RC272.2 RC278.2 RC279.2 RC282.2 RC287.2 RC291.2 RC292.2 RC318.2 RC319.2 RC345.2 RC370.2 RC402.2 RC403.2 RC404.2 RC413.2 RC414.2 RD4.1 RD6.1 RD8.1 RD10.1 RD19.2 RD20.1 RD22.1 RD24.1 RD26.1 RE48.1 RE51.1 RE67.2 RE547.2 RI79.1 RN2.1 RN4.1 RN25.1 RN26.1 RN27.1 RN28.1 RN42.1 RN43.1 RN44.1 RN49.1 RN50.1 RN51.1 RN55.1 RN56.1 RN57.1 RN58.1 RN63.1 RN64.1 RN65.1 RN69.1 RN70.1 RN71.1 RN171.1 RN226.1 RN228.1 RPC4.5 RPC4.6 RPC4.7 RPC4.8 RT397.1 RV8.2 RV18.1 RV19.2 RV20.2 RV70.2 RV72.2 RV79.2 RV81.2 RV83.2 RV85.2 RV87.2 RV89.2 RV91.2 RV93.2 RV95.2 RV106.2 RV107.2 RV124.1 RV326.1 RV620.1 RV622.1 RZ89.1 RZ362.1 RZ365.2 UC8.14 UC12.5 UN4.12 UN4.24 UN5.12 UN5.24 UV6.14 UV6.26 UV7.5 UV7.21 UV7.30 UV7.51 UV7.57 UZ5.6 UZ5.7
+3.3V_RUN_AUDIO: CA67.1 CA68.1 LA12.2 LA14.2 PJP16.2 PJP18.2 RA18.2 RA59.1 RA61.1
+3.3V_RUN_AUDIO_DVDD: CA10.1 CA61.1 LA14.1 UA1.1
+3.3V_RUN_AUDIO_IO: CA55.1 CA56.1 LA12.1 UA1.9
+3.3V_RUN_AUDIO_UZ5: CZ128.1 PJP16.1 UZ5.8 UZ5.9
+3.3V_RUN_CARD: CR17.2 CR18.2 JSD1.4 UR1.12
+3.3V_RUN_DIMM1: CD27.1 CD28.1 JDIMM1.255 RD10.2
+3.3V_RUN_DIMM2: CD59.1 CD60.1 JDIMM2.255 RD26.2
+3.3V_RUN_UT9: LT11.1 RT131.2 RT135.2 RT137.2 RT139.2 RT141.2 RT143.2 RT145.2 RT247.2 RT308.2 RT397.2 RT398.2 RT411.1 RT412.1
+3.3V_RUN_UZ3: CZ115.1 CZ211.1 PJP39.1 UZ3.8 UZ3.9
+3.3V_SPI: CC9.1 CC10.1 JSPI1.15 RC30.2 RC31.2 RC41.2 UC1.AJ16 UC5.8 UC6.8
+3.3V_TBTA_FLASH: CT70.1 CT84.1 JDB1.1 RT50.1 RT51.1 RT52.1 RT53.1 RT66.2 RT67.2 RT76.2 RT95.2 RT98.2 RT106.2 RT107.2 RT378.2 RT379.2 RT405.1 RT406.1 RT407.1 UT5.G1 UT6.8
+3.3V_TP: CZ83.1 CZ90.1 JKBTP1.9 PJP35.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_USB_UI5: CI37.1 CI38.1 RI79.2 RI80.2 UI5.1 UI5.13
+3.3V_VCCHDA: CC313.1 CC324.1 LC1.2 UC1.AJ19
+3.3V_VDD_DCIN: PC9.1 PC10.1 PD1801.3 PR17.1 PR27.2 PR1206.1 PR1208.1 PU1.5 PU2.3
+3.3V_VDD_PIC: CT91.1 CT92.1 PC1204.1 PD1801.2 PJP7.1 PR1214.1 PR1226.1 PR1236.2 PR1237.1 PR1240.1 PR1253.1 PR1254.2 PU1200.5 QT1.2 QT1.5 RT398.1 UT7.5
+3.3V_VDD_PIC_PDA: CT74.1 PJP7.2 UT5.B1 UT5.H1
+3.3V_VGA: LV14.2 UV6.1
+3.3V_WLAN: CZ27.1 CZ28.1 CZ29.1 CZ30.1 CZ31.1 CZ32.1 CZ33.1 CZ34.1 CZ35.1 CZ36.1 JNGFF1.2 JNGFF1.4 JNGFF1.72 JNGFF1.74 PJP36.2
+3.3V_WLAN_UZ4: CZ122.1 PJP36.1 UZ4.8 UZ4.9
+3.3V_WWAN: CZ17.1 CZ18.1 CZ19.1 CZ20.1 CZ21.1 CZ23.1 CZ24.1 CZ25.1 CZ26.1 CZ133.1 CZ134.1 CZ212.1 JNGFF2.2 JNGFF2.4 JNGFF2.70 JNGFF2.72 JNGFF2.74 PJP41.2 RZ43.2 RZ154.1 RZ156.1 RZ158.1 RZ160.1 RZ162.1 RZ164.1 RZ166.1 RZ354.1 RZ356.1 RZ358.1 RZ360.1 UZ36.12 UZ36.24
+3.3V_WWAN_UZ2: CZ119.1 CZ124.1 PJP41.1 UZ2.13 UZ2.14
+5V_ALW: CI6.1 CI7.1 CI11.1 CI12.1 CI19.1 CI31.1 CI33.1 CI34.1 CZ64.1 CZ69.1 DT1.2 JLED1.1 JUSH1.18 LED3.2 PC661.1 PC668.1 PC685.1 PC697.1 PJP8.1 PJP103.2 PJP403.1 PJP404.1 PL405.1 PL406.1 PR7.1 PR602.2 PR615.2 PR634.2 PR680.1 PR681.1 PR686.1 PR688.1 PR689.1 PR691.1 PU610.15 PU612.15 PU613.15 PU614.6 RA53.2 RI13.2 UI1.5 UI2.5 UI3.1 UI3.7 UI3.8 UZ2.4 UZ3.4 UZ4.1 UZ4.2 UZ4.4 UZ5.4 UZ8.4 UZ19.3 UZ21.3 UZ23.1 UZ23.2 UZ23.4 UZ26.3
+5V_ALW2: PC126.1 PU102.15
+5V_ALW_PDA: CT75.1 CT76.1 CT77.1 CT78.1 PJP8.2 UT5.A11 UT5.B11 UT5.C11 UT5.D11 UT5.H10
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PC130.1 PC132.1 PC144.1 PJP103.1 PL101.2 PR117.2 PU102.14
+5V_HDD: CN8.1 CN9.1 JSATA1.15 JSATA1.16 JSATA1.17 PJP32.2 PJP33.1 RN1.1
+5V_HDD_UZ23: CZ129.1 PJP32.1 UZ23.7 UZ23.8
+5V_PD_VDD: CT88.1 CT89.1 DT1.1 DT2.1 RT111.1 RT393.1 UT7.1
+5V_RUN: CE32.1 CE70.1 CV39.1 CZ66.1 CZ71.1 CZ92.1 DE1.1 JFAN1.4 JKBTP1.16 JUSH1.20 PJP17.1 PJP33.2 PJP40.2 QV8.3 RV6.2 RZ370.1 UV2.1 UV4.1 UZ5.1 UZ5.2
+5V_RUN_AUDIO: CA59.1 CA60.1 CA63.1 CA64.1 LA5.2 LA13.2 PJP15.1 PJP17.2
+5V_RUN_AUDIO_UZ5: CZ125.1 PJP15.2 UZ5.13 UZ5.14
+5V_RUN_CHG: QZ4.1 RZ370.2
+5V_RUN_PVDD_L: CA45.1 CA46.1 CA47.1 CA48.1 LA13.1 UA1.41 UA1.46
+5V_RUN_UZ4: CZ116.1 PJP40.1 UZ4.13 UZ4.14
+5V_TBT_VBUS: CT93.1 DT2.2 DT3.1
+5V_TBTA_VBUS_D: DT3.2 UT8.3
+5V_TSP: CV18.1 CV19.1 CZ2.1 JEDP1.1 QV8.1
+5V_USB_CHG_PWR: CI14.1 CI17.1 CI32.1 CI43.1 CI44.1 JUSB1.1 UI3.12
+DV33_18: CR2201.1 CR2202.1 UR1.18
+GND_CHASSIS: CL22.2 RL15.2 RL16.2 RL17.2 RL18.2
+VBUS_DC_SS: PD903.2 PD1202.2 PD1202.3 PQ1202.5 PQ1213.5
+VCC1V8A_TBTA_LDO: CT73.1 UT5.K1
+VCC1V8D_TBTA_LDO: CT72.1 RT97.1 UT5.A2
+VCC_1P8: CC112.1 CC113.1 RC313.2 UC1.U11 UC1.U12
+VCC_CORE: PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1061.1 PC1062.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC1127.1 PC1321.1 PL610.1 PL613.1 PR682.1 PR684.1 RC140.2 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_G0: T122.1(TP-1) UC1.K32
+VCC_CORE_G1: T123.1(TP-1) UC1.AK32
+VCC_GT: PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1055.1 PC1056.1 PC1063.1 PC1128.1 PC1129.1 PC1132.1 PC1133.1 PC1134.1 PC1136.1 PC1137.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1328.1 PC1329.1 PL612.1 PR683.1 RC161.2 RC437.1 RC438.2 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GT_+VCC_CORE: PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PR682.2 PR683.2 PR684.2 UC1.A48 UC1.A53 UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AM48 UC1.AM50 UC1.AM52 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.K48 UC1.K50
+VCC_GT_AK52: RC438.1 UC1.AK52
+VCC_GT_K52: RC437.2 UC1.K52
+VCC_GTX: UC1.AK53 UC1.AK55 UC1.AK56 UC1.AK58 UC1.AK60 UC1.AL53 UC1.AL56 UC1.AL60 UC1.AM53 UC1.AM56 UC1.AM58
+VCC_SA: PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PL614.1 RC168.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VCC_SFR_OC: CC288.1 CC322.1 CZ103.1 RZ119.2 UC1.AL23 UZ26.6
+VCCK_12: CV103.1 CV104.1 CV105.1 UV6.4 UV6.25
+VDD_DAC_33: LV30.2 UV6.20
+VDDA_AVDD1: CA8.1 CA9.1 LA5.1 UA1.26
+VSS_PLL: CE17.2 CE18.2 UE1.G1
