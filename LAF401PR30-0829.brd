# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_AUXN: length 38.4
  TOP w0.094: CV95.1 108.64,95.06 108.83,95.06 109.2,94.69 109.87,94.69 110.55,94.02 110.55,90.67 109.94,90.07 108.53,90.07 108.33,89.87 106.82,89.87 v1(106.81,89.87)
  IN1 w0.076: v1(109.65,67.25) 109.65,67.05 109.73,66.97 109.8,66.97 109.86,66.92 109.96,66.92 110.04,66.99 110.04,67.54 110.15,67.65 110.15,67.8
  IN1 w0.089: v1(109.91,74.82) 109.91,75.11 110,75.2 110.56,75.2 110.65,75.11 110.65,68.45 110.15,67.94 110.15,67.8
  IN4 w0.089: v1(109.91,74.82) 109.91,74.86 109.29,75.48 109.29,77.3 110.34,78.35 110.34,83.54 107.52,86.36 107.52,89.78 107.43,89.87 v1(106.81,89.87)
  BOTTOM w0.076: v1(109.65,67.25) 109.65,67.14 109.79,66.99 UC1.E48
CPU_DP2_AUXN_C: length 1.7
  TOP w0.094: UV7.25 106.76,95.26 106.9,95.11 107.7,95.11 CV95.2
CPU_DP2_AUXP: length 38.4
  TOP w0.094: v1(106.81,90.45) 107.21,90.06 108.25,90.06 108.45,90.25 109.86,90.25 110.36,90.75 110.36,93.94 109.8,94.51 109.12,94.51 108.75,94.88 108.62,94.88 CV94.1
  IN1 w0.076: 110.33,67.8 110.33,67.79 110.32,67.78 110.32,67.72 110.31,67.72 110.31,67.58 110.2,67.47 110.2,66.92 110.03,66.75 109.79,66.75 v1(109.65,66.61)
  IN1 w0.089: 110.33,67.8 110.33,67.87 110.83,68.37 110.83,75.19 110.64,75.38 110.22,75.38 v1(109.92,75.69)
  IN4 w0.089: v1(106.81,90.45) 107.22,90.05 107.51,90.05 107.7,89.85 107.7,86.44 110.52,83.62 110.52,78.28 109.47,77.22 109.47,75.56 109.69,75.34 109.81,75.34 109.92,75.44 v1(109.92,75.69)
  BOTTOM w0.076: UC1.F48 110.12,66.44 109.94,66.61 v1(109.65,66.61)
CPU_DP2_AUXP_C: length 1.7
  TOP w0.094: UV7.24 106.78,94.86 106.85,94.93 107.56,94.93 107.79,94.7 CV94.2
CPU_DP2_CTRL_CLK: length 62.4
  TOP w0.094: v1(107.23,93.97) 107.03,94.17 106.79,94.17 106.68,94.06 UV7.22 ; RC176.1 120.82,83.38 120.82,83.07 v1(120.92,82.97)
  IN1 w0.089: v1(133.6,62.34) 133.54,62.34 133.42,62.46 133.42,62.64 133.51,62.73 134.68,62.73 135.01,63.06 135.01,63.49 134.4,64.1 130.46,64.1 129.77,64.79 126.17,64.79 125.89,64.51 124.92,64.51 124.43,64.01 123.41,64.01 122.05,65.37 119.73,65.37 119.32,65.79 119.32,66.83 118.98,67.17 118.98,79.88 119.94,80.84 119.94,81.99 v1(120.92,82.97) 120.52,83.37 120.52,84.35 120.95,84.78 120.95,85.84 116.33,90.46 111.73,90.46 109.67,92.53 108.09,92.53 106.81,93.81 106.81,94.08 106.9,94.17 107.03,94.17 v1(107.23,93.97)
  BOTTOM w0.076: v1(133.6,62.34) 134.05,62.8 UC1.N7
CPU_DP2_CTRL_DATA: length 62.4
  TOP w0.094: RC177.1 120.64,83.61 120.64,83.27 v1(120.34,82.97) ; v1(107.23,94.55) 107.03,94.35 106.78,94.35 106.67,94.46 UV7.23
  IN1 w0.089: v1(107.23,94.55) 107.03,94.35 106.83,94.35 106.63,94.15 106.63,93.73 108.02,92.35 109.59,92.35 111.66,90.28 116.26,90.28 120.77,85.77 120.77,84.86 120.34,84.42 v1(120.34,82.97) 120.34,82.64 119.76,82.06 119.76,80.91 118.8,79.95 118.8,67.09 119.14,66.76 119.14,65.71 119.66,65.19 121.98,65.19 123.34,63.83 124.5,63.83 125,64.33 125.96,64.33 126.24,64.61 129.69,64.61 130.39,63.91 134.33,63.91 134.83,63.42 134.83,63.13 134.6,62.91 133.43,62.91 133.24,62.71 133.24,62.6 v1(132.99,62.36)
  BOTTOM w0.076: UC1.N8 133.34,62.8 132.99,62.46 v1(132.99,62.36)
CPU_DP2_HPD: length 76.9
  TOP w0.102: v2(119.13,83.43) 119.38,83.18 v1(119.73,83.18) ; v1(98.46,90.98) 98.8,91.32 UV7.3
  IN1 w0.089: v1(134.36,63.28) 133.96,63.68 130.26,63.68 130.01,63.43 125.77,63.43 125.76,63.44 123.2,63.44 122.84,63.8 121.62,63.8 121.11,64.31 121.11,64.79 120.99,64.92 119.41,64.92 118.78,65.55 118.61,65.55 118.31,65.85 118.31,66.28 118.48,66.46 118.48,72.08 117.55,73.02 117.55,79.53 119.26,81.24 119.26,82.71 v1(119.73,83.18) 119.73,84.51 119.13,85.11 115.58,85.11 115.19,85.5 115.19,85.97 112.58,88.59 109.78,88.59 109.54,88.35 109.54,86.89 110.05,86.38 110.05,83.2 108.72,81.87 105.1,81.87 104.46,82.5 102.94,82.5 100.65,84.79 100.65,86.25 99.07,87.84 99.07,90.37 v1(98.46,90.98)
  BOTTOM w0.076: v1(134.36,63.28) UC1.L7
CPU_DP2_N0: length 30.5
  TOP w0.094: v1(101.8,86.95) 101.61,87.15 101.61,87.57 100.68,88.5 100.68,89.1 CV87.1
  IN4 w0.089: v1(101.8,86.95) 101.61,87.15 101.61,87.62 101.86,87.88 104.23,87.88 104.63,87.48 104.63,86.28 105.31,85.59 105.7,85.59 106.31,84.98 106.31,84.31 105.9,83.9 105.9,82.9 107.42,81.38 107.42,74.77 107.62,74.58 107.75,74.58 107.96,74.37 v1(107.96,74.01)
  BOTTOM w0.076: v1(107.96,74.01) 107.96,74.32 108.03,74.38 108.28,74.38 108.49,74.18 108.96,74.18 109.32,73.82 109.32,70.39 109.24,70.31 109.16,70.31 109.1,70.25 109.1,70.13 109.17,70.06 109.35,70.06 109.43,69.98 109.43,69.61 109.37,69.49 109.37,69.34 109.43,69.15 109.43,68.98 109.43,68.97 109.35,68.71 109.16,68.71 109.06,68.61 109.06,68.43 109.1,68.39 109.14,68.39 UC1.C50
CPU_DP2_N0_C: length 3.4
  TOP w0.094: CV87.2 100.68,90.13 100.68,90.32 100.29,90.72 100.29,91.33 100.32,91.37 100.32,92.06 100.29,92.09 100.29,92.35 100.4,92.46 UV7.7
CPU_DP2_N1: length 24.9
  TOP w0.094: CV89.1 102.14,89.1 102.14,88.83 v4(102.53,88.44) 102.81,88.16 102.81,87.15 v1(103.01,86.95)
  IN4 w0.089: v1(106.9,73.03) 106.9,72.85 106.63,72.59 106.49,72.59 106.41,72.68 106.41,78.53 105.19,79.75 105.19,81.82 103.76,83.24 103.76,85.18 102.74,86.21 102.74,86.68 v1(103.01,86.95)
  BOTTOM w0.076: UC1.C52 108.08,68.46 108.08,68.6 107.96,68.72 107.89,68.72 107.83,68.79 107.83,68.79 107.77,68.98 107.77,69.15 107.83,69.34 107.83,69.49 107.77,69.61 107.77,69.87 107.95,70.05 107.95,70.53 107.61,70.87 107.61,72.17 106.9,72.88 v1(106.9,73.03)
CPU_DP2_N1_C: length 3.5
  TOP w0.094: UV7.10 101.6,92.49 101.49,92.38 v4(101.49,91.76) 101.49,91.19 102.14,90.54 102.14,90.13 CV89.2
CPU_DP2_N2: length 24.3
  TOP w0.094: v1(104.22,86.95) 104.02,87.15 104.02,88.16 103.41,88.76 103.41,89.1 CV91.1
  IN4 w0.089: v1(108.08,73.43) 108.08,73.33 107.85,73.1 107.63,73.1 107.03,73.7 107.03,78.8 106.46,79.37 106.46,81.48 105.37,82.56 105.37,83.97 104.6,84.74 104.6,85.51 103.81,86.3 103.81,86.55 v1(104.22,86.95)
  BOTTOM w0.076: v1(108.08,73.43) 108.28,73.24 108.64,73.24 109.05,72.82 109.05,70.49 108.85,70.29 108.85,69.51 108.92,69.43 109.08,69.43 109.16,69.51 UC1.A50
CPU_DP2_N2_C: length 3.5
  TOP w0.094: UV7.13 102.8,92.47 102.69,92.36 102.69,91.13 103.18,90.64 103.18,90.59 103.41,90.36 103.41,90.13 CV91.2
CPU_DP2_N3: length 25.3
  TOP w0.094: v1(105.8,86.95) 105.61,87.15 105.61,88.25 104.79,89.07 104.79,89.2 CV93.1
  IN4 w0.089: v1(108.03,71.03) 108.1,71.09 108.48,71.09 108.78,71.39 108.78,73.23 109.34,73.79 109.34,74.87 108.71,75.51 108.71,78.13 108.34,78.5 108.34,82.95 107.86,83.43 107.86,84.92 106.39,86.38 105.81,86.38 105.67,86.52 105.67,86.81 v1(105.8,86.95)
  BOTTOM w0.076: v1(108.03,71.03) 108.25,71.24 108.4,71.24 108.48,71.16 108.48,70.62 108.33,70.47 108.33,68.97 108.3,68.94 108.3,68.59 108.42,68.47 108.42,68.27 UC1.D51
CPU_DP2_N3_C: length 3.5
  TOP w0.094: CV93.2 104.68,90.13 v4(104.68,90.8) 104.68,91.01 104.35,91.34 104.35,91.76 103.93,92.18 103.93,92.39 104,92.45 UV7.16
CPU_DP2_P0: length 30.6
  TOP w0.094: v1(101.22,86.95) 101.42,87.15 101.42,87.49 101.04,87.87 100.5,88.42 100.5,89.1 CV86.1
  IN4 w0.089: v1(108.09,74.83) 108.01,74.76 107.69,74.76 107.6,74.85 107.6,81.46 106.08,82.97 106.08,83.83 106.49,84.23 106.49,85.05 105.77,85.77 105.39,85.77 104.81,86.35 104.81,87.56 104.31,88.06 101.78,88.06 101.42,87.7 101.42,87.15 v1(101.22,86.95)
  BOTTOM w0.076: v1(108.09,74.83) 108.09,74.81 108.56,74.34 109.03,74.34 109.48,73.89 109.48,70.31 109.59,70.2 109.59,69.57 109.58,69.54 109.56,69.48 109.56,69.29 109.59,69.2 109.59,68.95 109.59,68.93 109.52,68.69 109.52,68.44 109.36,68.16 UC1.D50
CPU_DP2_P0_C: length 3.4
  TOP w0.094: UV7.6 100,92.48 100.1,92.38 v4(100.1,91.76) 100.1,90.64 100.5,90.25 100.5,90.13 CV86.2
CPU_DP2_P1: length 24.9
  TOP w0.094: v1(102.43,86.95) 102.63,87.15 102.63,88.02 102.14,88.51 102.14,88.57 101.96,88.75 101.96,89.1 CV88.1
  IN4 w0.089: v1(102.43,86.95) 102.56,86.82 102.56,86.13 103.58,85.11 103.58,83.16 105.01,81.74 105.01,79.67 106.23,78.45 106.23,72.6 106.42,72.41 106.81,72.41 v1(106.9,72.32)
  BOTTOM w0.076: v1(106.9,72.32) 106.92,72.34 107.19,72.34 107.44,72.1 107.44,70.8 107.78,70.46 107.78,70.12 107.6,69.94 107.6,69.57 107.62,69.53 107.66,69.45 107.66,69.37 107.6,69.17 107.6,68.95 107.62,68.91 107.65,68.8 107.68,68.68 107.74,68.47 107.74,68.36 107.82,68.09 UC1.D52
CPU_DP2_P1_C: length 3.5
  TOP w0.094: UV7.9 101.2,92.5 101.3,92.4 101.3,92.1 101.27,92.06 101.27,91.47 101.3,91.43 101.3,91.12 101.96,90.46 101.96,90.13 CV88.2
CPU_DP2_P2: length 24.3
  TOP w0.094: v1(103.63,86.95) 103.83,87.15 103.83,88.08 103.23,88.68 103.23,89.1 CV90.1
  IN4 w0.089: v1(103.63,86.95) 103.63,86.23 104.42,85.44 104.42,84.66 105.19,83.9 105.19,82.49 106.28,81.4 106.28,79.29 106.85,78.72 106.85,73.63 107.56,72.92 107.97,72.92 v1(108.09,72.81)
  BOTTOM w0.076: v1(108.09,72.81) 108.09,72.92 108.24,73.07 108.57,73.07 108.89,72.75 108.89,70.56 108.68,70.35 108.68,69.44 108.85,69.27 109.08,69.27 109.16,69.19 UC1.B50
CPU_DP2_P2_C: length 3.5
  TOP w0.094: CV90.2 103.21,90.12 103.21,90.3 v4(102.73,90.78) 102.5,91.01 102.5,92.36 102.4,92.47 UV7.12
CPU_DP2_P3: length 25.3
  TOP w0.094: v1(105.22,86.95) 105.42,87.15 105.42,88.18 CV92.1
  IN4 w0.089: v1(105.22,86.95) 105.49,86.68 105.49,86.44 105.73,86.2 106.32,86.2 107.68,84.84 107.68,83.36 108.16,82.88 108.16,78.43 108.53,78.06 108.53,75.43 109.16,74.8 109.16,73.86 108.6,73.31 108.6,71.47 108.41,71.27 108.32,71.27 108.03,71.56 v1(108.03,71.61)
  BOTTOM w0.076: v1(108.03,71.61) 108.24,71.41 108.47,71.41 108.65,71.23 108.65,70.56 108.5,70.4 108.5,69.16 108.57,69.08 108.71,69.08 108.88,68.92 108.88,68.81 108.77,68.69 108.64,68.69 UC1.C51
CPU_DP2_P3_C: length 3.5
  TOP w0.094: CV92.2 104.46,90.1 104.46,90.96 104.16,91.26 104.16,91.69 103.74,92.1 103.74,92.34 103.6,92.49 UV7.15
CPU_DP3_AUXN: length 1.3
  TOP w0.102: v1(110.56,65.93) 111.03,65.46 T1.1
  BOTTOM w0.102: UC1.G46 110.84,65.69 110.6,65.93 v1(110.56,65.93)
CPU_DP3_AUXP: length 1.2
  TOP w0.102: v1(110.51,66.62) 110.23,66.34 T2.1
  BOTTOM w0.102: UC1.F46 110.78,66.34 110.51,66.61 v1(110.51,66.62)
CPU_POPIRCOMP: length 10.8
  TOP w0.254: 129.26,49.32 128.78,49.32 128.44,49.65 128.44,50.14 128.08,50.5 v1(127.99,50.5)
  TOP w0.381: RC88.1 132.85,45.9 v2(131.57,47.18) 130.35,48.4 130.35,48.68 129.71,49.32 129.26,49.32
  BOTTOM w0.254: UC1.AT16 128.4,50.81 v1(127.99,50.5)
CPU_XDP_PRDY#: length 96
  TOP w0.102: v1(56.46,37.82) 56.65,37.63 v2(56.65,36.59) 56.65,35.8 59.6,32.86 66.98,32.86 67.19,32.66 70.03,32.66 70.59,33.21 73.76,33.21 74.45,33.9 JXDP1.5
  IN1 w0.089: v1(56.46,37.82) 57.73,39.09 57.73,39.71 59.97,41.95 59.97,43.85 60.97,44.85 60.97,45.42 65.38,49.84 65.38,51.4 66.22,52.24 71.94,52.24 72.27,52.58 74.27,52.58 75.23,53.54 78.52,53.54 83.98,58.99 83.98,61.08 86.19,63.29 87.2,63.29 88.17,64.26 88.17,66.03 92.64,70.5 98.18,70.5 99.07,69.61 102.85,69.61 v1(104.86,71.62)
  BOTTOM w0.076: v1(104.86,71.62) 104.86,70.99 105.26,70.6 105.26,70.07 105.12,69.94 105.12,69.57 105.16,69.5 105.16,69.29 105.15,69.26 105.15,69.23 105.13,69.22 105.12,69.2 105.12,68.95 105.14,68.91 105.18,68.75 105.26,68.47 105.26,68.36 105.34,68.09 UC1.D56
CPU_XDP_PREQ#: length 80.2
  TOP w0.102: v1(60.56,45.34) 60.67,45.23 64,45.23 v2(64.82,44.41) 66.88,42.34 70.1,42.34 71.84,40.61 72.76,40.61 73.63,39.74 73.97,39.74 74.07,39.64 74.07,39.11 74.82,38.36 RC138.1 75.06,37.32 74.95,37.21 JXDP1.3
  IN1 w0.089: v1(60.56,45.34) 65.09,49.87 65.09,51.58 65.94,52.43 71.86,52.43 72.19,52.77 74.19,52.77 75.19,53.76 78.48,53.76 83.79,59.07 83.79,62.39 86.53,65.13 87,65.13 92.56,70.69 98.68,70.69 99.2,71.21 v1(103.17,71.21)
  BOTTOM w0.076: v1(103.17,71.21) 103.37,71.01 103.37,68.88 103.35,68.86 103.35,68.62 103.37,68.6 103.37,68.23 103.35,68.21 103.35,68.03 UC1.D61
CPU_XDP_TCLK: length 93.5
  TOP w0.102: JXDP1.57 61.45,37.47 61.35,37.58 RC139.1 60.29,38.36 59.42,39.24 59.42,44.95 58.83,45.53 58.02,45.53 57.38,46.17 v2(57.38,51.33) v1(57.38,53.79)
  IN1 w0.089: v1(101.73,74.15) 100.23,75.65 92.5,75.65 90.69,77.46 87.1,77.46 84.4,74.76 84.4,71.25 82.81,69.66 82.81,64.99 81.42,63.61 76.61,63.61 74.45,61.45 74.45,57.57 72.99,56.11 63.24,56.11 60.93,53.79 v1(57.38,53.79)
  BOTTOM w0.076: UC1.B61 102.87,69.27 102.87,69.49 102.81,69.61 102.81,69.87 102.99,70.04 102.99,70.63 102.52,71.09 102.52,71.74 101.49,72.77 101.49,73.03 101.66,73.21 101.66,74.08 v1(101.73,74.15)
  BOTTOM w0.102: v1(101.73,74.15) 102.11,74.53 102.11,77.35 101.58,77.88 RC328.1
CPU_XDP_TDI: length 86.7
  TOP w0.102: v2(51.81,38.18) v1(51.81,37.41) 52.18,37.04 52.18,36.31 RC134.1 51.69,34.92 52.22,34.39 UC8.6
  IN1 w0.089: v1(102.62,73.52) 102.62,73.46 102.27,73.11 102.27,72.65 102.13,72.51 101,72.51 99.7,73.81 97.35,73.81 96.78,73.23 92.78,73.23 89.29,69.74 87.25,69.74 85.7,68.19 85.57,68.19 85.04,67.66 85.04,65.93 81.62,62.5 76.97,62.5 75.84,61.37 75.84,57.62 73.47,55.26 63.86,55.26 62.43,53.82 62.43,50.19 60.4,48.16 58.35,48.16 56.9,46.72 56.9,41.42 53.76,38.27 52.56,38.27 51.81,37.53 v1(51.81,37.41)
  BOTTOM w0.076: UC1.D60 103.64,68.33 103.93,68.62 103.93,68.86 103.72,69.08 103.72,71.52 103.02,72.22 103.02,73.12 v1(102.62,73.52)
CPU_XDP_TDO: length 81.6
  TOP w0.102: v1(53.56,38.81) 54.3,38.07 v2(54.3,37.8) 54.23,37.72 54.23,36.32 RC135.1 53.72,35.81 UC8.3
  IN1 w0.089: v1(101.88,72.9) 101.87,72.89 100.89,72.89 99.79,74 97.22,74 96.65,73.42 92.65,73.42 89.16,69.93 86.2,69.93 84.84,68.57 84.84,66.03 81.56,62.76 76.9,62.76 75.42,61.27 75.42,57.52 73.34,55.45 63.78,55.45 62.24,53.9 62.24,50.26 60.32,48.35 58.27,48.35 56.69,46.78 56.69,41.48 54.03,38.81 v1(53.56,38.81)
  BOTTOM w0.076: UC1.A61 103.16,69.8 103.16,70.69 102.69,71.15 102.69,71.9 101.88,72.72 v1(101.88,72.9)
CPU_XDP_TMS: length 94.1
  TOP w0.102: v1(49.71,28.82) 50.71,28.82 RC131.1 51.12,29.37 51.12,32.19 51.22,32.29 UC8.8
  IN1 w0.089: v1(102.65,72.93) 102.65,72.67 102.26,72.28 100.95,72.28 99.62,73.61 97.48,73.61 96.91,73.04 92.91,73.04 89.41,69.55 87.38,69.55 85.76,67.93 85.6,67.93 85.23,67.57 85.23,65.84 82.34,62.95 82.34,59.62 81.03,58.31 76.84,58.31 73.59,55.07 63.94,55.07 62.62,53.74 62.62,50.11 60.48,47.97 58.43,47.97 57.1,46.65 57.1,41.35 53.82,38.07 52.74,38.07 52.21,37.54 52.21,35.98 49.71,33.49 v1(49.71,28.82)
  BOTTOM w0.076: v1(102.65,72.93) 102.65,72.35 103.55,71.46 103.55,68.83 UC1.C60
CPU_XDP_TRST#: length 108.6
  TOP w0.102: v1(101.26,73.33) v3(100.59,73.33) ; RC136.1 CC308.1 ; CC308.1 UC8.11 ; CC308.1 52.71,28.79 52.71,27.75 51.59,26.64 49.97,26.64 v1(49.89,26.56)
  IN1 w0.089: v1(49.89,26.56) 49.28,27.17 49.28,33.85 51.24,35.81 51.24,37.44 53.09,39.29 54.23,39.29 56.5,41.56 56.5,46.86 58.19,48.54 60.25,48.54 62.04,50.34 62.04,53.98 63.71,55.64 73.21,55.64 74.95,57.38 74.95,61.19 76.75,62.98 81.49,62.98 84.05,65.55 84.05,68.12 86.11,70.17 89.08,70.17 92.52,73.61 96.53,73.61 97.1,74.19 100.4,74.19 v1(101.26,73.33) 101.62,73.33 102.47,74.18 v1(102.47,74.27)
  BOTTOM w0.076: v1(102.47,74.27) 102.59,74.14 103.28,73.45 103.28,72.19 103.88,71.59 103.88,69.39 UC1.B59 ; v1(101.26,73.33) 101.26,72.72 102.36,71.62 102.36,71.02 102.82,70.56 102.82,70.11 102.65,69.94 102.65,69.57 102.66,69.54 102.68,69.48 102.68,68.87 102.69,68.86 102.69,68.8 UC1.C61
CSI2_COMP: length 12.8
  TOP w0.508: RC3.1 129.16,76.28 130.25,75.2 130.25,70.93 128.91,69.59 v2(128.91,67.84) 129.53,67.21 v1(129.77,67.21)
  BOTTOM w0.254: v1(129.77,67.21) UC1.E13
CSIN_ISL9538: length 7.5
  TOP w0.102: PR910.2 15.32,23.47 v2(15.32,24.91)
  TOP w0.203: PU901.14 17.85,20.96 PC927.1 PC925.2 16.8,23.02 15.77,23.02 PR910.2
CSIP_ISL9538: length 5
  TOP w0.203: PU901.15 v2(17.45,20.26) 17.45,20.5 PC926.1 PC925.1 15.87,22.5 PR909.2
CSON_ISL9538: length 5.9
  TOP w0.203: PC946.1 23.44,13.11 PR938.1 22.61,13.3 PC945.1 21.52,14.39 v2(21.52,14.93) 21.52,15.31 21.27,15.56 PU901.1
CSOP_ISL9538: length 7.3
  TOP w0.102: PC942.1 24.38,15.75 v2(26.14,15.75)
  TOP w0.203: PU901.2 20.87,15.96 20.91,15.92 21.39,15.92 21.93,15.38 21.93,14.9 PC945.2 23.25,14.37 PR937.1
  TOP w0.254: PC942.1 23.44,14.8 PR937.1
CV2_ON: length 157.5
  TOP w0.102: v1(237.24,25.8) 237.24,25.04 v3(237.5,24.78) ; JUSH1.3 224.28,8.15 v1(224.39,8.04) ; RE539.2 307.71,91.48 308.13,91.06 308.89,91.06 310.48,89.48 310.48,87.92 309.69,87.14 309.12,87.14 308.87,87.39 308.36,87.39 308.03,87.06 308.03,86.05 v1(307.8,85.82)
  IN3 w0.122: v1(307.8,85.82) 307.61,85.82 305,83.2 305,82.53 304.03,81.56 300.6,81.56 300.22,81.18 300.22,80.32 300.35,80.19 300.35,80.18 300.58,79.95 300.59,79.95 300.8,79.74 300.8,77.55 300.13,76.88 299.81,76.88 299.79,76.86 295.57,76.86 295.55,76.88 295.42,76.88 294.75,76.21 294.75,73.86 294.57,73.68 294.57,71.44 293.91,70.78 293.91,65.42 293.54,65.06 293.54,63.84 293.27,63.57 293.27,62.7 293.02,62.45 293.02,59.79 293.22,59.6 293.22,57.04 292.24,56.07 292.24,55.09 290.9,53.74 290.15,53.74 289.77,53.36 289.77,52.73 289.38,52.35 288.61,52.35 287.18,50.92 287.18,50.39 284.11,47.31 283.49,47.31 281.82,45.64 281.82,44.57 280.63,43.37 280.63,41.48 279.96,40.81 279.96,38.6 279.5,38.13 279.5,37.57 278.88,36.94 278.88,36.12 277.75,34.99 270.79,34.99 269.98,34.18 258.84,34.18 257.26,32.6 248.93,32.6 247.29,30.96 242.98,30.96 237.83,25.8 v1(237.24,25.8)
  IN4 w0.089: v1(224.39,8.04) 224.51,8.04 224.62,8.15 v1(230.05,8.15)
  BOTTOM w0.102: v1(237.24,25.8) 236.6,25.8 234.54,23.74 230.78,23.74 227.67,20.63 227.67,10.53 v1(230.05,8.15)
CV2_ON_R: length 18.4
  TOP w0.102: RE539.1 306.23,91.04 306.23,90.32 305.85,89.93 v2(305.85,89.38) 305.87,89.35 306.8,89.35 306.98,89.17 RPE10.1 v1(306.98,88.07)
  TOP w0.107: v1(301.56,77.93) UE1.H8
  BOTTOM w0.102: v1(306.98,88.07) 305.44,86.53 305.44,85.16 304.75,84.47 304.09,84.47 302.75,83.14 302.75,79.31 302.59,79.14 302.17,79.14 301.95,78.93 301.95,78.32 v1(301.56,77.93)
DAT_DDC2_CRT: length 86.2
  TOP w0.102: UV6.16 279.39,53.33 280.26,53.33 280.62,52.97 v1(280.62,52.89) ; v1(318.5,80.58) 317.84,80.58 317.63,80.8 RV119.1 318,81.3 v2(319.24,81.3) 319.54,81.3 319.95,80.89 JCRT1.12
  IN2 w0.122: v1(318.5,80.58) 318.39,80.58 317.64,79.82 317.64,77.67 318.1,77.2 318.1,75.36 316.27,73.52 315,73.52 313.21,75.32 313.21,81.02 312.26,81.97 312.26,82.44 310.63,84.08 300.95,84.08 300.63,84.4 298.58,84.4 297.87,83.69 295.43,83.69 290.48,78.73 290.02,78.73 289.05,77.76 288.39,77.76 288.09,77.46 288.09,75.62 285.29,72.82 284.55,72.82 284.14,72.41 284.14,71.85 281.2,68.92 281.2,67.46 282.14,66.53 283.08,66.53 284.37,65.23 284.37,58.35 284.71,58.01 284.71,55.93 283.52,54.73 283.01,54.73 281.49,53.21 281.05,53.21 280.74,52.89 v1(280.62,52.89)
DAT_TP_SIO_I2C_CLK: length 151.8
  TOP w0.102: v1(211.66,21.35) 211.66,22.24 213.49,24.07 213.49,25.16 214.2,25.88 RZ347.2 215.52,25.88 CZ80.1 ; RZ22.2 216.36,19.55 218.39,19.55 218.6,19.75 218.6,21 v1(218.98,21.38) ; v2(295.94,83.53) 295.94,82.87 v1(296.49,82.33) 296.57,82.33 296.67,82.23 296.67,81.22 UE1.C12
  IN1 w0.089: v1(211.66,21.35) 212.07,21.76 212.65,21.76 213.66,20.75 214.29,20.75 214.43,20.89 218.49,20.89 v1(218.98,21.38) 219.39,21.79 225.42,21.79 226.03,22.4 227.93,22.4 232.37,26.84 238.84,26.84 239.98,27.97 248.48,27.97 252.91,32.4 256.79,32.4 257.51,33.13 281.78,33.13 286.42,37.77 286.42,39.24 289.26,42.08 290.1,42.08 290.76,42.74 290.76,43.34 291.01,43.59 291.01,43.82 294.44,47.25 294.44,48.84 295.38,49.78 296.82,49.78 298.03,50.98 298.03,51.74 298.96,52.67 298.96,53.07 297.74,54.29 297.74,59.75 298.81,60.82 298.81,62.17 297.58,63.4 297.58,67.06 294.84,69.79 294.84,77.96 294.85,77.96 294.85,79.86 296.19,81.21 296.19,81.26 296.6,81.67 296.6,82.24 296.51,82.33 v1(296.49,82.33)
DAT_TP_SIO_R: length 4.6
  TOP w0.102: JKBTP1.8 213.65,19.15 213.8,19.3 v2(214.3,19.3) 214.3,19.32 215.32,20.34 RZ18.2 RZ22.1 216.9,20.34 CZ88.1
DCIN1_EN: length 433.3
  TOP w0.102: v1(22.74,39.9) v2(22.1,39.9) 21.34,39.13 PR1221.1
  TOP w0.107: v1(303.16,73.93) UE1.K4
  IN1 w0.089: v1(310.58,81.93) 309.95,81.3 309.95,79.71 309.38,79.14 306.41,79.14 305,77.73 304.1,77.73 303.34,76.97 301.36,76.97 300.8,76.41 300.8,74.86 301.36,74.31 302.59,74.31 302.97,73.93 v1(303.16,73.93)
  IN2 w0.122: v1(22.74,39.9) 23.63,39.9 25.33,41.6 25.33,42.49 25.1,42.72 25.1,47.14 23.16,49.07 23.16,54.18 32.92,63.93 32.92,64.6 38.87,70.56 38.87,72.79 42.05,75.98 42.05,77.09 44.99,80.03 49.54,80.03 53.04,83.53 53.04,85.62 54.75,87.33 58.3,87.33 59.81,88.84 62.28,88.84 64.98,91.54 67.21,91.54 68.65,92.98 72.4,92.98 73.28,92.09 87.46,92.09 88.22,91.33 90.66,91.33 92.31,92.98 94.42,92.98 95.26,92.14 96.73,92.14 97.36,92.78 100.23,92.78 103.18,89.82 104.56,89.82 105.06,89.32 107.75,89.32 108.97,90.54 109.85,90.54 110.01,90.7 115.44,90.7 116.33,89.81 120.04,89.81 120.68,89.18 125.74,89.18 126.25,89.68 132.98,89.68 134.12,90.83 145.35,90.83 146.11,90.06 151.64,90.06 152.81,88.9 v1(152.81,86.19)
  IN4 w0.089: v1(215.52,35.32) 216.74,36.54 220.65,36.54 221.15,37.04 245.43,37.04 255.81,47.41 255.81,48.02 260.55,52.76 260.55,53.49 264.04,56.98 264.04,60.85 266.45,63.26 266.45,69.33 266.87,69.76 266.87,82.89 272.14,88.16 275.02,88.16 275.65,88.79 275.65,90.52 277.33,92.2 283.06,92.2 286.2,95.33 302.07,95.33 302.52,94.89 302.52,94.48 302.88,94.13 303.25,94.13 303.52,94.39 306.19,94.39 309.19,91.39 309.19,84.92 310.58,83.52 v1(310.58,81.93)
  BOTTOM w0.102: v1(215.52,35.32) 211.52,35.32 205.7,41.14 205.28,41.14 204.56,41.86 203.92,41.86 202.87,42.91 199.99,42.91 187.77,55.14 187.77,59.13 171.24,75.65 166.12,75.65 165.8,75.96 161.23,75.96 159.45,77.74 159.45,81.23 154.5,86.19 v1(152.81,86.19)
DCIN2_EN: length 361.3
  TOP w0.102: UE1.L12 v1(303.97,81.14) ; v1(151.82,62.4) 152.35,62.4 v2(152.89,62.93)
  IN3 w0.122: v1(303.97,81.14) 304.9,81.14 305.44,81.68 307.09,81.68 307.15,81.74 309.76,81.74 310.27,81.23 310.27,75.91 309.68,75.33 309.68,73.12 308.56,72 308.56,67.84 309.3,67.1 309.3,63.87 307.62,62.2 307.62,61.05 307.05,60.48 307.05,55.28 304.68,52.9 303.87,52.9 302.52,51.55 302.52,50.82 301.43,49.73 299.33,49.73 298.77,49.17 298.77,48.02 299.01,47.78 299.01,47.41 297.63,46.03 297.63,44.73 297.05,44.14 296.04,44.14 295.78,43.89 295.78,42.93 293.87,41.02 293.87,40.33 293.49,39.95 293.49,39.67 292.86,39.05 292.86,38.06 290.06,35.25 289.3,35.25 281.61,27.56 266.27,27.56 266.04,27.78 261.22,27.78 258.96,25.52 250.57,25.52 249.5,24.45 246.59,24.45 240.8,18.66 232.33,18.66 229.63,15.97 217.95,15.97 217.62,15.64 215.33,15.64 214.19,16.78 210.7,16.78 209.38,18.1 207.92,18.1 204.1,21.92 199.57,21.92 191.21,30.27 188.13,30.27 176.54,41.86 176.54,43.13 172.28,47.39 171.99,47.39 171.3,48.07 171.3,49.14 164.17,56.28 160.58,56.28 154.47,62.4 v1(151.82,62.4) ; v1(141.86,94.4) 141.06,93.6 127.95,93.6 125.45,91.1 122.62,91.1 120.42,93.3 114.69,93.3 113.67,94.32 108.17,94.32 107.4,93.55 106.88,93.55 106.75,93.68 94.81,93.68 93.71,92.58 92.85,92.58 91.15,90.87 87.79,90.87 87.46,91.2 72.84,91.2 72.08,91.97 69.54,91.97 v1(69.47,91.9)
  IN4 w0.089: v1(141.86,94.4) 141.86,93.71 145.53,90.04 146.24,90.04 148.18,88.11 148.95,88.11 152.36,84.7 152.73,84.7 156.6,80.84 156.6,77.55 152.53,73.49 152.53,69.33 150.98,67.79 150.98,64.92 151.82,64.09 v1(151.82,62.4)
  BOTTOM w0.102: PR26.1 68.2,99.78 69.47,98.51 v1(69.47,91.9)
DCIN_ISL9538:
  vias: v2(14.23,19.32)
DDR_A_ACT#: length 73
  IN1 w0.076: 101.22,35.07 101.22,35.48 104.38,38.63 104.38,42.85 v1(104.05,43.18)
  IN1 w0.142: 101.22,35.07 101.22,32.16 96.67,27.6 85.1,27.6 84.41,26.92 83.01,26.92 82.37,26.27 78.08,26.27 67.21,15.4 67.21,9.4 67.44,9.18 67.44,8.13 67.12,7.81 67.12,7.56 67.28,7.39 67.88,7.39 v1(68.55,8.07)
  BOTTOM w0.076: v1(104.05,43.18) 104.05,43.35 106.1,45.4 106.1,46.09 105.84,46.35 105.84,46.67 105.98,46.81 105.98,47.22 105.93,47.36 105.93,47.47 105.98,47.6 105.98,47.83 UC1.BA55
  BOTTOM w0.168: JDIMM1.114 67.52,7.04 v1(68.55,8.07)
DDR_A_ALERT#: length 73.7
  IN1 w0.076: 101.66,35.07 101.66,35.35 104.66,38.35 104.66,42.21 106.24,43.79 v1(107.43,43.79)
  IN1 w0.142: 101.66,35.07 101.66,31.98 96.8,27.12 85.4,27.12 84.76,26.48 83.34,26.48 82.71,25.85 78.26,25.85 67.65,15.24 67.65,9.59 69.02,8.22 69.02,7.26 v1(68.55,6.8)
  BOTTOM w0.076: v1(107.43,43.79) 108.01,43.79 108.47,44.25 108.47,45.66 109.07,46.26 109.07,46.83 108.96,46.93 108.96,47.19 109.01,47.31 109.01,47.48 108.94,47.7 108.94,47.79 108.99,47.92 109,47.95 109,48.19 108.97,48.27 108.91,48.4 108.91,48.64 UC1.AW50
  BOTTOM w0.168: JDIMM1.116 68.03,6.27 v1(68.55,6.8)
DDR_A_BA0: length 74.2
  IN1 w0.076: 109.68,37.57 109.68,38.97 110.65,39.94 110.65,45.5 108.74,47.41 108.74,49.91 v1(108.75,49.91)
  IN1 w0.142: 109.68,37.57 109.68,26.98 109.45,26.75 109.18,26.75 109.04,26.89 108.77,26.89 108.58,26.7 108.58,26.43 108.72,26.29 108.72,26.02 108.53,25.83 108.26,25.83 108.12,25.97 107.85,25.97 107.66,25.78 107.66,25.51 107.8,25.37 107.8,25.1 100.3,17.59 86.75,17.59 86.47,17.32 81.16,17.32 79.81,15.96 79.21,15.96 77.25,14 77.25,8.64 v1(76.68,8.07)
  BOTTOM w0.076: v1(108.75,49.91) 108.46,50.2 UC1.AU52
  BOTTOM w0.168: v1(76.68,8.07) 78.53,6.22 JDIMM1.150
DDR_A_BA1: length 75.7
  IN1 w0.076: v1(109.66,50.58) 110.04,50.2 110.04,50.2 110.04,49.52 111.65,47.91 111.65,39.65 111.03,39.02 111.03,37.79
  IN1 w0.142: 111.03,37.79 111.03,25.06 108.05,22.09 107.78,22.09 107.61,22.26 107.34,22.26 107.15,22.07 107.15,21.8 107.32,21.63 107.32,21.36 107.13,21.17 106.86,21.17 106.69,21.34 106.42,21.34 106.23,21.15 106.23,20.88 106.4,20.71 106.4,20.44 106.21,20.25 105.94,20.25 105.77,20.42 105.5,20.42 102.34,17.26 102.34,16.99 102.75,16.58 102.75,16.31 102.56,16.12 102.29,16.12 101.88,16.53 101.61,16.53 101.2,16.12 87.33,16.12 87.13,15.92 81.76,15.92 78.72,12.88 78.72,9.45 v1(78.85,9.32)
  BOTTOM w0.076: v1(109.66,50.58) 110.02,50.85 UC1.AT48
  BOTTOM w0.168: v1(78.85,9.32) 77.27,10.9 77.27,13 JDIMM1.145
DDR_A_BG0: length 72.7
  IN1 w0.076: 100.36,35.25 100.36,35.76 103.43,38.83 103.43,39.62 v1(103.87,40.06)
  IN1 w0.142: v1(66.77,9.72) 66.77,9.38 66.51,9.12 65.82,9.12 65.18,9.75 65.18,13.08 65.5,13.4 65.5,13.91 65.18,14.23 65.18,14.62 77.68,27.11 80.24,27.11 80.95,27.83 83.77,27.83 84.54,28.59 96.32,28.59 100.36,32.63 100.36,35.25
  BOTTOM w0.076: v1(103.87,40.06) 104.47,40.66 104.47,43.53 106.65,45.71 106.65,46.66 106.44,46.86 106.44,47.23 106.46,47.26 106.49,47.34 106.49,47.46 106.42,47.68 106.42,47.82 106.48,47.98 106.48,48.16 106.4,48.32 106.11,48.61 UC1.AY55
  BOTTOM w0.168: JDIMM1.115 67.78,10.72 v1(66.77,9.72)
DDR_A_BG1: length 73.5
  IN1 w0.076: 100.79,35.07 100.79,35.65 103.18,38.04 103.19,38.04 v1(103.87,38.73)
  IN1 w0.142: v1(66.77,10.99) 66.32,10.54 66.32,9.88 66.1,9.66 65.87,9.66 65.64,9.89 65.64,10.89 66.27,11.52 66.27,11.76 66.66,12.16 66.66,12.36 66.52,12.5 65.77,12.5 65.6,12.67 65.6,12.91 65.77,13.07 66.48,13.07 66.73,13.33 66.73,13.63 66.13,14.23 66.13,14.92 77.91,26.69 80.83,26.69 81,26.87 81,27.14 81.23,27.36 81.49,27.36 81.66,27.2 81.66,26.86 81.83,26.69 82.06,26.69 82.23,26.86 82.23,27.2 82.4,27.36 84.02,27.36 84.69,28.03 96.49,28.03 100.79,32.33 100.79,35.07
  BOTTOM w0.076: v1(103.87,38.73) 103.87,38.79 104.71,39.63 104.71,43.54 106.81,45.64 106.81,46.73 106.61,46.93 106.61,47.19 106.66,47.31 106.66,47.45 106.6,47.68 106.6,47.81 106.67,48.03 106.67,48.28 UC1.AY54
  BOTTOM w0.168: v1(66.77,10.99) 67.27,11.49 JDIMM1.113
DDR_A_CKE0: length 73.5
  IN1 w0.076: 99.7,35.25 99.7,35.56 103.08,38.94 103.08,40.56 v1(103.85,41.33)
  IN1 w0.142: 99.7,35.25 99.7,32.99 95.97,29.25 84.21,29.25 83.44,28.49 80.65,28.49 79.92,27.76 77.41,27.76 64.52,14.88 64.52,9.49 65.57,8.45 v1(66.77,8.45)
  BOTTOM w0.076: UC1.BA56 105.55,47.59 105.41,47.45 105.4,47.44 105.4,47.44 105.28,47.19 105.28,47.19 105.28,46.89 105.34,46.82 105.34,46.14 105.47,46.02 105.47,45.59 103.15,43.27 103.15,42.03 v1(103.85,41.33)
  BOTTOM w0.168: v1(66.77,8.45) 66.11,9.11 66.11,11.26 66.27,11.42 JDIMM1.109
DDR_A_CKE1: length 72.5
  IN1 w0.076: v1(103.86,42.02) 102.65,40.8 102.65,38.92 99.27,35.55 99.27,35.25
  IN1 w0.142: 99.27,35.25 99.27,33.16 95.79,29.68 84.03,29.68 83.27,28.91 80.48,28.91 79.75,28.19 76.44,28.19 63.41,15.16 63.41,10 64.41,9.01 64.41,7.86 65.41,6.86 v1(66.3,6.86)
  BOTTOM w0.076: UC1.BB56 105.51,47.05 105.51,46.21 105.63,46.09 105.63,45.52 103.41,43.3 103.41,42.46 v1(103.86,42.02)
  BOTTOM w0.168: v1(66.3,6.86) 66.52,6.63 JDIMM1.110
DDR_A_CKE2: length 7.8
  BOTTOM w0.076: UC1.AW56 105.76,48.82 105.76,48.62 105.81,48.57 105.81,48.26 105.79,48.2 105.78,48.2 105.78,47.92 105.81,47.84 105.81,47.63 105.76,47.52 105.76,47.3 105.81,47.19 105.81,46.89 105.67,46.75 105.67,46.28 105.8,46.16 105.8,45.42 105.39,45.01 104.88,44.5 104.85,44.5 103.66,43.31 103.66,42.84 103.87,42.63 T3.1
DDR_A_CKE3: length 8
  BOTTOM w0.076: T4.1 102.94,41.66 102.94,43.29 105.3,45.66 105.3,45.95 105.12,46.14 105.12,47.22 105.14,47.27 105.14,47.27 105.28,47.63 105.28,47.92 105.55,48.18 UC1.AY56
DDR_A_CLK0: length 73.7
  IN1 w0.076: v1(106.96,50.55) 107.18,50.32 107.39,50.32 107.93,49.78 107.93,48.4 107.76,48.23 107.76,46.25 108.98,45.03 108.98,38.46 108.82,38.3 108.82,35.76 108.58,35.51 108.58,35.06 108.58,35.05 108.58,35.03
  IN1 w0.089: 108.58,35.03 108.58,29.1 102.22,22.73 102.22,22.48 102.29,22.41 102.29,22.01 102.01,21.73 101.62,21.73 101.54,21.81 101.29,21.81 101.12,21.63 101.12,21.38 101.19,21.31 101.19,20.91 100.91,20.63 100.52,20.63 100.44,20.71 100.19,20.71 100.02,20.53 100.02,20.28 100.09,20.21 100.09,19.81 99.81,19.53 99.42,19.53 99.34,19.61 99.09,19.61 98.42,18.94 84.16,18.94 83.6,18.38 80.12,18.38 75.95,14.22 75.95,12.72 75.72,12.49 75.72,11.96 76.03,11.65 76.03,11.04 76.52,10.54 76.52,10.18 76.33,9.99 75.94,9.99 75.9,10.03 75.66,10.03 v1(75.51,9.87)
  BOTTOM w0.094: UC1.AT53 107.26,50.85 v1(106.96,50.55) ; JDIMM1.137 73.27,12.12 73.36,12.03 73.36,11.68 75.01,10.03 75.35,10.03 v1(75.51,9.87)
DDR_A_CLK1: length 73.7
  IN1 w0.076: 107.89,35.17 107.89,35.19 107.89,35.2 107.89,35.67 108.36,36.14 108.36,38.57 108.53,38.74 108.53,44.72 107.13,46.12 107.13,48.15 106.52,48.76 106.52,50.09 106.27,50.34 106.12,50.34 v1(105.96,50.49)
  IN1 w0.089: v1(75.41,8.45) 75.23,8.28 75.07,8.28 74.99,8.36 74.99,9.9 74.78,10.1 74.78,11.26 74.99,11.46 74.99,12.39 74.78,12.6 74.78,13.38 75.27,13.87 75.27,14.57 79.8,19.09 83.34,19.09 83.88,19.63 98.15,19.63 107.89,29.37 107.89,35.17
  BOTTOM w0.094: JDIMM1.138 73.53,5.82 73.68,5.98 73.68,6.88 75.01,8.2 75.16,8.2 v1(75.41,8.45) ; UC1.AT55 106.09,50.49 105.96,50.49 v1(105.96,50.49)
DDR_A_CLK#0: length 73.8
  IN1 w0.076: 108.4,35.03 108.4,35.05 108.41,35.06 108.41,35.58 108.65,35.82 108.65,38.36 108.82,38.53 108.82,44.96 107.6,46.18 107.6,48.3 107.76,48.47 107.76,49.71 107.32,50.16 106.99,50.16 106.91,50.08 v1(106.91,49.87)
  IN1 w0.089: v1(75.51,10.53) 75.51,10.44 75.75,10.21 75.98,10.21 76.01,10.17 76.25,10.17 76.34,10.26 76.34,10.47 75.84,10.96 75.84,11.58 75.54,11.88 75.54,12.56 75.77,12.79 75.77,14.29 80.04,18.56 83.52,18.56 84.08,19.12 98.35,19.12 99.02,19.79 99.41,19.79 99.49,19.71 99.74,19.71 99.91,19.89 99.91,20.13 99.83,20.21 99.83,20.61 100.12,20.89 100.51,20.89 100.59,20.81 100.84,20.81 101.01,20.99 101.01,21.23 100.94,21.31 100.94,21.71 101.22,21.99 101.61,21.99 101.69,21.91 101.94,21.91 102.11,22.09 102.11,22.33 102.04,22.41 102.04,22.81 108.4,29.18 108.4,35.03
  BOTTOM w0.094: v1(106.91,49.87) 107.03,49.75 107.27,49.75 107.42,49.91 107.42,50.15 UC1.AU53 ; v1(75.51,10.53) 75.51,10.42 75.3,10.22 75.09,10.22 73.55,11.76 73.55,11.89 73.78,12.12 JDIMM1.139
DDR_A_CLK#1: length 73.7
  IN1 w0.076: v1(105.96,49.86) 105.96,49.99 106.14,50.17 106.21,50.17 106.36,50.02 106.36,48.69 106.96,48.08 106.96,46.05 108.36,44.65 108.36,38.8 108.2,38.64 108.2,36.21 107.72,35.74 107.72,35.2 107.71,35.19 107.71,35.17
  IN1 w0.089: v1(75.41,7.82) 75.41,7.9 75.21,8.1 75,8.1 74.81,8.29 74.81,9.82 74.6,10.03 74.6,11.33 74.81,11.54 74.81,12.32 74.59,12.53 74.59,13.46 75.09,13.95 75.09,14.64 79.72,19.27 83.27,19.27 83.8,19.81 98.08,19.81 107.71,29.44 107.71,35.17
  BOTTOM w0.094: JDIMM1.140 74.02,5.82 73.87,5.98 73.87,6.8 75.09,8.02 75.27,8.02 75.41,7.87 v1(75.41,7.82) ; UC1.AU55 106.2,50.2 105.96,49.96 v1(105.96,49.86)
DDR_A_CS#0: length 78.2
  IN1 w0.076: v1(111.49,49.87) 111.49,49.03 112.83,47.69 112.83,46.37 113.38,45.82 113.38,39.46 113.19,39.27 113.19,37.67
  IN1 w0.142: v1(80.7,9.38) 80.7,8.85 80.85,8.71 81.16,8.71 81.31,8.86 81.31,11.92 82.28,12.89 83.85,12.89 84.64,13.68 91.63,13.68 91.82,13.87 91.82,13.96 92.01,14.15 92.28,14.15 92.47,13.96 92.47,13.87 92.66,13.68 92.93,13.68 93.12,13.87 93.12,13.96 93.31,14.15 93.58,14.15 93.77,13.96 93.77,13.87 93.96,13.68 94.23,13.68 94.42,13.87 94.42,13.96 94.61,14.15 94.88,14.15 95.07,13.96 95.07,13.87 95.26,13.68 95.53,13.68 95.72,13.87 95.72,13.96 95.91,14.15 96.18,14.15 96.37,13.96 96.37,13.87 96.56,13.68 96.83,13.68 97.02,13.87 97.02,13.96 97.21,14.15 97.48,14.15 97.67,13.96 97.67,13.87 97.86,13.68 98.13,13.68 98.32,13.87 98.32,13.96 98.51,14.15 98.78,14.15 98.97,13.96 98.97,13.87 99.17,13.68 99.43,13.68 99.62,13.87 99.62,13.96 99.82,14.15 100.08,14.15 100.28,13.96 100.28,13.87 100.47,13.68 100.73,13.68 100.93,13.87 100.93,13.96 101.12,14.15 101.39,14.15 101.58,13.96 101.58,13.87 101.77,13.68 104.22,13.68 113.19,22.65 113.19,37.67
  BOTTOM w0.076: v1(111.49,49.87) UC1.AU45
  BOTTOM w0.168: JDIMM1.149 78.28,11.08 79.98,9.38 v1(80.7,9.38)
DDR_A_CS#1: length 79.2
  IN1 w0.076: v1(112.4,49.87) 112.4,49.67 113.98,48.09 113.98,40.97 114.08,40.88 114.08,37.67
  IN1 w0.142: v1(82.81,9.67) 82.28,10.2 82.28,11.65 82.67,12.05 84.55,12.05 85.1,12.59 104.65,12.59 105.35,13.29 107.26,13.29 109.86,15.89 111.89,15.89 114.08,18.08 114.08,18.45 113.89,18.64 112.67,18.64 112.53,18.78 112.53,19.15 112.67,19.29 113.89,19.29 114.08,19.48 114.08,19.75 113.89,19.94 112.97,19.94 112.78,20.13 112.78,20.4 112.97,20.59 113.89,20.59 114.08,20.78 114.08,37.67
  BOTTOM w0.076: v1(112.4,49.87) UC1.AU43
  BOTTOM w0.168: JDIMM1.157 80.28,11.83 82.44,9.67 v1(82.81,9.67)
DDR_A_D0: length 87.7
  IN1 w0.089: v1(93.62,52.95) 93.62,53.19 93.16,53.65 92.37,53.65 91.48,54.54 91.48,54.82 90.91,55.39 85.1,55.39 77.37,47.67 74.83,47.67 73.41,46.25 72.44,46.25 71.72,45.53 69.65,45.53 68.7,44.58 66.78,44.58 65.25,43.05 62.52,43.05 59.7,40.23 59.7,39.56 51.15,31.01 51.15,29.78 51.29,29.65 51.47,29.65 51.6,29.51 51.6,29.32 51.46,29.18 51.29,29.18 51.15,29.04 51.15,26.51 41.92,17.27 41.92,14.95 41.78,14.81 41.51,14.81 41.38,14.68 41.38,14.48 41.52,14.34 41.78,14.34 41.92,14.2 41.92,14.01 41.78,13.87 41.35,13.87 41.21,13.73 41.21,13.54 41.35,13.4 41.78,13.4 41.92,13.26 41.92,13.07 41.78,12.93 41.35,12.93 41.21,12.79 41.21,12.6 41.35,12.46 41.78,12.46 41.92,12.32 41.92,11.53 v1(41.37,10.99)
  BOTTOM w0.076: v1(93.62,52.95) 94.12,53.45 94.91,53.45 95.35,53.89 96.63,53.89 96.65,53.91 UC1.AL71
  BOTTOM w0.102: JDIMM1.7 40.78,11.58 v1(41.37,10.99)
DDR_A_D1: length 88.6
  IN1 w0.089: v1(95.52,52.97) 94.39,54.1 92.36,54.1 91.91,54.55 91.91,54.89 91.07,55.72 84.98,55.72 77.27,48.01 74.66,48.01 73.22,46.56 72.33,46.56 71.59,45.83 69.52,45.83 68.61,44.93 66.68,44.93 65.21,43.45 62.49,43.45 59.4,40.36 59.4,39.68 50.85,31.13 50.85,26.64 40.85,16.64 40.85,10.88 40.56,10.6 v1(40.28,10.6)
  BOTTOM w0.076: UC1.AL68 98.79,53.26 98.58,53.05 98.07,53.05 97.91,52.98 97.73,52.98 97.57,53.03 97.43,53.03 97.21,52.97 97.09,52.97 97.01,53 96.98,53.01 96.47,53.01 96.23,52.77 95.72,52.77 v1(95.52,52.97)
  BOTTOM w0.102: v1(40.28,10.6) 40.2,10.6 39.78,11.02 JDIMM1.3
DDR_A_D2: length 89.3
  IN1 w0.089: v1(45.56,10.61) 45.96,11 45.96,11.55 45.87,11.64 45.54,11.64 45.42,11.76 45.42,12.08 45.51,12.17 45.87,12.17 45.96,12.26 45.96,12.61 45.87,12.7 45.52,12.7 45.42,12.8 45.42,13.14 45.52,13.24 45.87,13.24 45.96,13.33 45.96,14.59 45.87,14.68 45.51,14.68 45.42,14.77 45.42,15.08 45.51,15.17 45.87,15.17 45.96,15.26 45.96,15.54 45.83,15.66 45.51,15.66 45.42,15.75 45.42,16.02 45.56,16.16 45.87,16.16 45.96,16.25 45.96,16.58 45.87,16.66 45.51,16.66 45.42,16.75 45.42,17.11 45.51,17.2 45.87,17.2 45.96,17.29 45.96,17.48 55.9,27.42 55.9,28.88 55.76,29.02 55.53,29.02 55.39,29.16 55.39,29.35 55.53,29.49 55.76,29.49 55.9,29.63 55.9,30.1 57.89,32.09 57.89,32.21 57.43,32.68 57.43,32.83 57.64,33.05 57.8,33.05 58.22,32.63 58.43,32.63 58.57,32.77 58.57,32.96 58.16,33.38 58.16,33.54 58.33,33.72 58.48,33.72 58.9,33.3 59.1,33.3 59.24,33.43 59.24,33.63 58.88,33.98 58.88,34.17 59.02,34.3 59.23,34.3 59.57,33.96 59.76,33.96 61.57,35.77 61.57,37.08 63.87,39.37 65.84,39.37 66.5,40.04 66.5,40.46 66.85,40.81 67.74,40.81 68.83,41.9 70.18,41.9 71.2,42.92 76.48,42.92 77.82,44.26 79.44,44.26 86.81,51.64 v1(89.72,51.64)
  BOTTOM w0.076: UC1.AN68 98.79,52.68 98.21,52.39 97.71,52.39 97.48,52.15 96.54,52.15 96.5,52.11 95.12,52.11 94.18,51.17 90.9,51.17
  BOTTOM w0.102: v1(45.56,10.61) 45.43,10.61 44.27,11.77 JDIMM1.21 ; v1(89.72,51.64) 90.18,51.17 90.9,51.17
DDR_A_D3: length 88.4
  IN1 w0.089: v1(43.53,7.94) 43.05,8.42 43.05,8.63 43.33,8.91 43.46,8.91 43.82,8.56 44,8.56 44.24,8.8 44.24,8.92 43.9,9.26 43.9,9.55 44.06,9.7 44.2,9.7 44.51,9.39 44.7,9.39 44.79,9.48 44.79,17.34 54.54,27.1 54.54,29.77 55.55,30.78 55.55,31.91 58.59,34.95 58.67,34.95 58.67,34.94 59.43,34.94 59.43,34.95 59.74,34.95 60.88,36.09 60.88,37.25 62.63,39 62.63,40.24 63.35,40.96 66.14,40.96 67.05,41.87 67.24,41.87 67.29,41.82 67.5,41.82 67.64,41.96 67.64,42.14 67.58,42.2 67.58,42.39 67.77,42.59 70.01,42.59 70.95,43.53 73.93,43.53 74.74,44.34 76.9,44.34 77.69,45.13 79.44,45.13 86.98,52.67 88.45,52.67 88.74,52.38 93.08,52.38 v1(93.49,51.97)
  BOTTOM w0.076: UC1.AN69 98.03,52.78 97.78,52.78 97.56,52.86 97.43,52.86 97.2,52.79 97.1,52.79 97.09,52.79 97.08,52.79 97.06,52.79 96.94,52.85 96.54,52.85 96.3,52.6 94.86,52.6 94.22,51.97 v1(93.49,51.97)
  BOTTOM w0.102: JDIMM1.16 43.03,7.43 v1(43.53,7.94)
DDR_A_D4: length 88.6
  IN1 w0.089: v1(41.5,7.94) 41.5,9.49 42.22,10.21 42.22,17.13 52.55,27.46 52.55,28.31 52.17,28.69 52.17,30.48 53.87,32.18 53.87,33.18 60.02,39.34 60.02,40.12 62.65,42.75 65.38,42.75 66.91,44.28 68.83,44.28 69.77,45.22 71.85,45.22 72.55,45.93 73.67,45.93 74.44,46.7 76.94,46.7 84.82,54.58 90.74,54.58 v1(92.37,52.94)
  BOTTOM w0.076: UC1.AL70 97.34,53.91 97.16,54.08 97.04,54.14 96.92,54.17 96.68,54.17 96.56,54.05 95.26,54.05 94.93,53.73 93.16,53.73 v1(92.37,52.94)
  BOTTOM w0.102: JDIMM1.4 40.03,6.47 v1(41.5,7.94)
DDR_A_D5: length 89.1
  IN1 w0.089: v1(41.5,6.67) 42.37,6.67 42.52,6.83 42.52,17 53.13,27.61 53.13,29.31 52.99,29.45 52.87,29.45 52.72,29.59 52.72,29.79 52.85,29.92 52.99,29.92 53.13,30.05 53.13,31.01 54.17,32.05 54.17,32.88 60.39,39.1 60.39,40.06 62.78,42.44 65.5,42.44 67.01,43.95 68.93,43.95 69.87,44.89 73.33,44.89 74.17,45.74 76.41,45.74 77.24,46.56 78.99,46.56 86.67,54.25 90.42,54.25 v1(91.66,53.01)
  BOTTOM w0.076: v1(91.66,53.01) 92.54,53.89 94.86,53.89 95.19,54.22 96.46,54.22 96.6,54.35 96.9,54.35 96.97,54.33 97.03,54.31 97.1,54.3 97.18,54.29 97.39,54.17 97.57,54.17 97.71,54.11 97.91,53.91 UC1.AL69
  BOTTOM w0.102: v1(41.5,6.67) 41.03,6.2 JDIMM1.8
DDR_A_D6: length 87.4
  IN1 w0.089: v1(45.56,9.34) 45.86,9.34 46.26,9.74 46.26,17.35 56.26,27.35 56.26,28.12 56.4,28.26 56.9,28.26 57.04,28.41 57.04,28.61 56.92,28.73 56.4,28.73 56.26,28.87 56.26,29.06 56.4,29.2 57.04,29.2 57.13,29.3 57.13,29.58 57.04,29.67 56.4,29.67 56.26,29.81 56.26,30.02 56.57,30.34 56.7,30.34 56.91,30.12 57.17,30.12 57.32,30.27 57.32,30.53 57.13,30.72 57.13,30.89 61.98,35.75 61.98,36.92 62.22,37.16 62.35,37.16 62.58,36.93 62.73,36.93 62.95,37.15 62.95,37.29 62.69,37.54 62.69,37.66 64.1,39.07 65.97,39.07 66.81,39.91 66.81,40.33 66.98,40.51 67.97,40.51 69.06,41.6 70.31,41.6 71.14,42.43 71.42,42.43 71.55,42.29 71.55,41.99 71.67,41.88 71.91,41.88 72.05,42.01 72.05,42.3 72.18,42.43 72.55,42.43 76.64,42.43 77.41,43.2 77.75,43.2 77.89,43.34 77.89,43.52 78.02,43.66 78.22,43.66 78.36,43.52 78.36,43.34 78.49,43.2 78.8,43.2 86.56,50.96 90.46,50.96 v1(91.1,51.59)
  BOTTOM w0.076: UC1.AN70 97.22,52.32 96.48,52.32 96.44,52.27 95.04,52.27 94.11,51.34 91.34,51.34 v1(91.1,51.59)
  BOTTOM w0.102: JDIMM1.17 43.27,12.13 45.18,10.22 45.18,9.72 v1(45.56,9.34)
DDR_A_D7: length 86.5
  IN1 w0.089: v1(43.68,6.82) 43.68,7.14 44.05,7.51 44.78,7.51 44.87,7.6 44.87,7.87 44.73,8 44.4,8 44.31,8.09 44.31,8.37 44.49,8.55 45.03,8.55 45.12,8.64 45.12,17.24 54.85,26.97 54.85,29.58 55.91,30.64 55.91,31.79 58.72,34.61 59.84,34.61 61.19,35.96 61.19,37.13 62.93,38.87 62.93,40.12 63.47,40.66 66.27,40.66 66.73,41.12 67.56,41.12 68.65,42.21 70.06,42.21 71.08,43.22 76.22,43.22 77.64,44.65 79.39,44.65 86.8,52.06 91.42,52.06 91.62,51.86 91.62,51.16 91.74,51.03 92.63,51.03 92.74,51.14 v1(92.74,51.87)
  BOTTOM w0.076: UC1.AN71 96.51,52.58 96.37,52.44 94.95,52.44 94.07,51.56 93.05,51.56 v1(92.74,51.87)
  BOTTOM w0.102: v1(43.68,6.82) 44.03,6.47 JDIMM1.20
DDR_A_D8: length 82.4
  IN1 w0.089: v1(89.46,49.38) 86.83,49.38 81.58,44.13 81.58,43.93 82.03,43.49 82.03,43.29 81.89,43.15 81.7,43.15 81.25,43.6 81.06,43.6 80.92,43.46 80.92,43.27 81.33,42.85 81.33,42.66 81.2,42.52 81,42.52 80.59,42.93 80.39,42.93 79.29,41.83 77.36,41.83 77.05,41.53 74.12,41.53 73.6,41 72.42,41 72.32,40.9 70.9,40.9 69.27,39.27 67.45,39.27 66.34,38.16 66.06,38.16 63.49,35.6 63.11,35.6 59.73,32.22 59.73,29.54 47.45,17.26 47.45,13.83 47.2,13.58 47.2,9.22 46.21,8.23 46.21,7.44 v1(45.56,6.8)
  BOTTOM w0.076: UC1.AR70 97.34,51.55 97.07,51.82 96.68,51.82 96.64,51.78 95.4,51.78 94.45,50.83 92.29,50.83 91.53,50.07
  BOTTOM w0.102: v1(45.56,6.8) 46.03,6.33 JDIMM1.28 ; 91.53,50.07 90.78,49.32 89.52,49.32 v1(89.46,49.38)
DDR_A_D9: length 83.4
  IN1 w0.089: v1(45.56,8.07) 46.87,9.37 46.87,13.74 47.1,13.96 47.1,17.34 58.14,28.38 58.14,28.5 57.72,28.91 57.72,29.13 57.9,29.31 58.09,29.31 58.48,28.92 58.68,28.92 59.23,29.47 59.23,30.76 58.73,31.26 58.73,31.65 64.33,37.25 64.33,37.79 65.01,38.47 66.21,38.47 67.39,39.64 68.42,39.64 68.71,39.93 68.71,40.14 69.02,40.45 70.02,40.45 70.77,41.2 72.17,41.2 72.8,41.83 76.93,41.83 77.32,42.23 79.09,42.23 87.04,50.17 v1(90.53,50.17)
  BOTTOM w0.076: v1(90.53,50.17) 91.01,50.17 91.84,51.01 94.36,51.01 95.3,51.94 96.57,51.94 96.61,51.99 97.48,51.99 97.71,51.75 98.26,51.75 UC1.AR68
  BOTTOM w0.102: JDIMM1.24 45.03,6.44 44.97,6.49 44.97,7.47 v1(45.56,8.07)
DDR_A_D10: length 80.7
  IN1 w0.089: v1(93.83,48.73) 93.83,48.29 93.48,47.95 93.48,44.31 89.06,39.89 78.21,39.89 77.08,38.77 72.93,38.77 72.59,38.42 71.35,38.42 69.96,37.03 67.95,37.03 67.14,36.23 66.92,36.23 63.97,33.28 63.97,33.28 62.35,31.66 62.35,29.4 50.22,17.27 50.22,14.17 49.95,13.89 49.95,10.75 49.71,10.51 49.71,8.85 48.28,7.42 48.28,7.23 48.46,7.06 48.61,7.06 49.5,7.94 v1(50.01,7.94)
  BOTTOM w0.076: UC1.AU71 96.73,50.12 95.72,50.12 94.33,48.73 v1(93.83,48.73)
  BOTTOM w0.102: JDIMM1.38 48.52,6.46 v1(50.01,7.94)
DDR_A_D11: length 82.4
  IN1 w0.089: v1(94.25,49.99) 94.25,48.18 93.89,47.82 93.89,44.28 89.19,39.59 88.93,39.59 78.33,39.59 77.21,38.46 73.05,38.46 72.71,38.12 72.18,38.12 70.79,36.73 68.07,36.73 67.27,35.92 67.05,35.92 64.28,33.16 64.28,33.16 62.73,31.61 62.73,29.35 50.58,17.19 50.58,14.09 50.25,13.77 50.25,10.62 50.04,10.41 50.04,8.9 50.66,8.28 50.66,7.69 50.37,7.4 49.39,7.4 49.25,7.26 49.25,7.03 49.38,6.9 v1(49.89,6.9)
  BOTTOM w0.076: v1(94.25,49.99) 94.59,49.99 95.88,51.28 96.45,51.28 96.61,51.12 96.98,51.12 97.01,51.14 97.09,51.17 97.21,51.17 97.43,51.1 97.57,51.1 97.73,51.16 98.32,51.16 98.34,51.18 98.58,51.18 98.79,50.98 UC1.AU68
  BOTTOM w0.102: v1(49.89,6.9) 49.52,6.54 JDIMM1.42
DDR_A_D12: length 81.2
  IN1 w0.089: v1(47.85,11.11) 47.98,11.11 48.29,11.43 48.29,12 48.21,12.08 47.77,12.08 47.69,12.17 47.69,12.47 47.77,12.56 48.15,12.56 48.24,12.65 48.24,12.98 48.15,13.07 47.76,13.07 47.67,13.16 47.67,13.52 47.76,13.61 48.19,13.61 48.28,13.7 48.28,15.61 48.19,15.7 47.88,15.7 47.79,15.79 47.79,16.22 47.89,16.32 48.2,16.32 48.29,16.41 48.29,16.72 48.2,16.81 47.92,16.81 47.83,16.9 47.83,17.21 60.08,29.46 60.08,32.14 62.96,35.02 63.37,35.02 66.21,37.86 66.47,37.86 67.58,38.97 69.4,38.97 71.03,40.59 72.45,40.59 72.55,40.7 73.72,40.7 74.25,41.22 77.18,41.22 77.49,41.53 83.64,41.53 83.77,41.67 83.77,42.18 83.91,42.32 84.11,42.32 84.24,42.18 84.24,41.67 84.38,41.53 85.33,41.53 85.86,42.06 88.88,42.06 91.23,44.41 91.23,48.47 92.08,49.33 v1(92.08,49.88)
  BOTTOM w0.076: UC1.AR71 96.78,51.61 95.5,51.61 94.52,50.63 92.65,50.63 92.08,50.06 v1(92.08,49.88)
  BOTTOM w0.102: v1(47.85,11.11) 47.34,11.11 46.27,12.18 JDIMM1.29
DDR_A_D13: length 82.3
  IN1 w0.089: v1(92.74,50.06) 92.74,49.56 91.66,48.47 91.66,44.38 89.03,41.75 86.11,41.75 85.58,41.22 77.6,41.22 77.31,40.92 74.38,40.92 73.85,40.39 72.68,40.39 72.57,40.29 72.04,39.75 70.61,39.75 69.53,38.66 69.39,38.66 69.39,38.66 67.7,38.66 66.59,37.55 66.33,37.55 63.49,34.71 63.09,34.71 60.53,32.15 60.53,31.46 60.8,31.19 60.8,29.74 48.6,17.54 48.6,11.28 48.39,11.07 48.39,9.41 48.12,9.14 47.82,9.14 47.68,9.28 47.68,9.68 v1(47.85,9.84)
  BOTTOM w0.076: UC1.AR69 98.03,51.35 97.78,51.35 97.56,51.28 97.43,51.28 97.2,51.34 97.1,51.34 97.09,51.35 97.08,51.34 97.06,51.34 96.94,51.29 96.68,51.29 96.52,51.45 95.78,51.45 95.2,50.87 94.78,50.45 93.13,50.45 v1(92.74,50.06)
  BOTTOM w0.102: JDIMM1.25 45.27,12.16 47.59,9.84 v1(47.85,9.84)
DDR_A_D14: length 81.1
  IN1 w0.089: v1(94.42,47.44) 94.42,44.38 89.32,39.28 88.81,39.28 78.46,39.28 77.34,38.16 73.18,38.16 72.84,37.81 72.31,37.81 70.86,36.36 69.76,36.36 69.27,35.87 69.15,35.87 68.66,36.36 68.38,36.36 68.19,36.17 68.19,35.88 68.6,35.47 68.6,35.34 68.35,35.09 68.17,35.09 67.61,35.64 67.39,35.64 67.15,35.4 67.15,35.28 67.25,35.17 67.25,35.02 67.06,34.82 66.93,34.82 66.75,35 66.63,35 66.43,34.8 66.43,34.64 66.59,34.48 66.59,34.35 65.9,33.66 65.77,33.66 65.58,33.85 65.45,33.85 65.22,33.61 65.22,33.49 65.41,33.3 65.41,33.17 65.19,32.95 65.06,32.95 64.86,33.15 64.74,33.15 64.52,32.93 64.52,32.8 64.72,32.6 64.72,32.48 64.49,32.25 64.37,32.25 64.18,32.44 64,32.44 63.74,32.19 63.74,32 64.51,31.24 64.51,30.9 64.26,30.65 63.96,30.65 63.59,31.03 63.39,31.03 63.25,30.89 63.25,30.7 63.79,30.17 63.79,29.97 50.93,17.12 50.93,14 50.56,13.63 50.56,10.18 v1(50.56,10.18)
  BOTTOM w0.076: v1(94.42,47.44) 94.42,48.57 95.8,49.95 97.21,49.95 UC1.AU70
  BOTTOM w0.102: v1(50.56,10.18) 49.27,11.46 JDIMM1.41
DDR_A_D15: length 81.6
  IN1 w0.089: v1(50.64,9.08) 50.45,9.27 50.45,9.56 50.54,9.65 50.97,9.65 51.06,9.74 51.06,10.32 50.86,10.52 50.86,13.44 51.24,13.81 51.24,16.99 65.36,31.12 65.36,31.36 64.8,31.92 64.8,32.13 65.2,32.53 65.38,32.53 65.59,32.33 65.81,32.33 65.98,32.49 65.98,32.72 65.75,32.95 65.75,33.08 65.97,33.3 66.16,33.3 66.58,32.88 66.71,32.88 66.99,33.16 66.99,33.26 66.54,33.71 66.54,33.87 67.42,34.75 68.58,34.75 69.89,36.06 71.86,36.06 71.97,36.17 71.97,36.37 71.84,36.5 71.84,36.7 71.98,36.83 72.17,36.83 72.31,36.7 72.5,36.7 72.64,36.84 72.64,37.03 72.5,37.17 72.5,37.36 72.64,37.5 73.3,37.5 73.65,37.85 77.74,37.85 78.87,38.98 88.68,38.98 89.47,38.98 94.84,44.35 v1(94.84,48.43)
  BOTTOM w0.076: v1(94.84,48.43) 94.84,48.76 95.85,49.77 97.29,49.77 97.37,49.85 97.55,49.85 97.93,50.23 UC1.AU69
  BOTTOM w0.102: v1(50.64,9.08) 48.27,11.45 JDIMM1.37
DDR_A_D16: length 60.9
  IN4 w0.076: v1(101.05,55.8) 100.51,56.34 98.77,56.34 96.45,54.02 96.45,52.52 95.71,51.78
  IN4 w0.089: v1(90.01,6.92) 90.01,7.01 88.52,8.5 88.52,12.32 87.02,13.83 87.02,15.11 88.88,16.97 88.88,37.2 91.13,39.45 91.13,41.51 93.02,43.4 93.02,47.19 94.82,48.99 94.82,49.94 95.06,50.18 95.06,51.14 95.71,51.78
  BOTTOM w0.076: v1(101.05,55.8) UC1.AF65
  BOTTOM w0.102: v1(90.01,6.92) 89.53,6.44 JDIMM1.194
DDR_A_D17: length 59.6
  IN4 w0.076: 96.67,51.43 97.1,51.86 97.1,53.65 98.82,55.38 101.27,55.38 v1(101.69,55.8)
  IN4 w0.089: 96.67,51.43 96.67,50.58 95.7,49.61 95.7,47.25 93.93,45.48 93.93,42.74 92.21,41.02 92.21,38.61 92.05,38.45 91.71,38.45 91.55,38.29 91.55,38.06 91.71,37.9 92.05,37.9 92.21,37.74 92.21,37.51 92.05,37.35 91.71,37.35 91.55,37.19 91.55,36.97 91.71,36.81 92.05,36.81 92.21,36.65 92.21,35.99 91.97,35.74 91.74,35.74 91.28,36.2 91.06,36.2 90.9,36.04 90.9,35.81 91.35,35.35 91.35,35.13 91.19,34.97 90.97,34.97 90.51,35.43 90.28,35.43 90.12,35.27 90.12,35.04 90.58,34.58 90.58,34.36 89.92,33.7 89.92,16.4 89.19,15.67 89.19,13.56 89.59,13.16 89.59,11.28 v1(89.99,10.89)
  BOTTOM w0.076: v1(101.69,55.8) UC1.AF64
  BOTTOM w0.102: JDIMM1.195 89.78,11.1 v1(89.99,10.89)
DDR_A_D18: length 60.2
  IN4 w0.076: v1(101.05,53.97) 100.52,53.43 99.45,53.43 98.94,52.92 98.94,51.7 97.84,50.6 97.84,49.24 97.44,48.84 97.44,46.4 97.03,46 97.03,45.58
  IN4 w0.089: v1(93.59,8.18) 92.92,8.86 92.92,11.15 93.08,11.31 93.39,11.31 93.55,11.47 93.55,11.7 93.39,11.86 93.08,11.86 92.92,12.02 92.92,12.24 93.08,12.4 93.39,12.4 93.55,12.56 93.55,12.79 93.39,12.95 93.08,12.95 92.92,13.11 92.92,13.33 93.08,13.49 93.39,13.49 93.55,13.65 93.55,13.88 93.39,14.04 93.08,14.04 92.92,14.2 92.92,14.43 93.08,14.59 93.39,14.59 93.55,14.75 93.55,14.97 93.39,15.13 93.08,15.13 92.92,15.29 92.92,15.52 93.08,15.68 93.39,15.68 93.55,15.84 93.55,16.06 93.39,16.23 93.08,16.23 92.92,16.39 92.92,16.61 93.08,16.77 93.39,16.77 93.55,16.93 93.55,17.39 93.39,17.55 93.08,17.55 92.92,17.71 92.92,17.94 93.08,18.1 93.39,18.1 93.52,18.23 93.52,30.29 94.7,31.47 94.7,38.71 97.03,41.04 97.03,45.58
  BOTTOM w0.076: v1(101.05,53.97) 101.02,54.01 UC1.AK65
  BOTTOM w0.102: v1(93.59,8.18) 92.03,6.62 JDIMM1.204
DDR_A_D19: length 61.4
  IN4 w0.076: 95.71,45.27 96.06,45.63 96.06,46.17 96.91,47.01 96.91,49.09 97.25,49.43 97.25,51.02 97.73,51.5 97.73,52.51 99.36,54.13 99.42,54.13 99.63,54.35 101.31,54.35 v1(101.69,53.97)
  IN4 w0.089: v1(92.17,9.34) 91.39,10.11 91.39,15.26 91.39,15.26 91.39,26.71 91.55,26.87 92.15,26.87 92.31,27.03 92.31,27.26 92.15,27.42 91.59,27.42 91.48,27.53 91.48,27.85 91.59,27.96 92.15,27.96 92.31,28.12 92.31,28.35 92.15,28.51 91.59,28.51 91.48,28.62 91.48,28.94 91.6,29.06 92.15,29.06 92.31,29.22 92.31,29.44 92.15,29.6 91.6,29.6 91.47,29.73 91.47,30.02 91.6,30.15 92.15,30.15 92.31,30.31 92.31,30.53 92.15,30.69 91.65,30.69 91.47,30.88 91.47,31.27 91.68,31.48 92.65,31.48 93.59,32.42 93.59,39.4 95.31,41.11 95.31,44.87 95.71,45.27
  BOTTOM w0.076: v1(101.69,53.97) UC1.AK64
  BOTTOM w0.102: v1(92.17,9.34) 91.66,9.84 91.66,11.62 91.78,11.73 JDIMM1.203
DDR_A_D20: length 60.2
  IN4 w0.076: v1(100.42,55.8) 100.04,56.18 98.96,56.18 96.67,53.89 96.67,52.28 95.71,51.31
  IN4 w0.089: v1(89.88,8.22) 89.39,8.22 88.91,8.71 88.91,12.5 87.53,13.87 87.53,15.09 89.21,16.76 89.21,37.04 91.47,39.3 91.47,41.42 93.32,43.27 93.32,45.76 94.9,47.34 94.9,47.85 95.23,48.18 95.23,49.9 95.45,50.12 95.45,51.05 95.71,51.31
  BOTTOM w0.076: v1(100.42,55.8) UC1.AF66
  BOTTOM w0.102: v1(89.88,8.22) 89.88,8.24 88.7,7.06 88.7,6.5 88.53,6.33 JDIMM1.190
