# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.2V_MEM_CPUCLK: length 6.6
  TOP w0.076: CC297.1 114.06,54.36 113.8,54.63 v2(113.8,54.98)
  TOP w0.254: v1(115.14,52.41) 115.14,52.79 114.07,53.87 CC297.1 113.56,54.37 112.79,54.37 RC231.1
  BOTTOM w0.254: v1(115.14,52.41) 115.14,53 UC1.AM40
+1.8V_3.3V_ALW_VTR3: length 108.6
  TOP w0.254: 307.66,75.39 305.76,75.39 305.49,75.13 UE1.N5
  TOP w0.305: RE549.1 v1(309.31,68.28)
  IN2 w0.508: v1(269.77,75.77) 269.77,86.13 272.04,88.41 272.43,88.41 274.9,90.88 279.71,90.88 280.69,89.91 282.03,89.91 282.54,90.41 282.54,91.39 283.38,92.23 284.42,92.23 287.58,95.39 303.01,95.39 303.69,94.71 306.12,94.71 307.35,93.49 317.79,93.49 319.79,91.48 319.79,89.54 319.17,88.91 319.17,74.13 317.65,72.61 314.62,72.61 314.12,72.12 312.89,72.12 312.24,72.78 312.24,74.5 v1(311.86,74.88)
  IN3 w0.254: v1(309.31,68.28) 310.22,69.18 310.22,70.07 310.04,70.25 310.04,74.54 310.37,74.88 v1(311.86,74.88)
  BOTTOM w0.102: v2(270.32,75.67) 270.22,75.77 v1(269.77,75.77)
  BOTTOM w0.508: RE340.2 v1(269.77,75.77)
+1.8V_PGPPF: length 17.7
  TOP w0.381: RC304.2 144.2,59.89 143.35,59.89 141.01,57.55 138.24,57.55 138.24,57.55 137.8,57.55 137.8,57.55 133.32,57.55 133.31,57.56 132.86,57.56 132.85,57.55 131.48,57.55 v2(131.22,57.3) 131.07,57.3 130.84,57.52 130.21,57.52 130.06,57.67 129.41,57.67 129.03,57.29 v1(129.03,57.15)
  BOTTOM w0.254: v1(129.03,57.15) UC1.AF16
+1.8V_PRIM: length 260.1
  TOP w0.127: v1(255.19,39.35) v3(255.19,40.25)
  TOP w0.381: v1(148.04,59.58) 148.4,59.95 CC101.1 CC100.1 147.68,60.7
  TOP w0.508: RC313.1 145.75,69.79 146.13,69.41 v1(146.13,67.61) ; RC212.1 v1(155.58,56.66) ; 147.68,60.7 147.38,60.7 146.26,59.58 RC304.1
  IN2 w1.016: 122.64,100.71 133.31,100.71 133.84,101.24 136.15,101.24 136.91,102 142.9,102 143.77,101.13 143.77,98.63 148.38,94.02 158.47,94.02 160.24,92.25 160.24,81.62 163.05,78.81 166.63,78.81 176.7,68.73 176.7,55.34 ; 122.64,100.71 v1(122.64,100.7) ; 122.64,100.71 v1(122.01,100.71)
  IN3 w0.508: v1(146.13,67.61) 146.13,66.26 144.02,64.15 141.04,64.15 139.98,63.1 139.98,60.14 ; 238.87,17.32 241.38,17.32 240.18,16.12 240.18,15.65 238.54,14.01 238.13,14.42 238.13,16.58 238.87,17.32
  IN3 w1.016: 164.58,50.91 165.6,49.89 167.21,49.89 168.41,48.7 168.41,44.37 169.35,43.43 170.26,43.43 180.85,32.83 180.85,30.63 ; 238.54,14.01 236.35,11.83 227.97,11.83 ; 261.7,25.93 260.76,25.93 259.42,24.58 251.67,24.58 250.14,23.06 247.09,23.06 241.38,17.34 241.38,17.32 ; 157.21,55.89 159.64,53.46 162.38,53.46 ; 185.12,29.02 185.18,29.08 185.8,29.08 186.41,28.48 188.78,28.48 189.74,27.51 191.39,27.51 195.53,23.38 195.53,20.81 196.54,19.79 197.84,19.79 199.02,20.98 203.26,20.98 207.37,16.87 208.04,16.87 209.22,15.68 209.22,15.03 210.27,13.99 211.62,13.99 213.02,12.59 213.8,12.59
  BOTTOM w0.203: v1(139.08,58.91) UC1.AA1
  BOTTOM w0.508: v1(151.97,56.6) 151.95,56.62 RC234.1
  BOTTOM w1.016: 255.17,38.07 255.17,32.73 258.22,29.67 261.75,29.67 263.02,28.4 263.02,27.2 ; 164.28,53.56 173.74,53.56 174.89,54.71
  vias: v1(163.34,54.07) v1(163.34,53.47) v1(175.76,55.08) v1(175.81,55.75) v1(254.78,38.87) v1(263.07,26.03) v1(263.53,26.46) v1(272.16,51.93) v1(272.69,51.66) v1(310.9,73.68) v1(310.9,73.04)
+1.8V_RUN: length 173.6
  TOP w0.508: v1(264.34,27.15) 264.56,26.93 v1(264.56,24.28) ; RC362.2 RC363.2 149.23,55.64 v1(149.61,55.26) ; CA66.1 272.62,43.91 272.06,43.35 271.1,43.35 269.17,41.42 269.17,40.48 v1(266.63,37.94)
  IN3 w0.508: v1(149.61,55.26) 150.63,54.24 153.93,54.24 154.2,53.98 156.82,53.98 158.46,52.34 159.08,52.34 160.38,51.04 160.38,50.13 161.9,48.61 161.9,47.69 163.61,45.99 165.11,45.99 170.74,40.35 170.74,38.37 172.39,36.72 175.7,36.72 179.84,32.58 179.84,29.48 182.12,27.2 183.19,27.2 184.12,26.27 186.28,26.27 187.06,25.49 191.82,25.49 194.39,22.93 194.39,20.1 195.81,18.68 198.5,18.68 198.89,19.07 201.3,19.07 202,18.37 204.13,18.37 209.74,12.76 209.74,12.09 212.06,9.77 217.01,9.77 217.84,8.94 235.64,8.94 248.43,21.74 250.86,21.74 251.47,22.34 256.14,22.34 257.21,23.41 261.47,23.41 262.34,24.28 v1(264.56,24.28)
  BOTTOM w0.508: v1(266.63,37.94) 264.34,35.65 v1(264.34,27.15)
  vias: v1(284.74,42.27) v1(284.76,41.67) v1(302.33,44.6) v1(302.96,44.6) v3(276.99,43.83)
+1.8V_RUN_AUDIO:
  vias: v1(302.27,43.17) v1(302.25,37.99) v1(302.8,38.22) v1(302.86,43.17) v2(301.45,42.66)
+1.8V_RUN_CARD: length 19.6
  IN4 w0.762: 10.67,62.18 14.4,62.18 18.38,58.2 24.12,58.2 25.15,57.17 25.15,54.27 25.29,54.13
  vias: v1(6.1,62.17) v1(6.1,61.59) v1(9.4,61.68) v1(10.04,61.68) v1(25.41,53.21) v3(9.72,61.04)
+1.8V_RUN_UZ8: length 0.7
  BOTTOM w0.127: v1(271.66,48.85) v2(271.66,49.51)
+1.8VALWP: length 8.4
  TOP w0.254: 119.69,103.25 119.22,103.25 118.58,103.88 118.58,108.36 v3(118.98,108.75) 120.03,108.75 PR501.1 PC503.1
+1VALWP: length 11.5
  BOTTOM w0.254: 183.9,83.53 186.25,85.88 186.25,92.78 PC307.1 185.07,93.1 PR306.1
  vias: v1(182.63,83.46) v1(182.63,82.82) v1(182.63,82.19) v1(182.63,81.55) v1(182.63,80.92) v3(181.89,83.05)
+1VALWP_B+:
  vias: v1(178.52,98.19) v1(178.52,97.6) v1(178.52,97.02) v2(176.61,95.6)
+1VS_VCCIOP: length 14.5
  TOP w0.254: 144.09,104.79 145.67,104.79 145.99,105.11 v2(145.99,105.99) 145.99,107.37 PR421.1 ; PU401.1 140.48,107.87 140.16,107.55 v1(139.98,107.55)
  TOP w0.508: PC426.1 v1(143.93,105.75)
  IN1 w0.254: v1(139.98,107.55) 139.98,107.99 140.25,108.25 143.29,108.25 143.93,107.61 v1(143.93,105.75)
  BOTTOM w0.508: PC407.1 v1(141.67,103.52) ; PC426.1 v1(143.93,105.75)
+2.5V_MEM:
  vias: v1(105.72,9.97) v1(106.3,9.97) v1(106.89,9.97) v1(109.89,11.02) v1(109.89,10.43) v1(109.89,9.85) v1(186.41,10.73) v1(186.77,11.27) v1(187.21,10.57) v1(187.61,11.06) v1(187.67,10.12) v3(187.97,10.59)
+2.5V_VIN: length 1.3
  TOP w0.102: v2(196.02,7.9) 196.55,7.37 196.55,6.84
+3.3V_1.8V_ESPI: length 75.1
  TOP w0.254: RC21.2 137.42,38.73 137.42,37.14 137.63,36.94 137.63,33.23 139.04,31.82 140.64,31.82 142.93,29.53 145.83,29.53 146.61,28.75 v2(167.82,28.75) 171.35,28.75 172.15,29.55 v1(172.15,30.24)
  IN2 w0.254: v1(158.27,53.49) 158.09,53.31 158.09,47.83 161.72,44.21 164.34,44.21 164.66,43.9 166.61,43.9 169.47,41.03 169.47,39.87 170.13,39.21 170.13,32.66 171.23,31.56 171.43,31.56 172.15,30.84 v1(172.15,30.24)
+3.3V_1.8V_PGPPA: length 1.3
  TOP w0.508: v1(129.82,53.71) 129.86,53.66 RC551.2
  BOTTOM w0.254: UC1.AK15 129.41,54.21 v1(129.82,53.71)
  vias: v1(141.7,49.28) v1(142.05,49.78) v1(154.08,53.08) v1(154.69,52.98) v2(154.98,53.68)
+3.3V_1.8V_PGPPG: length 18.4
  TOP w0.508: v1(149.66,56.33) 149.78,56.33 RC235.2
  IN3 w0.508: 136.5,55.47 139.32,55.47 139.51,55.66 142.89,55.66 143.01,55.77 145.34,55.77 146.54,56.96 149.15,56.96 149.66,56.46 v1(149.66,56.33)
  BOTTOM w0.127: v2(149.06,56.63) 149.3,56.63 149.6,56.33 v1(149.66,56.33)
  BOTTOM w0.254: UC1.AD15 129.67,57.24 v1(129.67,57.15)
  BOTTOM w0.381: v1(149.66,56.33) 149.95,56.62 RC234.2 150.54,56.86 CC127.1 CC126.1
+3.3V_ALW: length 408.3
  TOP w0.254: v1(124.27,112.1) 124.27,112.92 124.51,113.16 PR418.1 PR417.1 ; v1(43.52,43.05) 44.66,43.05 46.63,45.02 48.17,45.02 v1(48.84,45.68) ; PR404.1 136.77,108.68 v1(136.77,108.68) ; JKBTP1.15 213.53,15.65 214.28,14.9 214.28,14.52 214.51,14.29 215.02,14.29 215.27,14.04 CZ91.1 ; JLED1.6 286.9,50.64 286.34,50.08 286.01,50.08 284.26,48.33 284.26,46.98 283.04,45.76 282.42,45.76 281.91,45.25 ; RZ8.1 217.86,10.25 v1(218.57,9.55) ; PR107.1 153.01,116.08 v1(152.41,116.08) ; RZ9.1 v1(217.05,11.7)
  TOP w0.305: RE525.2 RE524.2 282.44,75.21 283.47,74.19 RE69.1 284.41,74.43 284.8,74.82 v1(285.4,74.82) ; v1(291.66,87.58) 291.66,87.03 UE4.5
  TOP w0.381: UZ6.5 137.5,29.68 137.5,30.36 137.89,30.75 CZ82.1 138.05,30.18 v1(138.1,30.14) ; RE303.2 RE302.2 290.81,74.26 v1(291.37,74.82) ; 267.98,64.85 267.98,64.15 v1(267.75,63.92) ; RE84.2 301.07,93.69 301.45,94.07 301.45,94.61 v1(301.45,94.62) ; v1(274.12,48.63) 274.66,48.63 276.9,46.39 277.51,46.39 277.91,45.99 277.91,45.53 279.63,43.81 280.92,43.81 281.91,44.8 281.91,45.27 281.21,45.97 CZ93.1 279.93,45.98 UZ10.5 ; CE53.1 307.73,92.42 UE3.5 ; v1(295.58,67.1) 296,67.52 RE362.2 296.22,68.2 RE11.2 ; v1(306.58,85.77) RE35.2 ; RE35.2 306.6,85.04 RE25.1 ; RE35.2 RE38.2 ; v1(31.25,34.18) PR1233.2 PR1231.2 ; RE365.2 298.42,84.74 RE5.2 298.52,85.02 298.86,85.36 v1(299.14,85.36) 299.32,85.18 RE10.2 ; UE5.5 305.39,92.22 CE52.1 ; PR1230.2 v1(35.06,33.99) ; CZ91.1 215.04,13.75 v1(214.63,13.75)
  TOP w0.457: RE63.2 RE83.2 CE61.1 303.28,88.42 v1(303.28,88.79) 303.14,88.93 RE91.2 ; v1(310.95,70.35) 310.42,70.88 RE43.2 RE37.2 RE561.2 ; v1(38.93,79.77) 38.44,79.77 RT68.2 ; RE300.2 300.61,90.06 301,90.44 v1(301,90.7)
  TOP w0.508: RZ518.1 182.86,13.12 183.37,12.62 184.21,12.62 184.71,13.12 184.71,13.73 185.79,14.81 189.47,14.81 189.49,14.83 ; PR1225.1 v1(20.33,30.88) ; PR1259.2 24.83,30.82 v1(24.77,30.75) ; v1(176.64,24.78) 178.69,24.78 182.1,28.19 182.1,29.96 ; v1(83.76,93.3) 84.21,92.85 v3(85.01,92.85) 87.86,90 89.41,90 91.38,88.03 v1(91.38,85.17) ; RE301.2 292.33,83.72 v1(292.71,84.1) ; v1(128.96,25.48) CZ104.1 128.98,26.38 UZ34.5 ; PR1224.2 v1(22.23,39.13) ; PR933.1 v1(15.54,10.77) ; 178.15,35.67 178.57,36.09 179.39,36.09 179.96,35.51 179.96,34.4 180.61,33.75 RC432.1 ; v1(138.1,30.14) 138.1,29.26 137.63,28.79 135.79,28.79 135.13,29.44 RC68.2 ; v1(305.04,85.45) 304.81,85.22 RE8.2 RE79.2 ; RC214.2 136.67,41.92 v1(137.1,41.48) ; v1(309.27,92.16) 309,92.42 CE53.1 ; PR1235.2 PR1234.2 32.44,41.23 v2(33.15,41.23) 34.17,41.23 v1(34.3,41.1) PR1232.2 ; v1(63.4,93.46) 63.68,93.74 PR4.2 ; v1(289.82,66.82) 290.28,67.28 RE92.2 ; RE505.2 v1(270.41,91.93) ; RZ369.1 174.68,43.85 175.52,43.01 175.52,40.66 v1(175.81,40.37) ; v1(305.39,90.75) CE52.1 ; RE68.2 v1(295.92,58.95) ; PR1.1 v1(17.48,2.56)
  IN1 w0.254: v1(34.3,41.1) 37.09,43.9 42.66,43.9 v1(43.52,43.05)
  IN1 w0.381: v1(291.66,87.58) 291.66,85.16 v1(292.71,84.1)
  IN1 w0.508: v1(17.48,2.56) 16.27,3.77 16.27,6.32 16.9,6.94 16.9,9.04 16.41,9.52 16.41,9.98 15.61,10.77 v1(15.54,10.77) ; v1(140.47,92.37) 140.47,89.48 138.05,87.07 138.05,86.12 138.82,85.36 138.82,83.97 v1(138.92,83.86) ; v1(65.26,101.39) 65.07,101.2 v1(65.07,98.15) 65.07,93.97 64.56,93.46 v1(63.4,93.46) ; v1(214.63,13.75) 214.03,13.15 214.03,12.21 214.53,11.7 v1(217.05,11.7) ; v1(91.38,85.17) 92.23,84.32 97.36,84.32 v1(97.68,84.65)
  IN2 w0.508: v1(291.37,74.82) 290.87,74.82 288.65,72.61 288.01,72.61 287.28,71.87 287.28,68.56 288.18,67.66 289.31,67.66 289.82,67.15 v1(289.82,66.82) ; v1(295.92,58.95) 296.45,58.95 298.41,60.91 298.41,62.09 299.52,63.21 299.52,64.89 v1(299.81,65.18)
  IN3 w0.508: v1(137.1,41.48) 134.78,39.17 133.86,39.17 131.78,37.09 131.78,30.75 132.94,29.59 135.47,29.59 136.7,30.82 137.42,30.82 138.1,30.14 v1(138.1,30.14) 135.24,27.28 130.76,27.28 130.11,26.63 v1(128.96,25.48) 128.96,25.11 131.27,22.8 172.76,22.8 174.26,24.3 176.15,24.3 v1(176.64,24.78)
  IN4 w0.508: v1(35.57,28.72) 37.83,26.46 37.83,12.69 36.43,11.3 27.66,11.3 26.02,12.94 17.7,12.94 v1(15.54,10.77) ; v1(182.19,30.94) 182.19,35.27 181.62,35.84 180.55,35.84 180.4,35.69 179.71,35.69 176.03,39.38 176.03,40.15 v1(175.81,40.37) ; v1(295.58,67.1) 296.9,67.1 298.1,65.9 v1(299.66,65.9)
  BOTTOM w0.254: v1(316.74,65.25) JAPS1.7 ; v1(170.13,119.04) 170.13,118.48 PR113.1 ; PR205.2 42.61,43.95 v1(43.52,43.05) ; v1(48.84,45.68) 48.79,45.63 PC206.1 47.54,46.28 PU200.13 ; JAPS1.3 316.44,63.25 v1(315.85,63.84)
  BOTTOM w0.305: v1(291.37,74.82) 289.69,73.14 286.85,73.14 285.4,74.59 v1(285.4,74.82)
  BOTTOM w0.381: v1(272.01,77.88) 272.76,77.88 273.22,77.42 RE72.1 ; UE6.5 269.39,74.86 269.65,75.13 v1(269.93,75.13) ; UZ35.5 v1(138.92,83.86)
  BOTTOM w0.457: PR307.1 v1(185.68,96.73) ; RE526.2 RE532.2 301,90.05 v1(301,90.7)
  BOTTOM w0.508: UV24.5 95.9,83.96 CV17.1 97.68,84.96 v1(97.68,84.65) ; v1(65.07,98.15) 63.06,100.16 63.06,101.22 62.55,101.73 62.04,101.73 60.53,103.24 60.53,104.29 61.08,104.83 PR28.2 ; v1(140.47,92.37) 140.47,95.34 146,100.88 ; RE74.1 RE73.1 v1(272.42,73.36) ; RE75.1 272.85,75.77 v1(271.94,75.77) ; v1(184.98,92.22) 184.6,92.22 PC312.1 183.96,91.9 182.96,92.91 ; PR29.1 v1(65.26,101.39)
  vias: v1(124.62,111.59) v1(124.91,112.1) v1(125.61,111.78) v1(144.91,103.27) v1(144.91,102.63) v1(145.1,103.9) v1(145.55,103.27) v1(145.55,102.63) v1(145.74,103.9) v1(146.06,112.76) v1(146.18,103.27) v1(146.18,102.63) v1(146.37,103.9) v1(146.82,103.27) v1(146.82,102.63) v1(147.01,103.9) v1(147.45,103.27) v1(147.45,102.63) v1(147.64,103.9) v1(182.31,115.07) v1(182.34,114.47) v1(182.37,113.88) v1(182.35,113.24) v1(182.63,30.5) v1(183.01,115.06) v1(183.04,114.45) v1(183.04,113.87) v1(183.03,113.23) v1(183.7,115.04) v1(183.7,113.85) v1(183.68,113.2) v1(183.7,114.46) v1(190.1,15.36) v1(190.1,14.78) v1(190.69,14.82) v1(190.95,14.29) v1(191.5,14.51) v1(191.43,13.93) v1(198.47,5.3) v1(198.47,4.71) v1(199.06,5.31) v1(199.08,4.72) v1(199.66,5.29) v1(199.66,4.7) v1(200.28,5.33) v1(200.26,4.74) v1(202.44,10.53) v1(202.48,9.92) v1(202.48,9.34) v1(203.12,10.51) v1(203.15,9.9) v1(203.13,9.3) v1(220.22,9.8) v1(220.88,12.59) v1(220.99,9.8) v1(221.15,29.09) v1(221.12,13.16) v1(221.35,29.65) v1(221.52,12.59) v1(221.75,29.09) v1(221.76,13.16) v1(221.95,29.65) v1(222.33,29.07) v1(222.53,29.66) v1(222.97,29.07) v1(223.17,29.66) v1(271.07,81.81) v1(271.07,81.21) v1(273.31,49.78) v1(273.31,49.19) v1(273.54,48.63) v1(273.75,51.85) v1(273.96,49.22) v1(274.21,52.71) v1(274.29,52.12) v1(274.78,52.46) v1(274.85,51.87) v1(307.92,64.28) v1(314.14,79.14) v1(314.61,71.43) v1(315.2,71.43) v3(200.55,6.47) v3(312.6,71.34)
+3.3V_ALW2: length 234.1
  TOP w0.127: v3(149.74,110.76) 149.99,110.51 150.42,110.51 150.95,111.04 v1(150.95,111.09)
  TOP w0.254: PR104.2 v1(150.95,111.09)
  TOP w0.508: RE57.2 295.58,68.24 295.28,67.94 v1(295.28,67.71)
  IN4 w0.508: 274.08,44.62 273.9,44.44 271.7,44.44 269.07,41.8 269.07,41.53 266.36,38.83 263.85,38.83 259.73,34.71 259.73,32.48 257.51,30.25 257.51,29.2 255.46,27.15 239.63,27.15 235.97,30.82 220.29,30.82 218.7,29.23 213.56,29.23 213.15,28.82 210.98,28.82 208.54,31.26 199.53,31.26 195.91,34.88 195.91,36.67 186.33,46.25 181.07,46.25 171.11,56.21 171.11,77.53 155.4,93.24 149.22,93.24 146.59,95.87 146.59,98.17 150.63,102.2 150.63,110.25 150.95,110.58 v1(150.95,111.09) ; 275.78,46 275.78,46.81 277.99,49.02 278.35,49.02 279.43,50.1 280.59,50.1 284.53,54.03 284.53,55.13 285.55,56.15 285.55,56.99 286.72,58.16 291.14,58.16 291.65,58.67 291.65,59.28 292.49,60.11 292.49,60.83 294.98,63.32 294.98,65.44 294.77,65.65 294.77,67.2 v1(295.28,67.71)
+3.3V_ALW_DSW: length 153.7
  TOP w0.127: v2(132.31,30.35) RC243.2
  TOP w0.254: RC241.2 v1(65.53,39.9)
  TOP w0.508: CC279.1 174.58,31.01 RC440.1 174.19,30.38 174.19,29.1 173.74,28.66 173.11,28.66 172.15,27.7 162.39,27.7 162.01,27.32 v1(161.96,27.32) ; CC279.1 175.15,31.02 175.15,31.68 176.07,32.59 RC439.1 ; CC279.1 CC280.1 ; v1(144.17,32.15) 143.64,32.68 RC323.2 ; RC72.2 v1(150.75,32.13) ; RC243.2 134.29,30.35 v1(134.36,30.28) ; RC67.2 133.08,35.43 v1(133.17,35.34)
  IN1 w0.508: v1(150.75,32.13) 151.56,31.32 152.26,31.32 153.73,29.84 160.58,29.84 161.96,28.47 v1(161.96,27.32)
  IN2 w0.508: v1(133.17,35.34) 133.35,35.52 ; 133.35,35.52 135.05,35.52 135.96,36.42 137.17,36.42 137.47,36.73 137.47,38.96 135.83,40.6 135.83,43.39 v1(136.02,43.58) ; 133.35,35.52 133.86,36.03 133.86,37.61 133.36,38.12 132.12,38.12 127,33 124.43,33 123.76,32.33 92.88,32.33 86.72,38.5 66.55,38.5 65.53,39.52 v1(65.53,39.9)
  IN3 w0.508: v1(133.17,35.34) 133.35,35.16 133.35,30.85 133.92,30.28 v1(134.36,30.28) 135.18,31.1 135.18,31.56 135.75,32.13 136.01,32.13 136.44,32.56 137.75,32.56 138.16,32.15 v1(144.17,32.15)
  BOTTOM w0.254: UC1.AD17 v1(127.73,57.15) 127.66,57.23 UC1.AD18 ; v1(127.71,54.64) UC1.AJ17
  BOTTOM w0.508: v1(150.75,32.13) 150.75,31.82 150.32,31.39 144.93,31.39 v1(144.17,32.15)
+3.3V_ALW_DSW_R: length 4.6
  TOP w0.127: v2(178.22,28.35) QC7.1
  TOP w0.508: RC439.2 178.22,31.81 QC7.1
+3.3V_ALW_PCH: length 560.4
  TOP w0.254: RC12.2 147.88,64.98 v1(147.88,64.27) 146.46,64.27 145.9,63.72 RC23.2
  TOP w0.305: RC133.2 60.33,40.28 v1(60.81,39.79)
  TOP w0.381: LC1.1 127.22,33.4 CC105.1 CC104.1 ; RI55.2 v1(306.67,49.55) ; RC74.2 v1(144.72,35.31) ; v1(129.82,37.66) 130.1,37.66 130.94,38.5 RC187.2
  TOP w0.457: v1(126.41,59.61) 126.08,59.94 CC337.1
  TOP w0.508: RC183.2 148.16,35.63 v1(148.16,34.85) ; v1(159.85,44.34) 162.95,44.34 163.84,43.45 165.99,43.45 168.72,46.18 171.14,46.18 173.3,44.02 RZ368.1 ; RI44.2 300.23,51.52 v1(300.64,51.11) 300.8,51.11 301.12,51.43 RI57.2 ; RC184.2 v1(149.74,38.25) ; v1(301.51,64.22) 301.63,64.1 RI53.2 RI38.2 ; RI51.2 RI40.2 v1(300.61,64.23) ; RI34.1 303.66,61.8 303.37,62.09 v1(303.37,62.31) ; RC344.2 136.35,29.85 136.66,30.15 v1(136.93,30.15) ; RC211.1 v1(154.69,56.66) ; v1(150.55,55.82) 151.25,56.52 151.25,56.88 ; RZ69.1 v1(162.82,41.45) ; v1(316.66,70.44) 316.11,70.44 315.54,69.87 RI80.1 ; v1(147.15,61.46) 146.89,61.46 145.9,60.47 RC308.1 ; RC14.2 v1(154.26,68.09) ; 151.25,56.88 RC306.1 ; 151.25,56.88 RC235.1 ; RC73.2 v1(151.77,32.06) ; RC387.2 149.74,32.09 v1(149.79,32.09) ; v1(126.5,34.79) LC1.1 ; v1(173.49,29.53) 173.16,29.86 RC440.2 ; RI42.2 v1(302.07,51.11)
  IN1 w0.508: v1(303.37,62.31) 303.37,61.25 302.5,60.38 302.5,58.6 303.33,57.77 303.33,53.03 302.07,51.77 v1(302.07,51.11)
  IN2 w0.508: v1(159.85,44.34) 162.75,41.45 v1(162.82,41.45) 163.92,41.45 164.32,41.05 167.61,41.05 169.49,39.17 169.49,35.69 168.15,34.36 168.15,31.72 170.34,29.53 v1(173.49,29.53) ; v1(127.59,40.46) 127.77,40.46 128.37,39.86 128.37,36.66 v1(126.5,34.79) 125.89,34.18 123.78,34.18 123.08,33.48 93.34,33.48 86.18,40.64 72.71,40.64 71.3,42.06 63.07,42.06 v1(60.81,39.79) ; v1(156.17,78.02) 156.7,77.49 165.96,77.49 v1(166.79,76.67) ; v1(281.29,90.64) 281.29,91.34 283.25,93.3 284.39,93.3 287.2,96.11 303.16,96.11 303.94,95.32 306.41,95.32 307.64,94.1 318.04,94.1 320.43,91.71 320.43,89.17 319.79,88.54 319.79,72.59 318.06,70.85 316.97,70.85 316.66,70.55 v1(316.66,70.44) 316.66,69.5 317.85,68.32 317.85,63.24 v1(318.71,62.38) 318.71,61.87 316.41,59.57 314.61,59.57 v1(313.14,58.1)
  IN3 w0.508: v1(156.08,52.19) 156.08,51.42 v1(158.6,48.9) ; 273.13,50.55 272.47,50.55 269.62,47.7 268.64,47.7 267.63,46.69 267.63,45.52 265.16,43.05 263.94,43.05 263.46,43.52 257.73,43.52 257.34,43.91 256.5,43.91 255.98,43.39 v1(255.98,42.58) ; 276.66,59.93 276.66,60.59 278.06,61.99 278.06,66.62 277.66,67.03 277.66,72.12 278.47,72.93 278.47,73.32 278.87,73.73 279.38,73.73 279.63,73.98 279.63,75.97 280.16,76.49 280.16,79.3 280.81,79.96 282.45,79.96 282.96,80.47 282.96,81.19 280.66,83.48 280.66,83.48 280.66,88.1 281.29,88.73 v1(281.29,90.64) ; v1(136.93,30.15) 135.71,28.93 132.37,28.93 131.17,30.13 131.17,37.96 131.17,37.97
  IN3 w1.016: 197.94,13.75 194.49,13.75 192.78,15.46 191.79,15.46 191.01,16.23 191.01,17.72 188.21,20.52 183.94,20.52 179.7,24.76 178.03,24.76 177.28,25.51 177.28,27.02 175.52,28.78 174.24,28.78 v1(173.49,29.53) 173.42,29.53 172.99,29.1 163.86,29.1 163,29.96 156.27,29.96 153.47,32.76
  IN4 w0.508: v1(156.17,78.02) v1(152.66,74.5)
  BOTTOM w0.254: v1(124.92,55.47) 125.04,55.35 125.14,55.35 UC1.AJ21 ; v1(126.41,59.61) 126.41,59.76 UC1.V19 ; RC41.1 159.19,48.66 159.19,48.05 159.85,47.38 JSPI1.16 159.85,45.82 ; RC347.2 151.16,60.09 151.77,60.09 v1(151.9,60.22) ; v1(318.71,62.38) 318.59,62.25 JAPS1.1 ; v1(150.07,62.15) 150.37,62.15 RC348.2 ; UC1.AK17 128.04,53.79 v1(127.96,53.71)
  BOTTOM w0.305: v1(159.85,44.34) 159.85,45.82
  BOTTOM w0.381: RC17.2 147.48,63.87 v1(147.88,64.27) 148.26,64.66 RC555.2 RC371.2 RC400.2 148.42,66.85 v1(148.42,67.71) ; RC15.2 149.46,62.76 v1(150.07,62.15)
  BOTTOM w0.457: RC346.2 152.65,74.49 v1(152.66,74.5) ; v1(156.17,78.02) 156.15,78 RC288.2
  BOTTOM w0.508: v1(148.16,34.85) 148.16,35.25 147.42,35.99 145.4,35.99 v1(144.72,35.31) ; RC553.2 146.99,59.84 v1(147.25,59.58) ; v1(255.98,42.58) 252.23,42.58 248.43,38.78 243.4,38.78 239.91,35.29 220.57,35.29 218.12,37.75 210.68,37.75 206.27,42.16 205.7,42.16 204.99,42.88 204.34,42.88 203.29,43.93 200.42,43.93 188.78,55.56 188.78,59.55 171.66,76.67 v1(166.79,76.67) ; RC222.2 280.66,92.93 281.29,92.3 v1(281.29,90.64) ; RC330.2 147.71,52.85 148.53,53.68 148.53,54.62 RC317.2 148.15,54.74 v1(147.17,55.72) 146.97,55.52 RC331.2 RC283.2 ; v1(302.07,51.11) 302.07,51.69 302.99,52.61 305.33,52.61 305.77,52.16 310.32,52.16 311.23,53.08 311.23,57.05 312.27,58.1 v1(313.14,58.1) ; UC7.5 v1(156.08,52.19) ; RC25.2 v1(147.15,61.46) ; v1(158.6,48.9) RC41.1
  vias: v1(136.5,77.41) v1(137.22,77.39) v1(206.9,9.58) v1(206.94,8.99) v3(145.04,56.22)
+3.3V_ALW_PCH_UZ3: length 2.7
  TOP w0.127: 206.09,10.08 206.21,10.2 207.42,10.2 207.6,10.03 207.6,9.44 v2(207.95,9.09)
+3.3V_ALW_UE1: length 27
  TOP w0.203: v1(303.16,72.33) UE1.K2 ; UE1.B7 295.96,76.33 295.13,76.33 294.85,76.04
  TOP w0.254: UE1.M9 v1(304.8,78.76) ; v1(306.96,78.15) CE20.1 307.65,78.74 CE19.1 ; UE1.H1 v1(301.16,70.51) 301.16,70.34 301.35,70.15 301.35,69.53 CE15.1 301.31,69.44 301.31,68.03 RE314.2 ; v1(299.98,77.9) UE1.G8
  TOP w0.381: 294.85,76.04 294.68,75.88 CE13.1 v1(292.92,75.88)
  TOP w0.508: 291.06,76.15 291.33,75.88 v2(292.04,75.88) v1(292.92,75.88)
  IN2 w0.381: v1(301.16,70.51) 302.97,72.33 v1(303.16,72.33)
  BOTTOM w0.508: v1(303.16,72.33) 306.31,72.33 307.03,73.04 307.03,74.5 305.49,76.04 305.49,76.71 304.8,77.4 v1(304.8,78.76)
+3.3V_ALW_UZ12:
  vias: v1(170.69,33.67) v1(175.54,35.4) v1(176.13,35.4) v2(170.79,35.63)
+3.3V_ALWP: length 20.6
  TOP w0.254: v1(150.32,111.09) 150.32,111.44 PR108.2 ; v1(151.95,111.8) 152.04,111.71 PU100.14
  BOTTOM w0.254: 148.47,105.3 146.99,106.78 146.99,109.92 148.87,111.8 v1(151.95,111.8) ; v1(150.32,111.09) 149.18,111.09 147.71,109.62 147.71,107.08 148.47,106.32
  vias: v1(148.98,105.56) v1(149.36,104.92) v1(149.74,105.56) v1(149.99,104.92) v1(149.99,104.16) v3(149.46,104.36)
+3.3V_CAM: length 10.5
  TOP w0.127: v3(112.4,86.63) 111.86,86.63 v1(111.62,86.39)
  IN1 w0.508: v1(111.62,86.39) 111.62,85.19 111.22,84.79 110.85,84.79 v1(110.84,84.79)
  BOTTOM w0.254: JEDP1.11 111.3,89.97 111.76,89.51 111.76,88.94 CZ1.1
  BOTTOM w0.508: v1(111.62,86.39) 111.62,86.91 CV23.1 CV22.1 ; v1(110.84,84.79) 111.72,83.91 QZ1.1
+3.3V_CPS: length 16.9
  TOP w0.127: CT121.1 22.29,92.69 v3(22.23,92.75)
  TOP w0.254: CT121.1 23.53,92.65 v1(23.96,92.22)
  TOP w0.356: v1(18.88,91.25) 19.05,91.42 CT120.1 CT118.1
  TOP w0.381: v1(18.87,90.62) 18.62,90.38 LT11.2 ; v1(21.85,98.7) 21.98,98.57 CT117.1 21.93,97.81 CT119.1
  IN1 w0.508: v1(16.96,101.43) 16.96,100.98 18.03,99.91 21.34,99.91 21.85,99.4 v1(21.85,98.7)
  BOTTOM w0.203: UT9.28 19.81,91.43 19.64,91.25 v1(18.88,91.25) ; UT9.20 23.62,92.56 v1(23.96,92.22)
  BOTTOM w0.254: v1(21.85,98.7) 21.81,98.66 UT9.6
  BOTTOM w0.508: RT246.1 v1(16.96,101.43)
+3.3V_CPS_R1: length 4.2
  BOTTOM w0.203: 19.58,98.42 19.81,98.19 UT9.1
  BOTTOM w0.254: RT246.2 CT122.1 17.98,99.76 17.98,99.38 v2(18.42,98.94) 19.07,98.94 19.58,98.42
+3.3V_EC_PLL: length 0.6
  BOTTOM w0.102: v2(300.61,68.22) v1(300.03,68.22)
+3.3V_HDD: length 32.2
  TOP w0.127: v3(273.99,60.27) 274.2,60.47 274.2,60.98 273.75,61.43 v1(273.61,61.43) ; v3(270.66,64.39) v1(271.25,64.66)
  TOP w0.254: CN16.1 279.55,64.32 UN7.20 ; UN7.10 274.36,62.32 273.97,61.93 CN17.1 ; RN12.1 RN20.1 281.56,63.4 v1(281.19,63.03)
  TOP w0.381: CN16.1 280.66,65.54 v1(281.18,66.06) ; RN18.1 280.66,58.62 281.73,59.68 v3(282.15,59.68) 282.15,60.14 281.56,60.72 RN16.1 281.56,61.37 v1(281.9,61.71) 281.59,62.02 RN10.2 ; CN17.1 272.84,61.81 273.22,61.43 v1(273.61,61.43)
  TOP w0.508: RN6.1 RN8.2 RN14.1 271.38,64.79 v1(271.25,64.66)
  BOTTOM w0.381: 273.58,61.43 271.87,61.43 270.34,62.96 270.34,63.86 270.85,64.37 270.96,64.37 v1(271.25,64.66)
  BOTTOM w0.508: v1(277.17,66.19) 276.31,66.19 275.71,65.59 275.71,64.9 274.96,64.15 274.96,63.03 273.61,61.68 v1(273.61,61.43) 273.58,61.43
  vias: v1(274.4,38.45) v1(274.83,38.85) v1(275.34,39.82) v1(275.32,39.19)
+3.3V_HDD_M2: length 3
  TOP w0.102: v3(300.61,24.15) 303.66,24.15
  vias: v1(264.77,21.77) v1(264.76,20.95) v1(264.76,20.06) v1(265.66,21.77) v1(265.65,20.95) v1(265.65,20.06) v1(290.33,28.4) v1(290.66,27.51) v1(290.9,28.05) v1(291.28,27.51) v1(291.54,28.04) v1(293.12,25.9) v1(303.92,25.1) v1(303.92,24.47) v1(304.55,25.1) v1(304.55,24.47) v1(305.25,25.1) v1(305.25,24.47) v3(293.76,25.67) v3(305.95,24.4)
+3.3V_LAN: length 267.9
  TOP w0.381: v1(270.01,89.55) 270.17,89.39 CL15.1 271,89.03 UL2.5 ; RL6.2 283.09,78.69 282.71,78.31 281.12,78.31 280.8,78.63 v1(280.8,78.94) 280.4,79.34 RL5.2 279.4,79.57 RL4.2
  TOP w0.457: RL29.1 282.19,101.44 v1(282.32,101.57)
  TOP w0.508: RL70.2 142.63,31.75 144.3,30.08 146.2,30.08 146.92,29.36 v3(150.93,29.36) 170.38,29.36 v1(171.52,30.5) ; RL1.2 271.36,84.09 v1(271.1,83.83) ; RL30.1 v1(278.26,102.25) ; RL2.2 v1(271.15,82.57)
  TOP w1.016: 284.42,105.11 285.39,106.08 JLOM1.9 ; JLOM1.12 304.25,106.08 305.11,105.22 305.11,103.76 304.68,103.33 v3(304.68,102.76) 304.68,97.79
  IN1 w0.508: v1(148.77,62.17) 151.39,59.56 v1(151.69,59.56) ; v1(264.93,52.79) 264.93,53.42 265.73,54.22 269.47,54.22 270.25,53.45 271.75,53.45 273.36,55.06 273.6,55.06
  IN3 w0.508: v1(216.64,8.02) 216.38,8.27 212.62,8.27 212.19,7.84 209.6,7.84 208.26,9.19 208.26,12.2 203.87,16.59 201.09,16.59 200.35,15.85 197.03,15.85 195.83,14.64 194.82,14.64 192.88,16.58 192.88,17.07 188.57,21.38 185.81,21.38 185.23,21.96 183.72,21.96 176.01,29.67 175.07,29.67 173.8,30.94 171.96,30.94 v1(171.52,30.5)
  IN4 w0.508: v1(171.52,30.5) 172.04,31.02 172.04,35.37 169.17,38.25 164.6,38.25 155.45,47.39 155.45,48.84 156.74,50.12 156.74,53.73 153.78,56.69 153.78,57.9 153.36,58.33 152.14,58.33 151.69,58.78 v1(151.69,59.56)
  BOTTOM w0.254: RC20.2 148.32,61.72 v1(148.77,62.17) ; v1(151.69,59.56) 151.26,59.56 RC19.2
  BOTTOM w0.508: v1(216.64,8.02) 216.64,11.25 215.87,12.02 215.87,17.27 213.52,19.62 213.52,22.05 214.46,22.99 214.46,32.01 215.51,33.06 217.53,33.06 218.22,32.38 225.64,32.38 226.58,33.32 240.53,33.32 244.11,36.9 249.25,36.9 253.03,40.68 255.38,40.68 256.71,42.01 256.71,42.73 256.01,43.43 256.01,44.7 258.13,46.82 258.13,48.72 259.82,50.41 261.97,50.41 262.9,49.48 264.36,49.48 264.93,50.06 v1(264.93,52.79)
  vias: v1(276.66,100.81) v1(276.64,99.84) v1(278.19,104) v1(278.86,104.01) v1(279.81,52.38) v1(280.02,52.94) v1(285.63,81.62) v1(285.89,82.16) v1(305.26,96.75) v1(305.72,97.14) v3(281.61,104.95)
+3.3V_LAN_OUT: length 6.4
  TOP w0.203: UL1.29 274.04,86.22 v1(274.01,86.19) ; UL1.15 v1(279.66,89.55) ; UL1.19 v1(278.06,89.68)
  BOTTOM w0.127: v1(274.01,86.19) v2(273.27,86.19)
  BOTTOM w0.254: v1(278.06,89.68) 278.01,89.63 CL30.1 ; CL7.1 279.53,89.42 v1(279.66,89.55)
  BOTTOM w0.381: v1(274.01,86.19) 274.07,86.25 CL29.1
  vias: v1(282.44,84.61) v1(284.14,83.92)
+3.3V_LAN_UZ2:
  vias: v2(276.71,53.33)
+3.3V_M_TPM: length 6.1
  TOP w0.127: RZ369.2 174.25,42.26 v2(174.58,41.93)
  TOP w0.508: RZ366.2 RZ367.1 172.01,42.11 172.34,42.44 CZ60.1 ; CZ60.1 CZ59.1 ; CZ60.1 RZ368.2 RZ369.2
+3.3V_MMI_AUX: length 2.4
  TOP w0.127: RR19.2 v2(27.74,44.25)
  TOP w0.203: 25.15,46.58 25.19,46.61 ; UR1.27 25.19,47.44
  TOP w0.508: 25.19,47.44 25.19,46.61
+3.3V_MMI_IN: length 1.2
  TOP w0.127: CR25.1 22.37,43.08 v2(22.84,43.55)
  vias: v1(20.61,43.92) v1(21.33,43.91) v1(27.34,54.86) v1(27.92,54.86)
+3.3V_PDA_VOUT: length 4.4
  TOP w0.076: 30.53,84.41 31.39,83.55 31.39,82.79 UT5.H2
  TOP w0.102: 30.53,84.41 30.5,84.43 v2(30.5,84.51) 30.5,84.61 v1(30.18,84.93)
  BOTTOM w0.102: v1(30.18,84.93) 29.45,84.21 CT83.1
+3.3V_PGPPB: length 0.5
  BOTTOM w0.254: v1(129.03,55.48) 129.28,55.82 UC1.AG15
+3.3V_PGPPC: length 16.1
  TOP w0.127: RC306.2 150.33,57.82 151.22,58.72 v2(151.64,58.72)
  TOP w0.508: RC306.2 v1(149.67,57.73)
  IN3 w0.508: 138,57.45 138.74,57.45 138.99,57.19 141.91,57.19 142.45,56.66 145.06,56.66 146.77,58.36 147.55,58.36 148.34,57.57 149.51,57.57 v1(149.67,57.73)
  BOTTOM w0.254: UC1.Y16 128.66,59.24 128.39,58.88 v1(128.4,58.82)
+3.3V_PGPPD: length 9.8
  TOP w0.127: v1(143.64,57.8) v2(142.8,57.8)
  TOP w0.508: RC307.2 143.9,57.55 v1(143.64,57.8)
  IN3 w0.508: v1(143.64,57.8) 142.58,58.87 141.5,58.87 140.88,58.25 138.9,58.25 137.95,59.2 137.29,59.2
  BOTTOM w0.254: v1(129.71,58.89) 129.71,58.9 129.36,59.25 UC1.Y15
+3.3V_PGPPE: length 11.4
  TOP w0.381: v1(128.4,60.47) 128.29,60.37 128.29,59.49 127.93,59.12 CC96.1 CC97.1
  TOP w0.508: RC308.2 143.07,60.47 142.3,59.69 137.43,59.69 136.87,59.13
  BOTTOM w0.254: UC1.T16 128.45,60.61 128.45,60.52 128.42,60.48 v1(128.4,60.47)
  vias: v1(134.42,59.17) v2(136.13,59.11)
+3.3V_RTC_LDO: length 132.7
  TOP w0.102: v1(58.92,79.89) 59.31,80.28 v3(59.31,80.49)
  TOP w0.254: PR105.2 v1(149.62,110.2)
  TOP w0.508: v1(58.92,79.89) 58.79,79.76 PD3.3
  IN1 w0.254: v1(71.63,96.96) 71.63,99.64 76.01,104.03 82.3,104.03 82.92,104.65 108.52,104.65 111.09,102.08 114.41,102.08 115.8,100.68 119.39,100.68 120.1,101.39 123.42,101.39 124.34,100.48 129.39,100.48 130.41,99.46 139.04,99.46 139.55,99.97 139.55,100.73 139.17,101.11 138.71,101.11 135.26,104.56 135.26,106.44 135.52,106.7 135.52,109.84 137.77,112.1 147.66,112.1 149.55,110.2 v1(149.62,110.2)
  BOTTOM w0.508: v1(58.92,79.89) 59.62,79.89 60.28,80.54 60.28,83.56 61.88,85.16 64.04,85.16 65.33,86.45 65.33,88.77 65.65,89.08 67.12,89.08 68.8,90.76 69.98,90.76 71.63,92.4 v1(71.63,96.96)
+3.3V_RUN: length 431.6
  TOP w0.203: v1(96.27,97.05) 96.48,97.26 UV7.51 ; RV622.1 278.16,52.24 278.29,52.37 UV6.14 ; v1(96.3,94.61) 96.58,94.61 96.83,94.86 UV7.57 ; CV85.1 99.55,90.01 99.55,92.25 99.6,92.29 UV7.5 ; v1(278.69,57.96) UV6.26
  TOP w0.254: UN4.24 262.15,49.58 261.49,50.25 CN20.1 ; v1(264.93,44.24) 264.65,44.51 UN4.12 ; 293.04,57.78 292.48,57.21 UN5.12 ; QC2.2 151.67,66.25 151.26,65.83 151.26,64.86 150.63,64.23 v1(150.12,64.23) ; RC50.2 137.94,43.4 138.56,44.02 140.59,44.02 141.42,43.2 141.42,42.44 140.9,41.92 RC414.2 ; UN5.24 287.5,54.71 v1(287.25,54.96) ; JUSH1.19 221.31,16.15 CZ67.1 ; v1(316.74,67.79) 317.4,67.79 317.76,68.14 317.76,68.75 317.45,69.06 317.45,70.36 315.92,71.9 315.92,73.04 315.09,73.87 314.2,73.87 313.82,74.25 313.82,76.03 312.43,77.42 RE547.2 ; QC2.5 149.49,66.25 v1(149.4,66.16)
  TOP w0.305: RZ362.1 173.75,37.1 RZ89.1 ; v1(57,32.25) CC30.1 54.73,32.25 UC8.14 ; RN226.1 249.95,42.13 v1(249.75,41.93) 249.32,41.5 RN228.1 ; v1(264.93,43.66) 266.55,43.66 266.86,43.35 266.86,42.79 266.17,42.11 RN49.1 ; v1(65.82,16.96) 65.66,17.11 RD19.2 ; v1(283.28,58.18) 283.28,56.62 282.81,56.15 CV100.1 282.62,55.99 LV30.1
  TOP w0.356: CV85.1 98.49,89.97 98.48,89.96 v1(98.46,89.96)
  TOP w0.381: v1(276.44,39.49) 276.44,38.44 276.84,38.04 RN2.1 ; RC51.2 145.67,32.37 v1(146,32.04) ; v1(142.75,38.75) 141.98,37.98 RC190.2 ; RV124.1 275.45,51.49 v1(275.45,52.79) ; RN65.1 210.66,32.39 211.31,31.74 212.32,31.74 212.67,32.09 v1(212.67,34.05) RN171.1 ; RN25.1 257.62,42.23 ; 257.62,42.23 257.37,41.98 257.37,40.52 257.8,40.09 259.66,40.09 260.74,41.17 RN26.1 RN28.1 ; 257.62,42.23 257.62,42.73 v1(257.1,43.25) ; RC414.2 141.44,41.32 v1(141.44,41.25) ; CA7.1 v1(111.89,91.13) ; v1(269.19,44.47) 269.13,44.53 RN27.1 RE51.1 ; RC237.2 151.26,54.76 151.52,54.5 151.76,54.5 152.08,54.18 153.32,54.18 153.7,54.56 RC282.2 ; RN64.1 219.64,31.71 220,31.35 221.97,31.35 222.68,32.06 v1(222.68,33.67) ; v1(117.87,105.4) 117.87,105.61 117.49,105.99 RV19.2 ; CN21.1 260.96,50.92 CN20.1
  TOP w0.457: v1(147.52,58.95) 145.95,58.95 RC279.2 ; v1(264.29,52.79) 264.29,52.29 RN50.1 ; RN42.1 v1(261.75,52.53) RN43.1 ; v1(93.29,93.72) 93.44,93.87 RV85.2 RV87.2
  TOP w0.508: RI79.1 315.97,67.79 v1(316.74,67.79) ; RN51.1 268.51,47.52 v1(268.99,47.03) ; v1(154.53,57.41) 154.43,57.41 153.8,56.79 RV326.1 153.7,56.71 RC282.2 ; RE67.2 296.55,63.85 296.17,63.47 v1(296.17,62.44) ; v1(105.68,8.37) 105.96,8.37 106.13,8.2 RD10.1 ; v1(187.42,14.2) 187.79,13.84 RD26.1 ; RC319.2 154.26,64.79 153.53,64.05 v1(152.87,64.05) ; QV5.2 116.29,110.73 RV20.2 v1(116.29,112.57) ; v1(63.15,26) 63.15,26.39 RC137.2 ; v1(142.12,89.88) RC413.2 RC175.2 RC178.2 ; RC47.2 v1(146.56,35.2) ; RC59.2 v1(149.36,35.2) ; RV91.2 v1(109.43,91.08) ; v1(279.03,51.45) 278.5,50.92 RV620.1 277.88,51.22 278.16,51.5 RV622.1 ; CN21.1 260.88,51.62 261.17,51.91 RN42.1 ; RV93.2 RV95.2 94.81,89.64 v1(94.99,89.46) ; 293.04,57.78 293.71,58.44 CN31.1 ; v1(120.34,85.57) RC177.2 RC176.2 ; RD6.1 RD4.1 v1(103.64,2.35) ; RV70.2 v1(111.79,96.35) ; v1(147.76,67.71) RC318.2 ; RN44.1 RN50.1 ; RC189.2 RC186.2 148.72,32.05 v1(148.71,32.05) ; RC370.2 152.41,38.93 v1(152.58,38.76) 152.76,38.93 RC278.2 ; RD22.1 v1(189.04,1.6) ; RV79.2 v1(94.81,101.19) ; v1(93.22,96.54) RV83.2 RV81.2 ; v1(145.31,67.56) RC404.2 RC345.2 ; RC267.2 v1(147.71,38.25) ; RV89.2 98.76,88.08 98.91,87.93 v1(98.91,87.2) ; v1(170.88,45.1) 170.69,45.1 170.31,44.72 170.31,43.97 RZ365.2 ; RN58.1 295.46,53.29 v1(295.98,52.78) 295.54,52.34 RN56.1 ; 106.57,99.33 v1(106.57,98.51) ; RD8.1 v1(89.84,2.29) ; RD20.1 v1(186.19,1.6) ; RZ89.1 174.18,40.85 v1(174.68,41.35) ; RV18.1 110.37,98.69 v1(110.64,98.42) ; RD24.1 170.06,2.49 170.19,2.37 170.25,2.37 v1(170.31,2.43) ; RN63.1 v1(226.14,36.54) ; CV81.1 v1(95.52,99.32) ; RC292.2 v1(133.61,84.78)
  IN1 w0.508: v1(316.74,67.79) 315.93,67.79 313.7,65.55 312.01,65.55 311.32,64.86 310.45,64.86 308.6,63.02 308.6,61.53 307.54,60.46 307.54,55.85 306.44,54.75 305.83,54.75 v1(305.73,54.84) ; v1(116.29,112.57) 117.87,110.98 v1(117.87,105.4) 117.87,103.15 v1(116.08,101.36) ; v1(133.61,84.78) 133.63,84.75 137.33,84.75 137.94,84.15 137.94,83.09 ; v1(137.29,81.81) 137.29,82.45 137.94,83.09 ; 137.94,83.09 139.47,83.09 142.12,85.75 v1(142.12,89.88) ; v1(111.97,80.31) 111.97,80.97 112.53,81.53 v1(112.53,85.46)
  IN2 w0.508: v1(279.03,51.45) 277.87,52.61 277.87,54.21 278.29,54.63 278.29,55.36 278.14,55.52 278.14,56.56 278.54,56.96 278.54,57.8 v1(278.69,57.96) ; v1(105.68,8.37) 105.52,8.2 105.52,5.18 103.64,3.3 v1(103.64,2.35) 103.57,2.29 v1(89.84,2.29) 87.13,5 79.54,5 78,6.54 78,12.98 74.02,16.96 v1(65.82,16.96) ; v1(37.21,45.77) 37.21,44.54 40.17,41.57 40.17,41.05 49.47,31.76 54.3,31.76 54.79,32.25 v1(57,32.25) ; v1(148.71,32.05) 149.92,33.26 152.16,33.26 153.65,34.75 153.65,37.98 152.87,38.76 v1(152.58,38.76)
  IN3 w0.508: v1(57,32.25) 57.82,32.25 59.35,30.71 59.35,29.8 v1(63.15,26) 63.15,23.84 67.76,19.23 67.76,17.56 67.16,16.96 v1(65.82,16.96)
  IN4 w0.508: v1(75.18,54.18) 74.6,54.76 74.24,54.76 71.63,57.36 70.36,57.36 69.86,56.85 58.62,56.85 57.53,55.76 53.85,55.76 52.53,57.08 v1(52.53,58.11) ; v1(299.42,54.54) 303.28,54.54 303.71,54.97 305.61,54.97 v1(305.73,54.84)
  IN4 w1.016: 32.69,61.19 26.07,61.19 17.09,70.18 17.09,78.24 16.11,79.22 16.11,82.9 15.17,83.85 15.17,85.37 15.63,85.83 15.63,88.23
  BOTTOM w0.254: v1(111.89,91.13) 111.82,91.2 111.82,91.25 111.8,91.27 JEDP1.10
  BOTTOM w0.305: RV8.2 99.19,87.48 v1(98.91,87.2) ; QV3.5 113.58,110.32 113.77,110.51 113.77,111.22 114.1,111.55 115.42,111.55 115.7,111.27 115.7,110.69 115.33,110.32 QV3.2
  BOTTOM w0.381: UC12.5 147.4,90.9 147.21,90.71 RC291.2
  BOTTOM w0.508: v1(146.31,91.66) RC291.2 ; RC403.2 RC402.2 147.03,53.74 v1(147.22,53.93) ; QZ1.3 111.74,80.54 v1(111.97,80.31) ; RC225.2 v1(151.39,92.44) ; v1(296.17,62.44) 296.36,62.25 296.36,60.33 296.82,59.87 296.82,58.11 296.83,58.1 ; RC287.2 147.07,57.3 v1(147.39,57.61) ; 273.87,46.63 269.93,46.63 269.52,47.03 v1(268.99,47.03) ; v1(137.29,81.81) 137.01,81.53 RC272.2 ; 115.7,111.27 116.29,111.85 v1(116.29,112.57) ; v1(75.18,54.18) 75.18,53.07 PR612.1
  vias: v1(15.98,89.67) v1(15.98,89.06) v1(16.96,44.6) v1(16.96,43.96) v1(16.96,43.33) v1(17.59,44.6) v1(17.59,43.96) v1(17.59,43.33) v1(32.8,60.11) v1(33.28,60.51) v1(106.56,93.2) v1(147.95,71.1) v1(148.53,71.1) v1(170.19,62.12) v1(170.24,62.94) v1(170.24,61.25) v1(174.06,27.77) v1(174.69,27.77) v1(201.13,2.37) v1(201.12,1.79) v1(201.81,2.37) v1(201.81,1.79) v1(202.53,2.37) v1(202.55,1.79) v1(203.26,2.39) v1(203.25,1.8) v1(217.25,12.97) v1(217.86,12.97) v1(260.36,20.82) v1(260.63,21.35) v1(261.02,21.89) v1(261.04,20.82) v1(261.45,21.35) v1(261.9,21.86) v1(264.41,43.93) v1(270.68,70.26) v1(270.73,69.66) v1(272.19,41.5) v1(272.6,77.26) v1(272.52,75.15) v1(272.75,41.19) v1(273.28,41.45) v1(295.99,58.08) v1(299.46,53.93) v3(217.81,14.5)
+3.3V_RUN_AUDIO: length 152.2
  TOP w0.508: v1(270.39,84.47) 269.29,83.38 v3(269.29,82.42) 269.29,79.95 270.52,78.73 ; v1(292.3,31.08) 292.77,31.08 293.58,31.9 RA59.1 293.62,32.75 LA12.2 ; v1(296.64,31.4) 296.22,30.98 RA61.1 ; 294.68,40.74 294.68,39.13 v1(294.72,39.08)
  IN3 w0.508: v1(289.41,94.38) 289.42,94.38 290.06,93.74 290.88,93.74 292.45,92.17 307.26,92.17 311.41,88.03 311.41,84.59 313.33,82.67 313.33,74.99 316.01,72.32 316.01,70.99 315.31,70.29 315.31,65.52 316.62,64.22 316.62,62.41 315.31,61.11 315.31,60.19 313.89,58.77 310.89,58.77 309.67,57.56 309.67,52.03 308.13,50.49 308.13,49.38 308.49,49.02 308.49,46.25 307.66,45.42 304.11,45.42 303.73,45.04 303.73,44.47 303.22,43.96 300.8,43.96 300.49,43.64 300.49,43.33 298.46,41.29 297.88,41.29 297.5,40.91 297.5,40.15 297.14,39.79 297.14,38.03 296.87,37.76 296.87,35.65 v1(292.3,31.08)
  IN4 w0.508: v1(289.41,94.38) 289.41,93.85 287.35,91.8 277.5,91.8 276.05,90.35 276.05,88.62 274.96,87.53 274.96,85.39 274.07,84.5 270.41,84.5 v1(270.39,84.47) ; v1(292.3,31.08) 292.3,32.47 296.01,36.19 296.01,37.79 v1(294.72,39.08)
  BOTTOM w0.508: v1(296.64,31.4) 296.32,31.08 v1(292.3,31.08)
+3.3V_RUN_AUDIO_DVDD:
  vias: v2(294.45,38.6)
+3.3V_RUN_AUDIO_IO:
  vias: v2(295.53,34.46)
+3.3V_RUN_AUDIO_UZ5:
  vias: v2(272.72,72.59)
+3.3V_RUN_CARD: length 9.3
  IN1 w1.016: 26.95,52.93 28,51.88 29.85,51.88 32.62,49.12 32.62,47.52 32.26,47.16
  vias: v1(26.02,53.56) v1(26.02,52.97) v1(30.69,44.11) v1(31.3,46.35) v1(31.3,44.11) v1(31.88,46.35) v3(30.94,44.62)
+3.3V_RUN_DIMM1: length 5.8
  TOP w0.305: v1(105,11.62) 104.65,11.28 v2(104.65,10.89) CD28.1 104.82,9.55 CD27.1
  TOP w0.508: CD27.1 104.73,8.87 RD10.2
  BOTTOM w0.254: v1(105,11.62) 104.78,11.84 JDIMM1.255
+3.3V_RUN_DIMM2: length 2.4
  TOP w0.102: 185.81,12.36 v2(184.74,12.36)
  BOTTOM w0.254: JDIMM2.255 v1(185.78,11.65)
+3.3V_RUN_UT9: length 52.9
  TOP w0.381: v1(18.74,101.43) 18.74,100.41 18.43,100.11 RT143.2 ; v1(15.98,92.11) 15.98,92.25 16.32,92.59 RT141.2
  TOP w0.406: v1(20.99,88.18) 20.99,88.23 21.47,88.71 RT131.2
  TOP w0.508: RT135.2 23.06,101.06 v1(23.06,101.45) ; RT145.2 26.8,93.87 v1(27.21,93.46) ; v1(22.89,88.11) 23.2,87.8 RT411.1 ; RT412.1 v1(26.27,89.71) ; v1(15.98,92.11) 17.15,90.94 17.15,89.27 17.55,88.87 LT11.1 ; RT139.2 26.52,96.31 v1(27,96.79) 26.56,97.22 RT137.2
  IN1 w0.508: v1(18.74,101.43) 18.74,101.05 19.13,100.65 22.27,100.65 v1(23.06,101.45) 23.06,101.17 23.98,100.25 26.34,100.25 v1(26.61,99.97)
  IN4 w0.508: v1(26.27,89.71) 26.27,89.4 26.01,89.15 26.01,87.95 25.56,87.5 23.5,87.5 v1(22.89,88.11) ; v1(20.99,88.18) 20.99,87.67 21.34,87.32 22.48,87.32 22.89,87.72 v1(22.89,88.11) ; v1(15.98,92.11) 15.98,92.6 15.12,93.46 15.12,99.18 16.59,100.65 17.96,100.65 v1(18.74,101.43) ; 26.6,93.57 26.6,93.06 23.93,90.39 23.93,89.15 v1(22.89,88.11)
  BOTTOM w0.381: RT247.2 v1(18.74,101.43)
  vias: v1(26.08,99.62) v2(25.49,99.66)
+3.3V_RUN_UZ3: length 1.5
  TOP w0.102: v2(207.98,4.08) 206.48,4.08
+3.3V_SPI: length 91.9
  TOP w0.508: 156.6,59.17 156.5,59.17 156.02,58.69 155.12,58.69 154.79,59.02 152.87,59.02 v1(152.6,59.29) ; 156.6,59.17 RC31.2 ; 156.6,59.17 157.1,58.66 v2(158.26,58.66) 161.14,58.66 v1(161.74,59.26)
  IN3 w0.254: v1(129,54.64) 129,54.26 129.34,53.92 129.34,52.12 129.65,51.81 130.79,51.81 131.23,51.37 131.79,51.37 131.8,51.38 131.84,51.38 132.06,51.6 132.06,51.89 132.29,52.12 132.71,52.12 132.72,52.11 132.72,52.11 132.98,51.85 132.98,51.51 133.01,51.48 133.01,50.21 133.3,49.93 134.63,49.93 135.01,50.31 137.42,50.31 137.63,50.52 145.89,50.52 146.75,51.39 152.01,51.39 156.14,47.26 157.99,47.26 159.47,45.79 v1(160.79,45.79)
  IN4 w0.508: 156.37,57.89 156.37,59.52 153.52,62.37 153.52,65.23 152.92,65.83 152.64,65.83 152.04,66.43 152.04,67.9 152.03,67.91 v1(152.03,67.96) ; 156.37,57.89 155.65,57.89 154.54,59 152.9,59 v1(152.6,59.29) ; 156.37,57.89 156.37,55.19 157.63,53.94 157.63,51.49 158.63,50.49 v1(159.43,50.49) 159.21,50.27 159.21,47.36 v1(160.79,45.79)
  BOTTOM w0.254: JSPI1.15 160.35,46.35 160.69,46.02 160.69,45.89 v1(160.79,45.79) ; v1(129,54.64) 128.69,54.95 UC1.AJ16
  BOTTOM w0.305: CC9.1 152.35,66.95 152.63,67.23 UC5.8
  BOTTOM w0.381: CC9.1 152.02,67.7 152.03,67.71 v1(152.03,67.96) ; v1(152.6,59.29) 152.56,59.25 152.29,59.25 151.6,58.57 CC10.1 151.32,58.38 153.07,58.38 UC6.8
  BOTTOM w0.508: RC41.2 v1(159.43,50.49) ; RC30.2 161.91,59.08 v1(161.74,59.26)
+3.3V_TBTA_FLASH: length 52.8
  TOP w0.203: v1(32.27,83.69) 32.27,83.16 UT5.G1
  TOP w0.254: JDB1.1 32.37,96.62 32.52,96.47 32.82,96.47 v1(33.08,96.73)
  TOP w0.381: RT95.2 26.61,86 26.42,86.19 v2(25.89,86.19) 25.41,86.19 24.59,85.37 RT66.2 ; RT378.2 35.39,86.94 RT379.2
  TOP w0.508: v1(35.18,88.08) 35.39,87.88 RT378.2 ; RT407.1 v1(23.68,80.03) ; RT95.2 27.36,86.68 v1(27.56,86.89) ; v1(39.02,85.97) 38.66,86.33 RT405.1 ; v1(41.53,86.76) 41.53,86.38 41.03,85.87 CT84.1 ; RT98.2 v1(32.71,74.25) ; RT406.1 v1(25.28,82.11)
  IN3 w0.508: v1(27.56,86.89) 27.56,83.33 26.34,82.11 v1(25.28,82.11) 25.28,80.27 v1(25.84,79.71) 30.28,75.27 31.69,75.27 v1(32.71,74.25)
  IN4 w0.508: v1(23.68,80.03) 24,79.71 v1(25.84,79.71)
  BOTTOM w0.381: RT106.2 32.45,83.51 v1(32.27,83.69) ; RT67.2 36.47,83.39 35.88,83.39 35.12,82.63 RT107.2
  BOTTOM w0.508: v1(25.84,79.71) 25.84,80.23 26.14,80.54 RT76.2 ; RT67.2 37.41,83.72 v1(37.41,83.9) 37.41,85.5 37.88,85.97 v1(39.02,85.97) 39.81,86.76 v1(41.53,86.76) ; v1(35.18,88.08) 35.18,88.16 33.61,89.73 RT50.1 RT51.1 RT52.1 RT53.1
  vias: v1(33.08,97.31) v1(33.66,96.98)
+3.3V_TP: length 9.3
  TOP w0.254: v1(214.38,21.71) 214.91,21.71 RZ19.1
  TOP w0.381: 219.08,23.82 RZ116.1 ; 219.08,23.82 219.36,23.54 220.4,23.54 220.86,24 RZ20.1 RZ21.1 220.86,25.9 220.45,26.31 v3(220.05,26.31) 219.84,26.31 219.08,25.55 RZ117.1 ; 219.08,23.82 219.08,23.79 218.37,23.08 v1(217.94,23.08)
  vias: v1(216.79,18.88) v1(217.43,18.88)
+3.3V_USB_UI5: length 37
  TOP w0.102: v2(314.1,66.74) 313.43,67.42 v1(313.43,68.18)
  TOP w0.254: CI37.1 304.07,60.04 304.07,59.91 302.88,58.72 UI5.13 ; UI5.1 300.38,53.84 CI38.1
  TOP w0.508: CI38.1 298.79,52.67 v1(298.56,52.9) ; RI80.2 RI79.2 313.47,68.22 v1(313.43,68.18) ; CI37.1 304.77,60.56 304.77,59.2 v1(304.47,58.9)
  IN1 w0.508: v1(313.43,68.18) 313.43,67.46 312.32,66.35 311.68,66.35 310.99,65.66 310.12,65.66 309.51,65.05 308.71,65.05 308.54,64.88 307.69,64.88 307.04,64.23 307.04,63.34 306.02,62.33 306.02,61.43 304.84,60.26 304.84,60.06 304.77,59.99 304.77,59.2 304.47,58.9 v1(304.47,58.9)
  IN4 w0.508: v1(304.47,58.9) 304.46,58.9 304.19,58.62 300.4,58.62 299.35,57.57 299.35,55.77 298.56,54.98 v1(298.56,52.9)
+3.3V_VCCHDA: length 1.5
  TOP w0.381: v1(126.41,54.64) 126.36,54.69 CC313.1
  BOTTOM w0.254: v1(126.41,54.64) 126.74,54.96 UC1.AJ19
  vias: v1(125.36,31.82) v1(125.37,31.21) v2(126.32,31.35)
+3.3V_VDD_DCIN: length 14.7
  TOP w0.102: v1(73.07,104.89) v2(72.51,104.89)
  TOP w0.508: v1(63.71,107.14) 63.27,107.59 PR17.1 ; PC10.1 73.23,104.73 v1(73.07,104.89)
  IN4 w0.508: v1(63.31,97.68) 64.65,99.01 68.08,99.01 v1(68.33,98.76)
  BOTTOM w0.457: PR27.2 v1(68.33,98.76)
  BOTTOM w0.508: PD1801.3 63.6,107.03 v1(63.71,107.14) ; v1(63.31,97.68) 63.31,97.3 62.77,96.75 PC9.1 62.5,96.09 PU1.5 ; PR1208.1 v1(65.67,112.18) ; PR1206.1 v1(63.89,109.59)
+3.3V_VDD_PIC: length 86.2
  TOP w0.254: v1(38.93,80.41) 38.3,80.41 38.04,80.66 QT1.2 ; PR1214.1 v1(18.3,31.02) ; v1(38.33,83.89) 38.04,83.6 QT1.5
  TOP w0.381: PR1226.1 v1(23.25,31.2) ; PR1253.1 v1(11.05,31.26) ; v1(20.71,39.26) v2(20.71,36.85) 18.79,34.94 PU1200.5
  TOP w0.508: PC1204.1 16.93,55.83 PR1236.2 17.79,56.3 18.29,56.81 v1(21.95,56.81) ; PR1254.2 v1(18.95,39.36) ; PR1240.1 v1(67.54,102.21)
  TOP w1.016: 42.82,100.58 42.11,101.29 28.64,101.29
  IN3 w0.762: v1(18.95,39.36) 18.95,45.67 18.23,46.4 18.23,51.14 18.95,51.86 18.95,53.81 v1(21.95,56.81) 23.17,58.02 23.18,58.02 32.44,67.29 32.44,70.17 36.33,74.06 36.33,74.88 37.09,75.65 37.09,76.79 38.17,77.87 38.17,80.22
  BOTTOM w0.508: v1(67.54,102.21) 68.73,102.21 69.24,102.72 PR1237.1 ; PD1801.2 v1(62.48,104.95)
  vias: v1(27.09,101.69) v1(27.74,101.69) v1(31.82,88.92) v1(32.45,88.92) v1(41.23,88.03) v1(41.23,87.39) v1(42.51,99.73) v1(43.23,99.77)
+3.3V_VDD_PIC_PDA: length 10.2
  TOP w0.102: v2(30.08,87.44) 30.59,86.94 30.82,86.94
  TOP w0.203: 31.34,84.26 31.64,83.95 UT5.H1 ; UT5.B1 v1(34.64,83.59)
  TOP w0.381: CT74.1 30.92,84.8 31.34,84.38 31.34,84.26
  IN1 w0.508: v1(31.95,87.01) 31.76,86.82 31.76,85.87 32.58,85.04 33.91,85.04 34.64,84.31 v1(34.64,83.59)
+3.3V_VGA: length 2.1
  TOP w0.203: UV6.1 275.79,56.47 275.8,56.49 v1(275.8,56.95)
  BOTTOM w0.127: v1(275.8,56.95) v2(275.8,57.63)
  BOTTOM w0.508: LV14.2 275.6,56.74 v1(275.8,56.95)
+3.3V_WLAN: length 1.7
  TOP w0.127: 214.13,5.1 214.13,3.96 v3(213.75,3.57)
  vias: v1(193.89,11.37) v1(193.89,10.79) v1(193.86,10.19) v1(194.49,11.38) v1(194.49,10.8) v1(194.49,10.19) v1(213.5,7.67) v1(213.53,7.01) v1(213.54,6.37) v1(214.17,7.63) v1(214.19,6.32) v1(214.2,6.98) v3(194.49,9.54) v3(213.16,8.17)
+3.3V_WLAN_UZ4:
  vias: v2(193.93,14.75)
+3.3V_WWAN: length 20.8
  TOP w0.127: v3(285.37,58.69) 285.74,59.06 v1(285.96,59.06)
  TOP w0.254: CZ134.1 284.61,66.13 UZ36.24 ; UZ36.12 288.55,61.62 288.68,61.49 288.93,61.49 v1(289.31,61.87)
  TOP w0.381: RZ360.1 290.97,65.79 v1(290.58,66.19)
  TOP w0.508: RZ154.1 282.42,61.3 v1(282.27,61.15) ; RZ43.2 288.55,49.6 288.15,49.2 288.15,48.32 287.5,47.67 287.06,47.67 v1(287.06,47.67) ; v1(284.74,66.95) CZ134.1
  BOTTOM w0.381: v1(285.96,59.06) 286.1,59.2 RZ156.1 RZ160.1 ; v1(288.8,69.28) 289.06,69.28 289.81,68.53 RZ164.1 RZ358.1 ; CZ133.1 289.18,61.99 v1(289.31,61.87)
  BOTTOM w0.457: v1(293.88,63.65) RZ166.1 RZ158.1
  BOTTOM w0.508: v1(291.22,60.09) 290.8,59.67 RZ162.1 ; v1(285.96,69.26) 285.96,68.9 286.03,68.83 RZ354.1 RZ356.1
  vias: v1(282.84,49.36) v1(283.26,49.79) v1(283.42,49.19) v1(283.67,50.21) v1(283.88,49.55) v1(284.26,50) v1(304.12,48.21) v1(304.14,47.63) v1(304.75,48.21) v1(304.78,47.63)
+5V_ALW: length 309.9
  TOP w0.203: v1(275.04,76.3) 275.04,76.25 274.96,76.17 UZ5.4 ; UZ4.4 v1(189.82,16.53)
  TOP w0.254: PR691.1 65.33,75.35 PR689.1 PC697.1 67.06,74.08 v1(67.06,74.03) ; v1(196.38,17.72) 196.65,17.45 196.65,17.37 196.83,17.19 196.83,15.75 195.62,14.55 195.62,11.49 196.02,11.09 196.02,10.69 195.48,10.14 195.48,9.6 197.15,7.93 197.75,7.93 198.46,7.22 200.76,7.22 201.15,7.61 UZ3.4 ; v1(58.63,58.01) 58.63,58.32 58.16,58.79 PR681.1 57.46,59.07 57.46,59.76 PR680.1 ; v1(269.6,52.16) 269.9,52.16 UZ8.4 ; JUSH1.18 222.6,15.65 222.26,15.31 222.26,15.21 221.72,14.67 CZ64.1 220.83,14.47 CZ69.1 219.92,14.72 v1(219.92,15.16) ; PR688.1 57.94,69.55 PR686.1 58.76,68.37 PC661.1 58.78,67.76 v1(58.98,67.56)
  TOP w0.305: v1(284.81,50.26) 284.4,50.67 JLED1.1
  TOP w0.381: RI13.2 304.24,63.04 v1(304.11,63.04)
  TOP w0.508: LED3.2 v1(319.4,97.5) ; v1(273.98,50.28) 274.93,49.32 274.93,49.17 277.16,46.94 277.75,46.94 278.5,46.19 278.5,45.74 279.86,44.37 v1(280.57,44.37) ; PR602.2 v1(75.23,46.2) ; v1(62.93,57.55) 62.93,56.57 63.4,56.1 PR615.2 PR634.2 ; RA53.2 v1(303.79,27.58) ; PR7.1 v1(62.03,93.51)
  IN1 w0.508: v1(131.37,80.74) 130.95,81.17 130.95,84.41 132.51,85.97 136.61,85.97 137.11,86.48 137.11,86.99 138.54,88.41 138.54,90.05 139.27,90.79 139.27,92.18 v1(139.5,92.41) ; v1(311.02,61.89) 312.24,60.66 314.52,60.66 317.06,63.2 318.84,63.2 319.49,63.85 319.49,81.86 317.1,84.24 317.1,88.26 317.95,89.11 317.95,92.23 317.29,92.88 v1(316.57,92.88) 316.57,94.67 v1(319.4,97.5) ; v1(303.79,27.58) 306.2,27.58 307.18,26.6 307.18,24.87 306.18,23.87 266.76,23.87 v1(266.32,24.3) ; v1(67.06,74.03) 68.36,74.03 69.8,75.48 69.8,79.01 70.08,79.29 70.08,82.01 v1(69.17,82.92)
  IN2 w0.305: v1(269.6,52.16) 270.74,52.16 271.99,50.92 273.47,50.92 273.98,50.41 v1(273.98,50.28)
  IN2 w0.508: v1(275.04,76.3) 275.29,76.3 276.02,77.03 276.02,79.14 276.53,79.65 281.62,79.65 283.32,81.35 283.32,82.12 284.87,83.66 284.87,84.09 284.43,84.53 284.43,85.35 284.94,85.86 285.5,85.86 286.49,86.85 286.49,88.33 285.51,89.31 285.51,91.27 287.25,93.01 291.52,93.01 292.32,93.81 300.67,93.81 302,92.49 308.5,92.49 308.89,92.88 v1(316.57,92.88)
  IN3 w0.508: v1(75.23,46.2) 73.52,46.2 71.97,47.75 67.3,47.75 65.95,49.1 60.77,49.1 59.95,49.93 v1(59.95,52.79) ; v1(129.1,81.98) 130.44,81.98 131.37,81.04 v1(131.37,80.74)
  BOTTOM w0.203: v1(273.98,50.28) 274.07,50.18 UZ2.4
  BOTTOM w0.254: v1(189.82,16.53) 188.63,16.53 188.12,17.04 v1(185.92,17.04) ; PC685.1 69.09,83.71 68.77,84.03 PU614.6 ; PU612.15 58.92,58.3 v1(58.63,58.01) PC668.1 ; UZ23.4 277.57,42.46 v1(277.57,42.74) ; UZ19.3 130.53,81.17 130.96,80.74 v1(131.37,80.74) ; UZ21.3 128.64,82.43 v1(129.1,81.98) ; v1(58.98,67.56) 59.05,67.62 PU610.15 ; PU613.15 v1(66.26,74.03)
  BOTTOM w0.508: v1(69.17,82.92) 69.09,83 PC685.1 ; v1(255.35,28.14) 255.91,27.58 258.96,27.58 261.96,24.58 263.9,24.58 264.42,25.1 265.95,25.1 266.32,24.73 v1(266.32,24.3) ; v1(136.28,115.08) 137.72,113.63 137.72,103.14 139.88,100.98 139.88,100.6 140.42,100.07 140.42,97.81 139.5,96.9 v1(139.5,92.41)
  vias: v1(24.71,74.88) v1(24.71,74.27) v1(25.34,74.88) v1(25.34,74.27) v1(35.89,99.48) v1(35.88,97.86) v1(36.55,99.48) v1(36.59,97.86) v1(37.23,99.48) v1(37.23,97.86) v1(83.09,101.19) v1(83.49,100.7) v1(84.08,100.7) v1(84.61,101.06) v1(127.75,29.43) v1(128.01,28.7) v1(128.33,29.22) v1(134.54,114.82) v1(135.2,114.83) v1(135.2,114.19) v1(135.58,115.97) v1(135.58,115.33) v1(165.49,99.52) v1(165.49,98.89) v1(166.18,99.52) v1(166.18,98.89) v1(166.18,98.25) v1(166.88,99.52) v1(166.88,98.89) v1(166.88,98.25) v1(167.58,99.52) v1(167.58,98.89) v1(167.58,98.25) v1(168.28,99.52) v1(168.28,98.89) v1(168.28,98.25) v1(185.29,17.67) v1(185.29,17.04) v1(185.92,17.67) v1(191.08,23.83) v1(191.09,23.19) v1(191.08,22.6) v1(191.68,23.83) v1(191.68,23.2) v1(191.73,22.59) v1(192.23,23.58) v1(192.27,22.91) v1(277.04,41.38) v1(277.21,40.28) v1(305.43,60.01) v1(305.68,59.44) v1(306.03,60) v1(306.36,60.49) v1(306.34,59.45) v1(309.83,62.72) v1(309.97,62.14) v1(309.98,61.5) v1(311.16,62.53) v3(38.49,98.82) v3(185.81,18.69) v3(187.53,21.38)
+5V_ALW2: length 3.1
  TOP w0.102: v3(169.93,112.67) v1(169.93,113.37)
  BOTTOM w0.254: PU102.15 169.58,113.72 v1(169.93,113.37) 170.63,112.67 PC126.1
+5V_ALW_PDA: length 1
  TOP w0.203: v1(33.64,77.55) UT5.D11 ; UT5.H10 31.64,78.99 v1(31.72,79.06)
  vias: v1(34.49,76.95) v1(34.62,77.54) v1(35.12,76.95) v1(35.3,77.52) v1(38.68,92.83) v1(38.82,92.25) v1(39.28,92.83) v1(41.05,92.76) v1(41.74,92.78) v1(45.8,92.91) v1(46.44,92.91) v2(44.84,93.74)
