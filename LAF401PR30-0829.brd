# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D21: length 60.3
  IN4 w0.076: 95.31,47.31 95.31,47.77 95.48,47.95 95.48,49.75 96.49,50.75 96.49,51.6 96.89,52 96.89,53.77 98.91,55.8 v1(99.78,55.8)
  IN4 w0.089: v1(90.01,9.59) 90.01,8.73 89.92,8.64 89.41,8.64 89.29,8.76 89.29,9.44 89.58,9.74 89.58,10.85 89.28,11.15 89.28,13.03 88.85,13.46 88.85,15.87 89.59,16.6 89.59,35.87 89.75,36.03 90.43,36.03 90.59,36.19 90.59,36.42 90.43,36.58 89.75,36.58 89.59,36.74 89.59,36.94 91.84,39.19 91.84,41.15 93.63,42.94 93.63,45.64 95.31,47.31
  BOTTOM w0.076: v1(99.78,55.8) UC1.AF67
  BOTTOM w0.102: JDIMM1.191 88.78,10.83 v1(90.01,9.59)
DDR_A_D22: length 58.5
  IN4 w0.076: 96.15,45.14 96.46,45.45 96.46,46.2 97.08,46.82 97.08,49.01 97.45,49.38 97.45,50.88 97.94,51.37 97.94,52.47 99.44,53.97 v1(99.78,53.97)
  IN4 w0.089: v1(92.17,10.61) 91.75,11.03 91.75,19.6 91.91,19.77 92.6,19.77 92.76,19.93 92.76,20.15 92.6,20.31 91.91,20.31 91.75,20.47 91.75,20.7 91.91,20.86 92.6,20.86 92.76,21.02 92.76,21.24 92.6,21.4 91.91,21.4 91.75,21.56 91.75,21.79 91.91,21.95 92.6,21.95 92.76,22.11 92.76,22.34 92.6,22.5 91.91,22.5 91.75,22.66 91.75,22.88 91.91,23.04 92.6,23.04 92.76,23.2 92.76,23.43 92.6,23.59 91.91,23.59 91.75,23.75 91.75,23.97 91.91,24.13 92.6,24.13 92.76,24.29 92.76,24.52 92.6,24.68 91.91,24.68 91.75,24.84 91.75,25.18 92.66,26.09 92.66,30.82 93.98,32.14 93.98,39.24 95.69,40.95 95.69,44.68 96.15,45.14
  BOTTOM w0.076: v1(99.78,53.97) UC1.AK67
  BOTTOM w0.102: v1(92.17,10.61) 92.78,11.21 JDIMM1.207
DDR_A_D23: length 59
  IN4 w0.076: 96.78,45.57 96.78,46.12 97.26,46.61 97.26,48.94 97.64,49.32 97.64,50.74 98.12,51.22 98.12,52.35 99.37,53.6 100.05,53.6 v1(100.42,53.97)
  IN4 w0.089: v1(93.55,6.77) 93.54,6.78 91.29,6.78 91.2,6.87 91.2,7.2 91.29,7.29 92.33,7.29 92.59,7.55 92.59,11.61 92.05,12.14 92.05,12.5 92.21,12.66 92.45,12.66 92.61,12.82 92.61,13.04 92.45,13.2 92.21,13.2 92.05,13.36 92.05,13.59 92.21,13.75 92.45,13.75 92.61,13.91 92.61,14.14 92.45,14.3 92.21,14.3 92.05,14.46 92.05,18.22 93.06,19.22 93.06,30.55 94.37,31.86 94.37,38.9 96.78,41.31 96.78,45.57
  BOTTOM w0.076: v1(100.42,53.97) UC1.AK66
  BOTTOM w0.102: JDIMM1.208 93.03,6.25 v1(93.55,6.77)
DDR_A_D24: length 67.3
  IN4 w0.089: v1(87.97,6.92) 87.97,6.87 87.74,6.63 86.96,6.63 86.87,6.72 86.87,7.37 86.78,7.47 86.42,7.47 86.33,7.38 86.33,6.64 86.22,6.53 85.89,6.53 85.79,6.63 85.79,8.63 86.57,9.41 86.57,11 86.13,11.45 85.95,11.45 84.87,12.53 84.87,16.07 86.44,17.64 86.44,18.67 85.65,19.46 85.65,30.07 86.73,31.15 86.73,39.6 90.99,43.86 90.99,50.26 91.7,50.97 91.7,52.14 92.08,52.52 93.76,52.52 94.14,52.9 94.14,56.05 v1(93.63,56.56)
  BOTTOM w0.076: v1(93.63,56.56) 94.23,57.16 96.67,57.16 97.27,56.56 UC1.AF70
  BOTTOM w0.102: JDIMM1.186 87.53,6.47 v1(87.97,6.92)
DDR_A_D25: length 69
  IN4 w0.089: v1(92.43,56.54) 91.28,55.39 88.75,55.39 82.53,49.17 82.53,17.94 79.89,15.3 79.89,9.33 82.55,6.67 v1(84.92,6.67)
  BOTTOM w0.076: UC1.AF68 98.25,56.73 98.18,56.75 97.95,56.75 97.83,56.87 97.19,56.87 96.74,57.32 93.21,57.32 v1(92.43,56.54)
  BOTTOM w0.102: v1(84.92,6.67) 84.92,6.65 84.53,6.26 JDIMM1.174
DDR_A_D26: length 66.6
  IN4 w0.089: v1(84.54,10.46) 84.34,10.66 83.97,10.66 83.76,10.45 83.76,9.57 83.67,9.48 83.33,9.48 83.22,9.59 83.22,11.28 83.47,11.52 83.47,12.07 83.33,12.21 81.99,12.21 81.85,12.35 81.85,12.54 81.99,12.68 83.33,12.68 83.47,12.82 83.47,13.01 83.33,13.15 81.99,13.15 81.85,13.29 81.85,13.48 81.99,13.62 83.33,13.62 83.47,13.76 83.47,48.71 89.01,54.25 91.79,54.25 v1(92.46,54.92)
  BOTTOM w0.076: v1(92.46,54.92) 92.86,54.52 94.73,54.52 95,54.8 95.93,54.8 96.37,55.23 UC1.AH71
  BOTTOM w0.102: JDIMM1.173 84.28,11.52 84.16,11.4 84.16,10.84 v1(84.54,10.46)
DDR_A_D27: length 69
  IN4 w0.089: v1(87.73,10.61) 87.73,10.72 87.58,10.87 87.58,12.42 86.32,13.68 86.32,15.3 86.7,15.68 86.7,15.87 86.48,16.09 86.48,16.29 86.61,16.43 86.81,16.43 87.03,16.21 87.22,16.21 87.36,16.34 87.36,16.54 87.14,16.76 87.14,16.95 87.28,17.09 87.47,17.09 87.69,16.87 87.89,16.87 88.2,17.18 88.2,17.52 88.04,17.68 87.61,17.68 87.45,17.84 87.45,18.06 87.61,18.22 88.04,18.22 88.2,18.38 88.2,18.61 88.04,18.77 87.61,18.77 87.45,18.93 87.45,19.16 87.61,19.32 88.04,19.32 88.2,19.48 88.2,19.88 88.04,20.04 87.14,20.04 86.98,20.2 86.98,20.43 87.14,20.59 87.9,20.59 88.06,20.75 88.06,20.97 87.9,21.13 87.14,21.13 86.98,21.29 86.98,21.52 87.14,21.68 88.04,21.68 88.2,21.84 88.2,38.13 88.36,38.29 88.73,38.29 88.89,38.45 88.89,38.68 88.73,38.84 88.36,38.84 88.2,39 88.2,39.59 88.37,39.77 88.6,39.77 89.1,39.27 89.32,39.27 89.48,39.43 89.48,39.66 88.99,40.16 88.99,40.38 89.15,40.54 89.37,40.54 89.87,40.04 90.1,40.04 90.26,40.2 90.26,40.43 89.76,40.93 89.76,41.16 91.9,43.3 91.9,48.48 93.2,49.77 93.2,50.16 95.08,52.05 95.08,55.5 v1(95.26,55.68)
  BOTTOM w0.076: UC1.AH68 98.79,55.89 98.58,56.09 98.13,56.09 98.03,56.16 97.72,56.16 97.59,56.12 97.36,56.12 97.35,56.13 97.35,56.13 97.35,56.13 97.26,56.16 97.06,56.16 96.97,56.13 96.61,56.13 96.56,56.18 95.64,56.18 95.26,55.8 v1(95.26,55.68)
  BOTTOM w0.102: JDIMM1.183 86.78,11.43 87.6,10.61 v1(87.73,10.61)
DDR_A_D28: length 66.6
  IN4 w0.089: v1(87.98,8.19) 87.22,8.19 87.16,8.13 87.16,7.97 87.08,7.88 86.73,7.88 86.62,7.99 86.62,8.98 86.88,9.25 86.88,12.14 86.39,12.63 86.16,12.63 85.83,12.3 85.59,12.3 85.43,12.46 85.43,12.67 85.78,13.02 85.78,13.24 85.27,13.75 85.27,16.02 86.75,17.5 86.75,19.42 86,20.18 86,27.81 86.09,27.9 87.16,27.9 87.27,28.01 87.27,28.34 87.16,28.45 86.06,28.45 85.97,28.54 85.97,29.71 87.12,30.86 87.12,39.56 91.29,43.73 91.29,50.13 92.02,50.85 93,50.85 94.44,52.3 94.44,56.41 v1(94.29,56.56)
  BOTTOM w0.076: v1(94.29,56.56) 94.29,56.68 94.6,56.99 96.4,56.99 UC1.AF71
  BOTTOM w0.102: v1(87.98,8.19) 86.53,6.74 JDIMM1.182
DDR_A_D29: length 68.2
  IN4 w0.089: v1(87.73,9.34) 87.73,9.12 87.61,9 87.35,9 87.25,9.11 87.25,12.24 85.63,13.86 85.63,15.87 87.15,17.39 87.15,19.49 86.61,20.03 86.61,21.9 87.85,23.14 87.85,23.57 87.69,23.73 86.57,23.73 86.41,23.89 86.41,24.11 86.57,24.27 87.56,24.27 87.71,24.43 87.71,24.65 87.54,24.82 86.57,24.82 86.41,24.98 86.41,25.21 86.57,25.37 87.69,25.37 87.85,25.53 87.85,25.75 87.69,25.91 86.57,25.91 86.41,26.07 86.41,26.3 86.57,26.46 87.69,26.46 87.85,26.62 87.85,39.76 91.6,43.5 91.6,49.98 92.17,50.55 93.16,50.55 94.75,52.14 94.75,54.93 94.76,54.94 94.76,55.81 v1(95.47,56.52)
  BOTTOM w0.076: v1(95.47,56.52) 96.45,56.52 96.68,56.29 96.94,56.29 97.03,56.33 97.04,56.33 97.29,56.33 97.38,56.29 97.59,56.29 97.67,56.32 97.67,56.32 97.77,56.36 98.03,56.36 UC1.AF69
  BOTTOM w0.102: v1(87.73,9.34) 88.43,10.04 88.43,11.55 87.78,12.21 JDIMM1.187
DDR_A_D30: length 67.3
  IN4 w0.089: v1(84.54,9.21) 84.54,8.01 84.42,7.89 83.94,7.89 83.85,7.98 83.85,8.8 83.58,9.07 82.75,9.07 82.33,9.5 82.33,10.15 80.93,11.55 80.93,15.09 83.16,17.32 83.16,48.91 88.83,54.58 90.26,54.58 v1(90.66,54.98)
  BOTTOM w0.076: UC1.AH70 97.34,55.09 97.28,55.06 97.19,55.09 96.99,54.99 96.94,54.97 96.34,54.97 96,54.63 95.07,54.63 94.76,54.32 92.26,54.32
  BOTTOM w0.102: JDIMM1.169 83.28,10.47 v1(84.54,9.21) ; v1(90.66,54.98) 91.31,54.32 92.26,54.32
DDR_A_D31: length 68.2
  IN4 w0.089: v1(84.93,7.94) 84.31,7.32 83.39,7.32 80.4,10.31 80.4,15.23 82.86,17.7 82.86,49.07 88.77,54.98 v1(89.33,54.98)
  BOTTOM w0.076: UC1.AH69 97.93,55.23 97.54,54.84 97.05,54.84 96.16,54.41 95.09,54.41 94.77,54.09 92.08,54.09
  BOTTOM w0.102: v1(84.93,7.94) 83.53,6.53 JDIMM1.170 ; 92.08,54.09 91.82,53.83 90.47,53.83 v1(89.33,54.98)
DDR_A_D32: length 74.9
  IN1 w0.089: v1(96.17,43.15) 95.69,42.67 95.69,42.51 90.61,37.43 80.12,37.43 79.02,36.34 74.28,36.34 72.44,34.5 70.49,34.5 67.73,31.74 67.73,31.3 62.68,26.24 62.68,24.55 52.89,14.76 52.89,8.14 52.69,7.94 v1(52.04,7.94)
  BOTTOM w0.076: UC1.BB65 100.49,46.98 100.49,46.14 99.64,45.29 97.7,45.29 96.86,44.44 96.86,43.84 v1(96.17,43.15)
  BOTTOM w0.102: JDIMM1.46 50.52,6.85 51.61,7.94 v1(52.04,7.94)
DDR_A_D33: length 76.6
  IN1 w0.076: v1(97.69,43.43) 97.37,43.43 96.78,42.83 96.78,41.15 96.34,40.71 96.08,40.71
  IN1 w0.089: v1(53.94,7.94) 53.94,8.64 54.95,9.64 54.95,14.55 68.34,27.95 68.34,29.49 71.58,32.73 72.54,32.73 73.26,33.44 74.21,33.44 75.75,34.99 79.55,34.99 80.67,36.11 91.27,36.11 95.88,40.71 96.08,40.71
  BOTTOM w0.076: v1(97.69,43.43) 97.39,43.73 97.39,44.16 98,44.77 100.08,44.77 101.64,46.33 101.64,46.66 101.49,46.81 101.49,47.23 101.53,47.34 101.53,47.46 101.47,47.68 101.47,47.82 101.52,47.98 101.52,48.16 101.45,48.32 101.45,48.83 101.24,49.04 UC1.AW65
  BOTTOM w0.102: v1(53.94,7.94) 54.57,7.31 54.57,6.32 54.52,6.27 JDIMM1.62
DDR_A_D34: length 77.6
  IN1 w0.076: 96.22,39.56 96.39,39.56 v1(97.8,40.96)
  IN1 w0.089: 96.22,39.56 96.03,39.56 91.66,35.19 81.09,35.19 80.81,34.91 80.81,34.63 80.9,34.54 81.8,34.54 81.9,34.44 81.9,34.19 81.74,34.03 76.09,34.03 74.59,32.53 73.64,32.53 72.75,31.65 72.75,31.45 73.04,31.17 73.04,30.97 72.9,30.84 72.7,30.84 72.42,31.12 72.23,31.12 72.09,30.98 72.09,30.79 72.37,30.5 72.37,30.31 72.23,30.17 72.04,30.17 71.76,30.45 71.56,30.45 71.33,30.22 71.33,29.43 56.61,14.7 56.61,14.51 56.82,14.3 56.82,14.12 56.62,13.92 56.39,13.92 56.17,14.14 56.05,14.14 55.89,13.98 55.89,13.63 56.05,13.47 56.32,13.47 56.48,13.31 56.48,13.08 56.32,12.92 56.05,12.92 55.89,12.76 55.89,12.01 56.48,11.41 56.48,10.69 56.39,10.61 v1(56.1,10.61)
  BOTTOM w0.076: v1(97.8,40.96) 98.58,41.75 98.58,43.63 99.06,44.11 100.36,44.11 102.35,46.1 102.35,47.74 102.13,47.96 102.13,48.51 101.82,48.82 UC1.AW63
  BOTTOM w0.102: v1(56.1,10.61) 54.78,11.93 JDIMM1.63
DDR_A_D35: length 76.3
  IN1 w0.089: v1(51.46,10.82) 51.46,13.17 51.85,13.56 51.85,16.76 59.01,23.92 59.23,23.92 59.54,23.61 59.77,23.61 59.93,23.77 59.93,24 59.62,24.3 59.62,24.53 59.78,24.69 60.01,24.69 60.2,24.5 60.44,24.5 60.6,24.66 60.6,24.87 60.39,25.08 60.39,25.3 66.56,31.46 66.56,31.88 70.13,35.46 72.1,35.46 73.9,37.25 78.08,37.25 79.21,38.38 88.43,38.38 90.21,38.38 94.56,42.74 94.56,43.04 95.43,43.91 95.43,44.15 96.01,44.72 97.11,44.72 v1(97.8,44.04)
  BOTTOM w0.076: UC1.AY63 101.72,48.28 101.72,48.03 101.64,47.81 101.64,47.68 101.71,47.45 101.71,47.31 101.65,47.19 101.65,46.93 101.83,46.75 101.83,46.28 100.15,44.6 98.36,44.6 v1(97.8,44.04)
  BOTTOM w0.102: JDIMM1.45 50.27,12 v1(51.46,10.82)
DDR_A_D36: length 75.5
  IN1 w0.089: v1(96.14,43.73) 95.34,42.93 95.34,42.59 90.49,37.74 79.76,37.74 78.67,36.64 74.15,36.64 72.31,34.8 70.34,34.8 67.17,31.63 67.17,31.21 62.13,26.17 62.13,24.59 52.58,15.05 52.58,9.07 52.37,8.86 52.1,8.86 51.93,9.03 51.67,9.03 51.51,8.87 51.51,8.68 51.74,8.45 51.74,8.23 51.53,8.02 51.53,7.04 v1(51.69,6.88)
  BOTTOM w0.076: UC1.BA65 100.59,47.59 100.45,47.45 100.45,47.44 100.44,47.44 100.33,47.19 100.33,46.21 99.57,45.46 97.59,45.46 96.65,44.52 96.65,44.24 v1(96.14,43.73)
  BOTTOM w0.102: JDIMM1.50 51.52,6.16 51.69,6.32 v1(51.69,6.88)
DDR_A_D37: length 75.9
  IN1 w0.089: v1(52.04,11.6) 52.04,12.04 52.18,12.18 52.18,16.65 52.73,17.21 52.96,17.21 53.38,16.79 53.6,16.79 53.76,16.96 53.76,17.18 53.35,17.6 53.35,17.82 53.51,17.98 53.73,17.98 54.05,17.67 54.26,17.67 54.42,17.83 54.42,18.06 54.12,18.37 54.12,18.6 54.28,18.76 54.5,18.76 54.92,18.34 55.15,18.34 55.31,18.5 55.31,18.73 54.89,19.14 54.89,19.37 55.05,19.53 55.28,19.53 55.69,19.11 55.92,19.11 56.15,19.35 56.15,19.51 55.93,19.74 55.93,19.86 56.14,20.07 56.26,20.07 56.46,19.87 56.68,19.87 57.02,20.22 57.02,20.22 61.56,24.75 61.56,26.04 66.86,31.34 66.86,31.75 70.21,35.11 72.19,35.11 74.03,36.95 78.36,36.95 79.49,38.07 88.31,38.07 90.33,38.07 94.95,42.7 94.95,42.98 95.73,43.76 95.73,43.9 v1(96.17,44.34)
  BOTTOM w0.076: UC1.AY65 100.59,48.18 100.33,47.92 100.33,47.63 100.27,47.5 100.27,47.46 100.24,47.39 100.16,47.23 100.16,46.28 99.5,45.62 97.45,45.62 v1(96.17,44.34)
  BOTTOM w0.102: JDIMM1.49 51.27,12.05 51.5,11.82 51.81,11.82 v1(52.04,11.6)
DDR_A_D38: length 76.2
  IN1 w0.076: 96.04,39.86 96.24,39.86 97.36,40.97 97.36,42.09 97.53,42.26 v1(97.8,42.26)
  IN1 w0.089: 96.04,39.86 95.88,39.86 91.52,35.5 80.94,35.5 79.78,34.34 75.97,34.34 74.47,32.83 73.51,32.83 71.02,30.34 71.02,29.79 70.93,29.7 70.81,29.7 70.31,30.19 70.09,30.19 69.93,30.03 69.93,29.8 70.49,29.24 70.49,29.01 70.33,28.85 70.11,28.85 69.58,29.38 69.36,29.38 69.2,29.22 69.2,28.99 69.72,28.47 69.72,28.24 55.55,14.08 55.55,9.88 v1(56.1,9.34)
  BOTTOM w0.076: v1(97.8,42.26) 98.35,42.81 98.35,43.63 98.99,44.27 100.29,44.27 102.18,46.17 102.18,47.26 101.92,47.52 UC1.BA63
  BOTTOM w0.102: v1(56.1,9.34) 53.78,11.66 JDIMM1.59
DDR_A_D39: length 74.9
  IN1 w0.076: 96.05,40.27 96.28,40.27 97.06,41.05 97.06,42.32 97.58,42.84 v1(97.82,42.84)
  IN1 w0.089: v1(53.94,6.67) 53.72,6.89 53.13,6.89 53.02,7.01 53.02,7.29 53.14,7.41 54.35,7.41 54.44,7.5 54.44,8.53 55.25,9.34 55.25,14.37 68.67,27.79 68.67,29.39 71.7,32.42 72.67,32.42 73.39,33.14 74.34,33.14 75.84,34.64 79.65,34.64 80.81,35.8 91.39,35.8 95.86,40.27 96.05,40.27
  BOTTOM w0.076: v1(97.82,42.84) 98.13,43.15 98.13,43.64 98.92,44.44 100.22,44.44 102,46.21 102,47.01 UC1.BB63
  BOTTOM w0.102: JDIMM1.58 53.52,6.25 v1(53.94,6.67)
DDR_A_D40: length 74.3
  IN1 w0.076: 98.24,40.03 98.63,40.42 98.63,41.68 99.39,42.44 v1(99.39,42.44)
  IN1 w0.089: 98.24,40.03 92.5,34.29 83.28,34.29 82.1,33.11 76.45,33.11 58.91,15.57 58.91,14.8 57.55,13.44 57.43,13.33 57.43,9.39 57.96,8.86 57.96,8.2 57.87,8.1 57.61,8.1 57.34,8.36 57.13,8.36 56.02,7.25 55.1,7.25 54.95,7.1 54.95,6.73 55.06,6.62 v1(55.89,6.62)
  BOTTOM w0.076: UC1.BA61 102.95,47.51 102.68,47.25 102.68,45.96 99.78,43.06 99.78,42.83 v1(99.39,42.44)
  BOTTOM w0.102: v1(55.89,6.62) 55.52,6.26 JDIMM1.66
DDR_A_D41: length 75.6
  IN1 w0.076: 97.97,40.21 98.37,40.6 98.37,42.7 99.39,43.73 v1(99.39,43.74)
  IN1 w0.089: v1(56.1,7.94) 55.65,7.94 55.56,7.85 55.56,7.67 55.44,7.55 55.19,7.55 55.04,7.7 55.04,8.11 55.61,8.69 56.42,8.69 57.08,9.35 57.08,13.48 58.45,14.85 58.45,15.54 76.33,33.42 81.97,33.42 83.15,34.6 92.36,34.6 97.97,40.21
  BOTTOM w0.076: UC1.AW61 103.05,48.85 102.72,48.52 102.72,47.98 102.52,47.77 102.52,46.03 100.23,43.74 v1(99.39,43.74)
  BOTTOM w0.102: v1(56.1,7.94) 56.52,7.52 JDIMM1.70
DDR_A_D42: length 74.3
  IN1 w0.076: v1(101.3,40.68) 100.6,39.98 100.6,39.08 100.37,38.84
  IN1 w0.089: 100.37,38.84 97.96,36.43 97.96,33.73 97.66,33.43 97.47,33.43 97.29,33.61 97.1,33.61 96.96,33.47 96.96,33.28 97.14,33.1 97.14,32.91 97,32.77 96.8,32.77 96.63,32.95 96.43,32.95 96.29,32.81 96.29,32.61 96.47,32.44 96.47,32.24 96.33,32.1 96.14,32.1 95.96,32.28 95.77,32.28 95.63,32.14 95.63,31.95 95.81,31.77 95.81,31.58 95.52,31.29 83.67,31.29 82.66,30.27 79.71,30.27 78.89,29.45 75.95,29.45 61.55,15.04 61.55,13.69 61.01,13.15 61.01,12.95 61.48,12.49 61.48,12.29 61.34,12.15 61.15,12.15 60.68,12.62 60.48,12.62 60.17,12.31 60.17,10.4 v1(60.85,9.72)
  BOTTOM w0.076: UC1.BB59 104.37,46.98 104.37,46.3 104.13,46.06 104.13,45.48 102.22,43.57 102.22,41.6 v1(101.3,40.68)
  BOTTOM w0.102: v1(60.85,9.72) 58.78,11.8 JDIMM1.79
DDR_A_D43: length 76.4
  IN1 w0.076: 100.18,39.13 100.33,39.28 100.33,41.01 v1(101.3,41.98)
  IN1 w0.089: 100.18,39.13 97.62,36.58 97.62,34.57 97.25,34.2 97.06,34.2 96.85,34.4 96.66,34.4 96.52,34.26 96.52,34.07 96.72,33.86 96.72,33.67 94.65,31.59 83.34,31.59 82.33,30.57 80.16,30.57 79.62,31.11 77.19,31.11 61.19,15.12 61.19,13.76 59.81,12.38 59.81,10.2 60.93,9.08 60.93,8.36 60.52,7.95 v1(59.53,7.95)
  BOTTOM w0.076: v1(101.3,41.98) 100.91,42.37 100.91,43.48 103.18,45.75 103.18,46.66 103.38,46.86 103.38,47.22 103.38,47.22 103.34,47.31 103.34,47.51 103.38,47.6 103.38,47.6 103.38,47.6 103.39,47.61 103.39,47.84 103.34,47.97 103.34,48.22 103.42,48.32 103.42,48.83 103.62,49.04 UC1.AW59
  BOTTOM w0.102: v1(59.53,7.95) 60.03,7.46 JDIMM1.84
DDR_A_D44: length 73.8
  IN1 w0.076: v1(99.42,41.76) 98.91,41.25 98.91,40.22 98.59,39.9
  IN1 w0.089: v1(58.36,9.11) 58.44,9.18 58.44,9.76 58.27,9.92 57.98,9.92 57.83,10.08 57.83,13.29 59.29,14.75 59.29,15.52 76.58,32.81 82.23,32.81 83.4,33.99 86.27,33.99 86.72,33.53 86.97,33.53 87.42,33.99 87.95,33.99 88.11,33.83 88.11,33.52 88.27,33.36 88.49,33.36 88.65,33.52 88.65,33.83 88.81,33.99 89.04,33.99 89.2,33.83 89.2,33.52 89.36,33.36 89.59,33.36 89.75,33.52 89.75,33.83 89.91,33.99 90.13,33.99 90.29,33.83 90.29,33.52 90.45,33.36 90.68,33.36 90.84,33.52 90.84,33.83 91,33.99 92.67,33.99 98.59,39.9
  BOTTOM w0.076: v1(99.42,41.76) 99.99,42.33 99.99,43.03 102.85,45.89 102.85,46.98 UC1.BB61
  BOTTOM w0.102: JDIMM1.67 55.78,12.13 56.65,11.26 56.65,10.82 v1(58.36,9.11)
DDR_A_D45: length 75.2
  IN1 w0.089: v1(99.4,40.51) 99.4,40.23 96.21,37.05 96.21,35.52 95.34,34.65 95.15,34.65 94.63,35.16 94.44,35.16 94.3,35.02 94.3,34.83 94.81,34.31 94.81,34.12 94.68,33.98 94.48,33.98 93.9,34.56 93.68,34.56 93.54,34.42 93.54,34.25 94.15,33.65 94.15,33.46 93.71,33.01 93.12,33.01 92.96,33.17 92.96,33.51 92.8,33.67 92.57,33.67 92.41,33.51 92.41,33.17 92.25,33.01 92.02,33.01 91.86,33.17 91.86,33.51 91.7,33.67 91.48,33.67 91.32,33.51 91.32,33.17 91.16,33.01 83.21,33.01 82.86,33.01 82.29,32.44 76.64,32.44 59.75,15.54 59.75,14.67 58.14,13.06 58.14,10.5 v1(58.26,10.38)
  BOTTOM w0.076: v1(99.4,40.51) 100.16,41.27 100.16,42.98 103.01,45.82 103.01,46.73 103.21,46.93 103.21,47.19 103.18,47.28 103.18,47.29 103.18,47.54 103.21,47.63 103.21,47.84 103.18,47.92 103.18,47.92 103.15,48.02 103.15,48.28 UC1.AY61
  BOTTOM w0.102: JDIMM1.71 56.78,11.86 v1(58.26,10.38)
DDR_A_D46: length 75.2
  IN1 w0.076: 100.61,38.62 100.91,38.92 100.91,39.64 v1(101.3,40.03)
  IN1 w0.089: 100.61,38.62 98.27,36.28 98.27,33.6 95.52,30.85 83.72,30.85 82.81,29.94 79.89,29.94 79.09,29.14 76.08,29.14 61.93,14.99 61.93,14.77 62.07,14.64 62.31,14.64 62.45,14.5 62.45,14.3 62.31,14.17 62.07,14.17 61.93,14.03 61.93,13.83 62.07,13.7 62.31,13.7 62.45,13.56 62.45,13.36 62.31,13.23 62.07,13.23 61.93,13.09 61.93,12.89 62.07,12.76 62.31,12.76 62.45,12.62 62.45,12.42 62.31,12.29 62.07,12.29 61.89,12.1 61.89,11.32 62.4,10.8 62.4,10.53 62.24,10.37 61.93,10.37 61.77,10.21 61.77,9.99 61.93,9.83 62.21,9.83 62.37,9.67 62.37,9.44 62.26,9.33 61.36,9.33 61.27,9.42 61.27,10.64 60.92,10.99 v1(60.64,10.99)
  BOTTOM w0.076: v1(101.3,40.03) 102.41,41.14 102.41,43.51 104.3,45.39 104.3,45.99 104.54,46.23 104.54,47.18 104.48,47.33 UC1.BA59
  BOTTOM w0.102: JDIMM1.83 59.78,11.85 v1(60.64,10.99)
DDR_A_D47: length 75.8
  IN1 w0.089: v1(59.42,7) 60.69,7 60.85,7.16 60.85,7.57 61,7.72 61.22,7.72 61.39,7.55 61.39,7.16 61.55,7 62.21,7 62.75,7.54 62.75,15.38 76.21,28.84 79.39,28.84 80.14,29.58 82.96,29.58 83.8,30.42 95.57,30.42 98.64,33.49 98.64,36.17 101.21,38.74 v1(101.3,38.74)
  BOTTOM w0.076: v1(101.3,38.74) 102.61,40.05 102.61,43.46 104.46,45.31 104.46,45.92 104.7,46.16 104.7,47.22 104.67,47.29 104.54,47.72 104.54,47.92 104.27,48.18 UC1.AY59
  BOTTOM w0.102: v1(59.42,7) 59.03,6.61 JDIMM1.80
DDR_A_D48: length 49.2
  IN4 w0.076: v1(99.6,50.5) 99.01,49.92 99.01,47.27 98.4,46.66 98.4,45.26
  IN4 w0.089: 98.4,45.26 98.4,40.14 96.63,38.37 96.63,31.15 94.65,29.16 94.65,28.8 94.81,28.64 95.34,28.64 95.5,28.48 95.5,28.25 95.34,28.09 94.81,28.09 94.65,27.93 94.65,10.25 95.18,9.72 v1(95.35,9.72)
  BOTTOM w0.076: UC1.AT66 99.95,50.85 v1(99.6,50.5)
  BOTTOM w0.102: v1(95.35,9.72) 95.22,9.72 93.78,11.16 JDIMM1.211
DDR_A_D49: length 48.6
  IN4 w0.076: 98.61,46.01 98.61,46.55 99.21,47.16 99.21,49.48 v1(99.6,49.87)
  IN4 w0.089: 98.61,46.01 98.61,39.78 96.95,38.12 96.95,28.78 95.04,26.86 95.04,24.91 95.13,24.82 95.43,24.82 95.59,24.66 95.59,24.44 95.43,24.28 95.11,24.28 94.95,24.12 94.95,23.89 95.11,23.73 95.43,23.73 95.59,23.57 95.59,23.35 95.43,23.19 95.11,23.19 94.95,23.03 94.95,22.8 95.11,22.64 95.43,22.64 95.59,22.48 95.59,22.25 95.43,22.09 95.11,22.09 94.95,21.93 94.95,21.71 95.11,21.55 95.43,21.55 95.59,21.39 95.59,21.16 95.43,21 95.11,21 94.95,20.84 94.95,20.62 95.11,20.46 95.43,20.46 95.59,20.3 95.59,20.07 95.43,19.91 95.11,19.91 94.95,19.75 94.95,11.38 v1(95.35,10.99)
  BOTTOM w0.076: v1(99.6,49.87) UC1.AU66
  BOTTOM w0.102: v1(95.35,10.99) 94.98,10.99 94.61,11.36 94.61,12 94.78,12.17 JDIMM1.215
DDR_A_D50: length 52.1
  IN4 w0.076: 100.53,45.49 100.67,45.63 100.67,48.37 101.1,48.81 101.1,50.07 100.89,50.28 100.89,52.03 v1(100.51,52.41)
  IN4 w0.089: v1(98.71,9.75) 98.27,9.75 97.97,10.05 97.97,23.33 98.13,23.49 98.72,23.49 98.88,23.65 98.88,23.87 98.72,24.03 98.13,24.03 97.97,24.19 97.97,24.42 98.13,24.58 98.72,24.58 98.88,24.74 98.88,24.97 98.72,25.13 98.13,25.13 97.97,25.29 97.97,25.72 99.27,27.02 99.27,32.59 99.25,32.6 99.25,36.01 99.27,36.02 99.27,37.73 100.53,38.99 100.53,45.49
  BOTTOM w0.076: v1(100.51,52.41) 100.77,52.15 UC1.AP65
  BOTTOM w0.102: v1(98.71,9.75) 97.28,11.18 JDIMM1.225
DDR_A_D51: length 52.6
  IN4 w0.076: v1(100.51,53.04) 101.06,52.5 101.06,50.35 101.3,50.11 101.3,48.66 100.88,48.25 100.88,45.35
  IN4 w0.089: 100.88,45.35 100.88,38.91 99.6,37.64 99.6,23.62 98.28,22.29 98.28,21.54 98.44,21.38 99.1,21.38 99.26,21.22 99.26,20.99 99.1,20.83 98.44,20.83 98.28,20.67 98.28,19.64 98.44,19.48 98.61,19.48 98.77,19.32 98.77,19.1 98.61,18.94 98.44,18.94 98.28,18.78 98.28,18.55 98.44,18.39 98.61,18.39 98.77,18.23 98.77,18 98.61,17.84 98.44,17.84 98.28,17.68 98.28,17.46 98.44,17.3 98.61,17.3 98.77,17.14 98.77,16.91 98.61,16.75 98.44,16.75 98.28,16.59 98.28,16.37 98.44,16.21 98.61,16.21 98.77,16.05 98.77,15.82 98.61,15.66 98.44,15.66 98.28,15.5 98.28,15.27 98.44,15.11 98.61,15.11 98.77,14.95 98.77,14.73 98.61,14.57 98.44,14.57 98.28,14.41 98.28,14.18 98.44,14.02 98.61,14.02 98.77,13.86 98.77,13.64 98.61,13.48 98.44,13.48 98.28,13.32 98.28,13.09 98.44,12.93 98.61,12.93 98.77,12.77 98.77,12.54 98.61,12.38 98.44,12.38 98.28,12.22 98.28,11.47 v1(98.79,10.97)
  BOTTOM w0.076: v1(100.51,53.04) 100.76,52.8 UC1.AN65
  BOTTOM w0.102: JDIMM1.229 98.28,11.32 98.63,10.97 v1(98.79,10.97)
DDR_A_D52: length 51.8
  IN4 w0.076: 97.26,45.54 97.26,45.85 97.62,46.2 97.62,48.74 98.03,49.15 98.03,50.11 99.22,51.3 99.22,52.03 v1(99.6,52.41)
  IN4 w0.089: 97.26,45.54 97.26,40.33 95.84,38.9 95.84,31.62 93.93,29.72 93.93,11.1 93.4,10.57 93.4,9.42 94.7,8.12 94.7,7.56 v1(95.32,6.94)
  BOTTOM w0.076: UC1.AN66 99.99,52.8 v1(99.6,52.41)
  BOTTOM w0.102: JDIMM1.216 95.03,5.89 94.95,5.96 94.95,6.57 v1(95.32,6.94)
DDR_A_D53: length 51.3
  IN4 w0.076: v1(99.6,51.77) 99.6,51.13 98.21,49.74 98.21,49.07 97.82,48.68 97.82,45.36 98.21,44.98 98.21,40.83
  IN4 w0.089: v1(95.28,8.4) 95.26,8.37 94.9,8.37 94.29,8.98 94.29,29.42 96.33,31.46 96.33,38.59 98.21,40.47 98.21,40.83
  BOTTOM w0.076: v1(99.6,51.77) UC1.AP66
  BOTTOM w0.102: JDIMM1.212 94.03,6.09 94.17,6.23 94.17,7.29 v1(95.28,8.4)
DDR_A_D54: length 50.8
  IN4 w0.076: 100.18,45.52 100.44,45.78 100.44,48.53 100.89,48.99 100.89,50.04 100.51,50.42 v1(100.51,50.5)
  IN4 w0.089: v1(98.48,8.07) 98.48,8.9 98.33,9.06 98.13,9.06 97.45,8.38 97.26,8.38 97.12,8.52 97.12,8.71 97.64,9.24 97.64,26.07 98.96,27.38 98.96,37.86 100.18,39.08 100.18,45.52
  BOTTOM w0.076: UC1.AT65 100.86,50.85 v1(100.51,50.5)
  BOTTOM w0.102: v1(98.48,8.07) 98.48,8.02 97.03,6.56 JDIMM1.224
DDR_A_D55: length 50.2
  IN4 w0.076: v1(100.51,49.87) 100.51,49.01 100.18,48.68 100.18,46.03 99.84,45.68
  IN4 w0.089: v1(97.97,6.16) 97.38,6.76 96.65,6.76 96.46,6.95 96.46,7.17 96.62,7.33 97.4,7.33 97.56,7.49 97.56,7.71 97.4,7.87 96.62,7.87 96.46,8.03 96.46,8.83 97.34,9.71 97.34,26.6 98.57,27.83 98.57,37.9 99.84,39.17 99.84,45.68
  BOTTOM w0.076: v1(100.51,49.87) 100.85,50.2 UC1.AU65
  BOTTOM w0.102: JDIMM1.228 98.03,6.11 v1(97.97,6.16)
DDR_A_D56: length 49.5
  IN4 w0.076: v1(102.34,50.5) 102.34,50.39 101.86,49.92 101.86,48.65 102.07,48.45 102.07,44.89 102.42,44.54 102.42,44.37
  IN4 w0.089: 102.42,44.37 102.42,38.22 100.85,36.64 100.85,20.53 100.03,19.71 100.03,10.35 100.17,10.21 100.28,10.21 100.42,10.07 100.42,9.85 100.31,9.74 100.17,9.74 100.03,9.6 100.03,9.1 100.35,8.79 100.62,8.79 v1(100.78,8.95)
  BOTTOM w0.076: UC1.AT61 102.69,50.85 v1(102.34,50.5)
  BOTTOM w0.102: v1(100.78,8.95) 99.28,10.45 JDIMM1.233
DDR_A_D57: length 49.1
  IN4 w0.076: v1(102.34,49.87) 102.05,49.58 102.05,48.7 102.26,48.49 102.26,45.05 102.72,44.59 102.72,44.25
  IN4 w0.089: 102.72,44.25 102.72,37.99 101.19,36.46 101.19,20.24 100.36,19.41 100.36,18.52 100.52,18.36 100.97,18.36 101.13,18.2 101.13,17.97 100.97,17.81 100.52,17.81 100.36,17.65 100.36,17.42 100.52,17.26 100.97,17.26 101.13,17.1 101.13,16.88 100.97,16.72 100.52,16.72 100.36,16.56 100.36,16.33 100.52,16.17 100.97,16.17 101.13,16.01 101.13,15.78 100.97,15.62 100.52,15.62 100.36,15.46 100.36,15.24 100.52,15.08 100.97,15.08 101.13,14.92 101.13,14.69 100.97,14.53 100.52,14.53 100.36,14.37 100.36,10.79 v1(100.77,10.38)
  BOTTOM w0.076: UC1.AU61 102.68,50.2 v1(102.34,49.87)
  BOTTOM w0.102: v1(100.77,10.38) 100.28,10.87 JDIMM1.237
DDR_A_D58: length 52.3
  IN4 w0.076: 103.88,36.57 104.79,37.48 104.79,44.58 104.15,45.22 104.15,47.13 103.92,47.36 103.92,49.99 103.64,50.27 103.64,52.03 v1(103.26,52.41)
  IN4 w0.089: 103.88,36.57 103.13,35.82 103.13,18.17 106.19,15.1 106.19,11.53 104.21,9.55 104.21,8.17 v1(103.6,7.56)
  BOTTOM w0.102: JDIMM1.246 102.53,6.48 v1(103.6,7.56) ; v1(103.26,52.41) 103.51,52.15 UC1.AP60
DDR_A_D59: length 52.8
  IN4 w0.076: v1(103.26,53.06) 103.8,52.52 103.8,50.34 104.26,49.88 104.26,47.54 104.5,47.3 104.5,45.32 104.97,44.85 104.97,37.23 103.42,35.68 103.42,34.25
  IN4 w0.089: v1(103.6,6.16) 104.51,7.08 104.51,9.41 106.57,11.46 106.57,15.39 103.43,18.53 103.43,34.24 103.42,34.25
  BOTTOM w0.076: v1(103.26,53.06) 103.51,52.8 UC1.AN60
  BOTTOM w0.102: v1(103.6,6.16) 103.53,6.16 JDIMM1.250
DDR_A_D60: length 51.8
  IN4 w0.076: v1(102.34,52.41) 101.81,51.87 101.81,50.32 101.5,50.02 101.5,48.44 101.63,48.32 101.63,44.81 101.69,44.75 101.69,44.55
  IN4 w0.089: v1(100.55,6.74) 100.21,7.08 99.98,7.08 99.64,6.74 99.52,6.74 99.26,7 99.26,7.12 99.6,7.46 99.6,7.68 99.09,8.18 99.09,9.19 99.4,9.49 99.4,20.19 100.2,21 100.2,37.01 101.69,38.5 101.69,44.55
  BOTTOM w0.076: v1(102.34,52.41) 102.74,52.8 UC1.AN61
  BOTTOM w0.102: v1(100.55,6.74) 100.47,6.74 100.03,6.29 JDIMM1.236
DDR_A_D61: length 51.1
  IN4 w0.076: v1(102.34,51.77) 101.97,51.4 101.97,50.26 101.68,49.97 101.68,48.56 101.86,48.38 101.86,44.87 102.07,44.66 102.07,44.5
  IN4 w0.089: 102.07,44.5 102.07,38.39 100.51,36.83 100.51,20.76 99.73,19.98 99.73,9.19 99.39,8.86 99.39,8.32 99.56,8.16 99.71,8.16 100.05,8.5 100.24,8.5 v1(100.54,8.2)
  BOTTOM w0.076: UC1.AP61 102.72,52.15 v1(102.34,51.77)
  BOTTOM w0.102: v1(100.54,8.2) 99.03,6.68 JDIMM1.232
DDR_A_D62: length 51.6
  IN4 w0.076: 103.58,36.88 104.62,37.93 104.62,44.51 103.95,45.18 103.95,46.74 103.64,47.05 103.64,50.03 103.26,50.42 v1(103.26,50.5)
  IN4 w0.089: 103.58,36.88 102.82,36.12 102.82,17.92 105.61,15.13 105.61,15 105.53,14.91 104.88,14.91 104.72,14.75 104.72,14.53 104.88,14.37 105.65,14.37 105.81,14.21 105.81,13.98 105.65,13.82 104.88,13.82 104.72,13.66 104.72,13.43 104.88,13.27 105.65,13.27 105.81,13.11 105.81,12.83 105.67,12.69 104.92,12.69 104.78,12.55 104.78,12.36 104.92,12.22 105.67,12.22 105.81,12.09 105.81,11.7 105.1,10.99 v1(103.73,10.99)
  BOTTOM w0.076: v1(103.26,50.5) 103.61,50.85 UC1.AT60
  BOTTOM w0.102: JDIMM1.249 103.28,11.44 v1(103.73,10.99)
DDR_A_D63: length 50.5
  IN4 w0.076: 103.25,37.16 104.43,38.34 104.43,43.88 103.02,45.29 103.02,47.96 103.26,48.19 v1(103.26,49.87)
  IN4 w0.089: 103.25,37.16 102.52,36.42 102.52,16.76 102.68,16.6 103.53,16.6 103.69,16.44 103.69,16.22 103.53,16.06 102.68,16.06 102.52,15.9 102.52,15.67 102.68,15.51 103.53,15.51 103.69,15.35 103.69,15.12 103.53,14.96 102.68,14.96 102.52,14.8 102.52,13.94 102.68,13.78 104.15,13.78 104.31,13.62 104.31,13.4 104.15,13.24 102.58,13.24 102.34,13 102.34,11.55 v1(102.82,11.07)
  BOTTOM w0.076: UC1.AU60 103.59,50.2 v1(103.26,49.87)
  BOTTOM w0.102: v1(102.82,11.07) 102.28,11.62 JDIMM1.245
DDR_A_DQS0: length 88.7
  IN1 w0.091: v1(90.4,53.01) 90.21,53.2 90.21,53.44 90.01,53.64 86.87,53.64 79.18,45.94 77.43,45.94 76.58,45.1 74.36,45.1 73.56,44.3 70.15,44.3 69.23,43.38 67.39,43.38 65.79,41.77 62.96,41.77 61.22,40.03 61.22,38.74 59.09,36.61 59.09,36.26 59.32,36.03 59.32,35.9 59.11,35.7 58.99,35.7 58.75,35.93 58.41,35.93 54.74,32.27 54.74,31.81 53.72,30.79 53.72,27.39 43.95,17.62 43.95,16.93 43.81,16.79 43.52,16.79 43.32,16.6 43.32,16.16 43.52,15.96 43.81,15.96 43.95,15.82 43.95,13.81 43.81,13.67 43.4,13.67 43.21,13.47 43.21,13.03 43.4,12.83 43.81,12.83 44.03,12.61 44.03,10.57 43.92,10.46 43.68,10.46 v1(43.4,10.73)
  BOTTOM w0.076: 91.06,52.53 94.02,52.53 94.4,52.91 94.7,52.91 94.9,53.11 95.51,53.72 96.6,53.72 96.69,53.63 96.91,53.63 97.1,53.68 97.31,53.68 97.39,53.65 97.56,53.65 97.75,53.7 97.89,53.7 98.03,53.63 98.14,53.52 98.14,53.42 98.22,53.34 UC1.AM69
  BOTTOM w0.099: JDIMM1.13 42.27,12.12 42.14,11.99 42.14,11.17 42.88,10.43 43.1,10.43 v1(43.4,10.73) ; 91.06,52.53 90.27,52.53 90.17,52.63 90.17,52.78 v1(90.4,53.01)
DDR_A_DQS1: length 82
  IN1 w0.091: v1(92.31,48.22) 92.43,48.22 92.58,48.06 92.58,44.48 88.75,40.64 77.84,40.64 76.74,39.55 72.64,39.55 72.27,39.18 71.04,39.18 69.95,38.09 67.93,38.09 66.83,36.98 66.57,36.98 62.66,33.07 62.26,33.07 61.37,32.19 61.37,31.78 61.37,31.78 61.37,29.51 49.2,17.33 49.2,11.06 48.96,10.83 48.96,9.17 47.23,7.44 46.94,7.44 46.83,7.55 v1(46.83,7.68)
  BOTTOM w0.076: v1(92.31,48.22) 92.42,48.22 92.61,48.41 92.61,49 92.93,49.32 94.21,49.32 95.39,50.49 96.32,50.49 96.48,50.66 96.97,50.66 97.09,50.61 97.23,50.61 97.34,50.66 97.49,50.66 97.72,50.89 UC1.AT70
  BOTTOM w0.099: JDIMM1.34 47.52,5.82 47.37,5.98 47.37,6.18 47.71,6.52 47.71,7 47.27,7.43 46.97,7.43 46.83,7.58 v1(46.83,7.68)
DDR_A_DQS2: length 59.8
  IN4 w0.076: 95.83,46.28 95.85,46.3 95.85,46.31 96.66,47.13 96.66,49.51 97.05,49.89 97.05,51.21 97.53,51.69 97.53,52.61 99.21,54.3 99.34,54.3 99.56,54.51 100.57,54.51 100.94,54.88 v1(101.05,54.88)
  IN4 w0.091: 95.83,46.28 94.7,45.15 94.7,42.28 93.01,40.59 93.01,35.42 91.51,33.92 91.25,33.92 90.71,33.39 90.71,33.2 90.88,33.04 91.89,33.04 92.16,32.77 92.16,32.39 91.89,32.13 90.88,32.13 90.78,32.03 90.78,16.15 89.97,15.34 89.97,13.84 90.34,13.47 90.34,11.61 90.79,11.17 90.79,9.67 91.79,8.67 91.79,8.11 v1(91.98,7.92)
  BOTTOM w0.099: v1(101.05,54.88) 100.95,54.88 100.74,55.09 UC1.AH65 ; JDIMM1.200 91.03,6.65 91.76,7.39 91.76,7.71 v1(91.98,7.92)
DDR_A_DQS3: length 67.4
  IN4 w0.091: v1(93.52,55.85) 93.47,55.85 93.24,55.62 93.24,54.61 92.11,53.48 89.37,53.48 84.24,48.36 84.24,27.61 84.4,27.45 84.81,27.45 85.08,27.19 85.08,26.81 84.81,26.54 84.4,26.54 84.24,26.38 84.24,26.15 84.4,25.99 84.81,25.99 85.08,25.73 85.08,25.35 84.81,25.08 84.4,25.08 84.24,24.92 84.24,24.7 84.4,24.54 84.81,24.54 85.08,24.27 85.08,23.89 84.81,23.63 84.4,23.63 84.24,23.47 84.24,23.24 84.4,23.08 84.81,23.08 85.02,22.87 85.02,22.38 84.81,22.17 84.4,22.17 84.24,22.01 84.24,21.78 84.4,21.62 84.51,21.62 84.71,21.42 84.71,20.91 84.51,20.71 84.4,20.71 84.24,20.55 84.24,12.3 85.31,11.24 85.31,10.24 85.42,10.13 85.58,10.13 85.98,10.53 v1(85.98,10.67)
  BOTTOM w0.076: UC1.AG70 97.74,55.9 97.49,55.65 97.39,55.65 arc(97.3,55.64) 97.21,55.61 97.2,55.61 arc(97.12,55.59) 97.05,55.62 97.04,55.63 arc(96.93,55.67) 96.81,55.68 96.49,55.63 96.49,55.63 96.2,55.55 95.83,55.18 94.75,55.18 94.51,54.94 93.34,54.94 93.26,55.02 93.26,55.59 v1(93.52,55.85)
  BOTTOM w0.099: JDIMM1.179 85.78,12.27 85.46,11.96 85.46,10.99 85.35,10.88 85.35,10.39 85.51,10.23 85.69,10.23 85.98,10.52 v1(85.98,10.67)
DDR_A_DQS4: length 75.8
  IN1 w0.091: v1(96.1,41.85) 96.1,41.73 95.89,41.51 95.52,41.51 90.87,36.86 80.35,36.86 79.26,35.77 74.52,35.77 72.23,33.48 70.83,33.48 67.49,30.14 67.49,29.84 63.81,26.15 63.81,24.81 54.18,15.18 54.18,14.07 54.02,13.91 53.85,13.91 53.59,13.65 53.59,13.27 53.85,13 54.02,13 54.18,12.84 54.18,12.62 54.02,12.46 53.85,12.46 53.59,12.19 53.59,11.81 53.85,11.55 54.02,11.55 54.19,11.37 54.19,10.2 54.09,10.1 v1(53.94,10.1)
  BOTTOM w0.076: v1(96.1,41.85) 96.1,41.72 96.24,41.58 96.56,41.58 97.06,42.09 97.06,44.37 97.81,45.13 99.86,45.13 100.7,45.96 100.7,46.77 100.86,46.93 100.86,47.19 100.81,47.3 100.81,47.52 100.86,47.63 100.86,48.27 101.16,48.56 UC1.AY64
  BOTTOM w0.099: v1(53.94,10.1) 53.62,9.78 53.24,9.78 52.78,10.24 JDIMM1.55
DDR_A_DQS5: length 75.4
  IN1 w0.076: v1(101.3,43.28) 101.3,43.17 101.05,42.92 100.48,42.92 99.84,42.29 99.84,39.85 99.6,39.61 99.59,39.61 99.58,39.6
  IN1 w0.091: 99.58,39.6 96.85,36.87 96.85,35.35 93.94,32.44 83.1,32.44 82.53,31.87 76.88,31.87 60.35,15.34 60.35,14.29 59.03,12.97 59.03,9.22 59.03,8.91 58.6,8.48 58.6,7.53 58.4,7.32 57.38,7.32 57.25,7.46 v1(57.25,7.65)
  BOTTOM w0.076: UC1.BA60 103.76,48.06 103.84,47.98 103.84,47.6 103.86,47.54 103.89,47.46 103.89,47.34 103.85,47.26 103.84,47.23 103.84,46.81 104,46.65 104,46.39 103.69,46.08 103.69,45.68 101.77,43.76 101.77,43.04 101.69,42.96 101.51,42.96 101.3,43.17 v1(101.3,43.28)
  BOTTOM w0.099: JDIMM1.76 58.03,5.82 57.87,5.98 57.87,6.97 57.66,7.18 57.37,7.18 57.25,7.31 v1(57.25,7.65)
DDR_A_DQS6: length 50.8
  IN4 w0.076: v1(100.51,51.14) 100.54,51.17 100.54,51.28 100.4,51.42 100.16,51.42 100.06,51.33 100.06,50.9 100.13,50.73 100.13,48.99 99.95,48.81 99.95,46.29 99,45.33 99,39.13 97.81,37.94 97.81,37.79 97.81,37.79 97.81,37.78 97.81,37.78 97.81,37.76
  IN4 w0.091: v1(96.76,11.03) 96.76,10.88 96.48,10.6 96.39,10.6 96.29,10.7 96.29,11.77 95.79,12.27 95.79,13.29 96.35,13.84 96.35,14.19 96.1,14.43 95.88,14.43 95.78,14.53 95.78,14.82 95.88,14.91 96.1,14.91 96.35,15.15 96.35,15.5 96.1,15.74 95.91,15.74 95.82,15.83 95.82,16.12 95.91,16.21 96.1,16.21 96.35,16.46 96.35,16.8 96.1,17.05 95.92,17.05 95.83,17.14 95.83,17.43 95.92,17.52 96.1,17.52 96.35,17.76 96.35,18.11 95.81,18.64 95.81,18.77 96.35,19.3 96.35,27.1 97.81,28.56 97.81,37.76
  BOTTOM w0.099: v1(100.51,51.14) 100.51,51.24 100.7,51.43 100.71,51.43 100.78,51.5 UC1.AR65 ; JDIMM1.221 96.28,12.19 95.96,11.88 95.96,10.83 96.21,10.58 96.45,10.58 96.76,10.89 v1(96.76,11.03)
DDR_A_DQS7: length 50.9
  IN4 w0.076: v1(103.26,51.77) 103.02,51.54 102.85,51.54 102.59,51.29 102.59,50.78 102.71,50.66 102.71,49.39 102.85,49.25 102.85,48.62 102.54,48.32 102.54,45.12 103.1,44.56 103.1,37.86 101.77,36.53 101.77,35.69 101.76,35.69 101.76,35.67
  IN4 w0.091: 101.76,35.67 101.76,14.16 101.22,13.62 101.22,10.73 101.34,10.62 101.34,9.99 101.35,9.98 101.35,8.71 101.22,8.58 101.22,7.54 101.59,7.17 101.91,7.17 v1(102.07,7.01)
  BOTTOM w0.076: UC1.AR60 103.53,51.5 v1(103.26,51.77)
  BOTTOM w0.099: JDIMM1.242 101.53,5.67 101.36,5.83 101.36,7.08 101.56,7.27 101.97,7.27 102.07,7.17 v1(102.07,7.01)
DDR_A_DQS#0: length 88.7
  IN1 w0.091: v1(43.4,10.1) 43.58,10.28 43.99,10.28 44.21,10.5 44.21,12.69 43.88,13.01 43.48,13.01 43.39,13.11 43.39,13.4 43.48,13.49 43.88,13.49 44.13,13.73 44.13,15.9 43.88,16.14 43.59,16.14 43.5,16.23 43.5,16.52 43.59,16.61 43.88,16.61 44.13,16.86 44.13,17.54 53.9,27.31 53.9,30.71 54.92,31.74 54.92,32.19 58.48,35.75 58.68,35.75 58.91,35.52 59.19,35.52 59.5,35.83 59.5,36.11 59.27,36.34 59.27,36.53 61.4,38.66 61.4,39.96 63.03,41.59 65.86,41.59 67.47,43.2 69.31,43.2 70.23,44.12 73.63,44.12 74.44,44.92 76.66,44.92 77.5,45.76 79.25,45.76 86.94,53.46 89.94,53.46 90.03,53.37 90.03,53.19 89.85,53.01 v1(89.75,53.01)
  BOTTOM w0.076: UC1.AM70 97.9,53.25 97.98,53.32 97.98,53.45 97.94,53.49 97.85,53.54 97.77,53.54 97.58,53.48 97.35,53.48 97.28,53.52 97.12,53.52 96.93,53.47 96.62,53.47 96.53,53.56 95.58,53.56 94.77,52.75 94.47,52.75 94.09,52.37 91.15,52.37 91.14,52.36 91.09,52.36 91.07,52.34 91.06,52.34
  BOTTOM w0.099: 91.06,52.34 90.2,52.34 89.99,52.55 89.99,52.77 v1(89.75,53.01) ; JDIMM1.11 41.78,12.15 41.95,11.97 41.95,11.09 42.8,10.24 43.26,10.24 v1(43.4,10.1)
DDR_A_DQS#1: length 82.1
  IN1 w0.091: v1(46.83,7.05) 47.04,7.26 47.31,7.26 49.14,9.09 49.14,10.75 49.38,10.99 49.38,17.26 61.55,29.43 61.55,31.7 61.55,31.71 61.55,32.11 62.33,32.89 62.74,32.89 66.65,36.8 66.9,36.8 68.01,37.91 70.03,37.91 71.12,39 72.35,39 72.72,39.36 76.82,39.36 77.92,40.46 88.82,40.46 92.76,44.4 92.76,48.01 92.77,48.02 92.77,48.03 v1(92.96,48.21)
  BOTTOM w0.076: UC1.AT69 98.07,50.49 97.38,50.49 97.27,50.44 97.05,50.44 96.94,50.5 96.87,50.5 96.87,50.5 96.55,50.5 96.39,50.33 95.45,50.33 94.28,49.15 93,49.15 92.78,48.94 92.78,48.39 v1(92.96,48.21)
  BOTTOM w0.099: v1(46.83,7.05) 47.03,7.25 47.2,7.25 47.52,6.93 47.52,6.6 47.18,6.26 47.18,5.98 47.03,5.82 JDIMM1.32
DDR_A_DQS#2: length 59.8
  IN4 w0.076: 95.71,46.41 95.71,46.42 95.72,46.42 95.73,46.43 96.5,47.19 96.5,49.58 96.88,49.96 96.88,51.28 97.36,51.76 97.36,52.68 99.14,54.46 99.28,54.46 99.49,54.68 100.21,54.68 v1(100.42,54.88)
  IN4 w0.091: v1(91.26,7.92) 91.44,7.92 91.61,8.09 91.61,8.59 90.61,9.59 90.61,11.09 90.16,11.54 90.16,13.39 89.79,13.76 89.79,15.41 90.6,16.22 90.6,32.11 90.8,32.31 91.82,32.31 91.98,32.47 91.98,32.7 91.82,32.86 90.8,32.86 90.53,33.12 90.53,33.46 91.17,34.1 91.43,34.1 92.83,35.49 92.83,40.67 94.52,42.35 94.52,45.22 95.71,46.41
  BOTTOM w0.099: UC1.AH66 100.09,55.21 v1(100.42,54.88) ; JDIMM1.198 90.53,5.68 90.84,5.99 90.84,6.73 91.57,7.47 91.57,7.82 91.47,7.92 v1(91.26,7.92)
DDR_A_DQS#3: length 67.4
  IN4 w0.091: v1(92.83,55.47) 93.06,55.24 93.06,54.69 92.03,53.66 89.29,53.66 84.06,48.43 84.06,27.54 84.33,27.27 84.73,27.27 84.9,27.11 84.9,26.88 84.73,26.72 84.33,26.72 84.06,26.46 84.06,26.08 84.33,25.81 84.73,25.81 84.9,25.65 84.9,25.43 84.73,25.26 84.33,25.26 84.06,25 84.06,24.62 84.33,24.36 84.73,24.36 84.9,24.19 84.9,23.97 84.73,23.81 84.33,23.81 84.06,23.54 84.06,23.16 84.33,22.9 84.73,22.9 84.84,22.79 84.84,22.45 84.73,22.35 84.33,22.35 84.06,22.08 84.06,21.71 84.33,21.44 84.44,21.44 84.53,21.35 84.53,20.98 84.44,20.89 84.33,20.89 84.06,20.62 84.06,12.23 85.12,11.16 85.12,10.17 85.34,9.95 v1(85.98,9.95)
  BOTTOM w0.076: UC1.AG69 97.57,55.49 97.39,55.49 arc(97.34,55.48) 97.28,55.46 97.27,55.46 arc(97.11,55.43) 96.96,55.48 96.95,55.49 arc(96.9,55.51) 96.84,55.51 96.83,55.51 96.53,55.47 96.51,55.47 96.28,55.4 95.9,55.02 94.82,55.02 94.58,54.78 93.27,54.78 93.09,54.95 93.09,55.2 v1(92.83,55.47)
  BOTTOM w0.099: v1(85.98,9.95) 85.89,10.04 85.43,10.04 85.16,10.31 85.16,10.95 85.27,11.07 85.27,12.04 85.28,12.04 JDIMM1.177
DDR_A_DQS#4: length 75.8
  IN1 w0.091: v1(53.94,9.46) 54.37,9.89 54.37,11.45 54.09,11.73 53.93,11.73 53.77,11.89 53.77,12.12 53.93,12.28 54.09,12.28 54.36,12.54 54.36,12.92 54.09,13.19 53.93,13.19 53.77,13.35 53.77,13.57 53.93,13.73 54.09,13.73 54.36,14 54.36,15.11 63.99,24.73 63.99,26.08 67.67,29.76 67.67,30.07 70.9,33.3 72.3,33.3 74.59,35.59 79.34,35.59 80.43,36.68 90.95,36.68 95.6,41.33 95.97,41.33 v1(96.1,41.2)
  BOTTOM w0.076: v1(96.1,41.2) 96.32,41.42 96.62,41.42 97.22,42.02 97.22,44.3 97.88,44.96 99.93,44.96 100.86,45.89 100.86,46.7 101.02,46.86 101.02,47.23 100.97,47.34 100.97,47.36 100.97,47.47 101.02,47.6 101.02,47.83 UC1.BA64
  BOTTOM w0.099: v1(53.94,9.46) 53.82,9.59 53.16,9.59 52.59,10.16 52.59,12 52.27,12.31 JDIMM1.53
DDR_A_DQS#5: length 75.3
  IN1 w0.076: 99.71,39.47 99.72,39.48 99.72,39.49 100.01,39.78 100.01,42.22 100.54,42.75 101.18,42.75 v1(101.3,42.63)
  IN1 w0.091: 99.71,39.47 97.03,36.8 97.03,35.28 94.02,32.26 83.17,32.26 82.6,31.69 76.95,31.69 60.53,15.27 60.53,14.22 59.21,12.89 59.21,9.22 59.21,8.83 58.78,8.4 58.78,7.45 58.47,7.14 57.37,7.14 57.25,7.01 v1(57.25,6.8)
  BOTTOM w0.076: v1(101.3,42.63) 101.46,42.8 101.76,42.8 101.93,42.97 101.93,43.69 103.85,45.61 103.85,46.01 104.17,46.33 104.17,46.72 104.01,46.88 104.01,47.19 104.06,47.31 104.06,47.45 104.04,47.53 104.03,47.59 104.01,47.63 104.01,48.06 UC1.AY60
  BOTTOM w0.099: JDIMM1.74 57.52,5.82 57.68,5.98 57.68,6.9 57.58,6.99 57.44,6.99 57.25,6.8 v1(57.25,6.8)
DDR_A_DQS#6: length 50.8
  IN4 w0.076: v1(100.51,51.77) 100.33,51.59 100.09,51.59 99.9,51.4 99.9,50.87 99.97,50.7 99.97,49.06 99.79,48.88 99.79,46.36 98.83,45.4 98.83,39.2 97.64,38 97.63,37.78 97.63,37.76
  IN4 w0.091: 97.63,37.76 97.63,28.64 96.17,27.17 96.17,19.38 95.63,18.85 95.63,18.57 96.17,18.03 96.17,17.84 96.03,17.7 95.84,17.7 95.65,17.5 95.65,17.06 95.84,16.86 96.03,16.86 96.17,16.73 96.17,16.53 96.03,16.39 95.84,16.39 95.64,16.2 95.64,15.76 95.84,15.56 96.03,15.56 96.17,15.42 96.17,15.23 96.03,15.09 95.8,15.09 95.6,14.89 95.6,14.45 95.8,14.25 96.03,14.25 96.17,14.12 96.17,13.92 95.61,13.37 95.61,12.19 96.11,11.7 96.11,10.63 96.32,10.42 96.65,10.42 v1(96.76,10.31)
  BOTTOM w0.099: JDIMM1.219 95.78,10.75 96.13,10.4 96.67,10.4 v1(96.76,10.31) ; v1(100.51,51.77) 100.33,51.77 UC1.AR66
DDR_A_DQS#7: length 50.9
  IN4 w0.076: v1(103.26,51.14) 103.26,51.2 103.08,51.38 102.91,51.38 102.76,51.22 102.76,50.84 102.88,50.73 102.88,49.46 103.01,49.32 103.01,48.55 102.71,48.25 102.71,45.19 103.26,44.63 103.26,37.79 101.94,36.46 101.94,35.69 101.94,35.69 101.94,35.67
  IN4 w0.091: 101.94,35.67 101.94,14.08 101.4,13.55 101.4,10.81 101.52,10.69 101.52,10.07 101.53,10.06 101.53,8.63 101.4,8.51 101.4,7.61 101.67,7.35 101.84,7.35 102.07,7.58 v1(102.07,7.73)
  BOTTOM w0.076: v1(103.26,51.14) 102.89,51.5 UC1.AR61
  BOTTOM w0.099: v1(102.07,7.73) 102.07,7.62 101.91,7.46 101.48,7.46 101.17,7.16 101.17,5.73 101.03,5.58 JDIMM1.240
DDR_A_MA0: length 70.9
  IN1 w0.076: 106.19,35.42 106.19,35.64 107.21,36.66 107.21,38.94 107.7,39.44 107.7,40.65 v1(107.28,41.08)
  IN1 w0.142: 106.19,35.42 106.19,30.18 97.64,21.63 80.01,21.63 73.08,14.71 73.08,8.93 73.16,8.86 73.16,7.92 73.31,7.77 74,7.77 75,6.76 v1(75,6.49)
  BOTTOM w0.076: UC1.AY50 109.23,48.16 109.72,47.67 109.72,46.21 108.98,45.47 108.98,43.84 107.94,42.8 v2(107.94,41.74) v1(107.28,41.08)
  BOTTOM w0.168: JDIMM1.144 75.02,6.47 v1(75,6.49)
DDR_A_MA1: length 71.3
  IN1 w0.076: v1(107.28,43.03) 108.06,42.25 108.06,39.13 107.78,38.85 107.78,36.49 107.06,35.77 107.06,35.51
  IN1 w0.142: v1(73.97,10.22) 73.97,14.4 79.47,19.91 80.18,19.91 80.34,20.06 80.34,20.46 80.49,20.62 80.71,20.62 80.86,20.46 80.86,20.06 81.01,19.91 81.23,19.91 81.38,20.06 81.38,20.46 81.54,20.62 81.75,20.62 81.91,20.46 81.91,20.06 82.06,19.91 82.4,19.91 82.56,20.06 82.56,20.57 82.71,20.72 83.09,20.72 83.38,20.43 83.61,20.43 83.9,20.72 84.14,20.72 84.42,20.43 84.66,20.43 84.95,20.72 85.18,20.72 85.47,20.43 85.7,20.43 85.99,20.72 86.23,20.72 86.52,20.43 86.75,20.43 87.04,20.72 87.27,20.72 87.56,20.43 87.8,20.43 88.09,20.72 88.32,20.72 88.61,20.43 88.84,20.43 89.13,20.72 89.53,20.72 89.82,20.43 90.06,20.43 90.35,20.72 90.58,20.72 90.87,20.43 91.1,20.43 91.39,20.72 91.63,20.72 91.91,20.43 92.15,20.43 92.44,20.72 92.67,20.72 92.96,20.43 93.2,20.43 93.48,20.72 98,20.72 107.06,29.78 107.06,35.51
  BOTTOM w0.076: v1(107.28,43.03) 107.36,43.11 107.58,43.11 108.64,44.16 108.64,45.59 109.31,46.27 109.31,47.01 UC1.BB50
  BOTTOM w0.168: JDIMM1.133 72.27,11.44 73.49,10.22 v1(73.97,10.22)
DDR_A_MA2: length 73.1
  IN1 w0.076: 105.72,35.11 105.72,35.53 106.94,36.75 106.94,40.11 v1(107.28,40.44)
  IN1 w0.142: v1(72.99,6.8) 73.25,6.54 73.83,6.54 74.07,6.78 74.07,7.09 73.85,7.31 72.87,7.31 72.73,7.45 72.73,8.6 72.6,8.73 72.6,14.82 79.83,22.06 97.4,22.06 105.72,30.37 105.72,35.11
  BOTTOM w0.076: v1(107.28,40.44) 106.79,40.92 v2(106.79,43.33) 106.79,43.69 107.28,44.17 107.58,44.17 107.61,44.15 108.01,44.15 108.3,44.44 108.3,45.73 108.9,46.33 108.9,46.76 108.8,46.86 108.8,47.23 108.84,47.34 108.84,47.46 108.78,47.68 108.78,47.75 108.77,47.78 108.79,47.84 108.83,47.98 108.83,48.16 UC1.AY51
  BOTTOM w0.168: JDIMM1.132 72.03,5.57 72.61,6.16 72.61,6.3 72.99,6.68 v1(72.99,6.8)
DDR_A_MA3: length 72
  IN1 w0.076: 106.62,35.43 106.62,35.69 107.5,36.57 107.5,38.88 107.88,39.26 107.88,42.12 107.63,42.38 v1(107.28,42.38)
  IN1 w0.142: v1(73.66,8.91) 73.66,8.36 73.83,8.2 74.03,8.2 74.17,8.34 74.17,9.2 73.98,9.39 73.68,9.39 73.54,9.53 73.54,14.57 80.12,21.15 97.82,21.15 106.62,29.95 106.62,35.43
  BOTTOM w0.076: UC1.BA50 109.53,47.43 109.53,46.26 108.8,45.53 108.8,43.9 v1(107.28,42.38)
  BOTTOM w0.168: v1(73.66,8.91) 73.66,9.3 71.78,11.19 JDIMM1.131
DDR_A_MA4: length 72.6
  IN1 w0.076: 104.85,34.9 104.85,35.51 106.61,37.28 106.61,42.47 v1(106.06,43.03)
  IN1 w0.142: v1(72.23,7.18) 71.52,6.47 71.15,6.47 71.02,6.6 71.02,6.95 71.71,7.64 71.71,13.61 71.2,14.12 71.2,14.62 79.48,22.9 93.62,22.9 93.73,23.01 93.73,23.77 93.99,24.02 95.89,24.02 96.53,23.39 97.44,23.39 104.85,30.79 104.85,34.9
  BOTTOM w0.076: v1(106.06,43.03) 106.06,43.48 107.8,45.23 107.8,46.99 UC1.BB52
  BOTTOM w0.168: JDIMM1.128 71.03,6.48 71.72,7.18 v1(72.23,7.18)
DDR_A_MA5: length 73.1
  IN1 w0.076: v1(107.86,44.53) 107.86,43.67 107.61,43.41 106.9,43.41 106.78,43.29 106.78,37.01 105.27,35.5 105.27,34.04
  IN1 w0.142: 105.27,34.04 105.27,30.53 97.24,22.5 96.02,22.5 95.86,22.65 95.86,23.44 95.71,23.59 95.49,23.59 95.34,23.44 95.34,22.88 95.18,22.73 94.97,22.73 94.81,22.88 94.81,23.44 94.66,23.59 94.39,23.59 94.21,23.41 94.21,22.73 93.96,22.48 79.66,22.48 72.14,14.96 72.14,8.53 v1(72.23,8.45)
  BOTTOM w0.076: UC1.BA51 108.34,47.84 108.34,47.61 108.34,47.6 108.33,47.6 108.33,47.6 108.3,47.51 108.3,47.31 108.33,47.22 108.33,46.86 108.14,46.66 108.14,44.81 v1(107.86,44.53)
  BOTTOM w0.168: JDIMM1.126 70.52,6.99 71.98,8.45 v1(72.23,8.45)
DDR_A_MA6: length 71.9
  IN1 w0.076: v1(106.06,42.38) 106.24,42.38 106.45,42.17 106.45,37.52 104.36,35.44 104.36,34.72
  IN1 w0.142: v1(71.27,11.01) 71.27,11.01 71.07,10.81 70.87,10.81 70.77,10.91 70.77,12.52 70.96,12.71 71.07,12.71 71.26,12.9 71.26,13.17 71.07,13.36 70.96,13.36 70.77,13.55 70.77,14.78 79.31,23.32 90.56,23.32 90.76,23.52 90.76,24.3 90.94,24.48 91.32,24.48 91.47,24.33 91.47,23.47 91.62,23.32 91.84,23.32 91.99,23.47 91.99,24.33 92.15,24.48 92.36,24.48 92.52,24.33 92.52,23.47 92.67,23.32 92.89,23.32 93.04,23.47 93.04,24.33 93.19,24.48 96.47,24.48 96.66,24.29 96.66,24.02 96.85,23.83 97.12,23.83 97.31,24.02 97.31,24.29 97.5,24.48 97.9,24.48 104.36,30.94 104.36,34.72
  BOTTOM w0.076: UC1.BA52 107.9,47.51 107.64,47.25 107.64,45.3 105.69,43.35 105.69,42.54 105.86,42.38 v1(106.06,42.38)
  BOTTOM w0.168: JDIMM1.127 70.78,11.38 71.14,11.01 v1(71.27,11.01)
DDR_A_MA7: length 75.4
  IN1 w0.076: v1(106.06,41.08) 104.91,39.93 104.91,38.19 102.09,35.37 102.09,35.07
  IN1 w0.142: 102.09,35.07 102.09,31.75 97.03,26.69 85.68,26.69 85.04,26.05 83.65,26.05 83.02,25.43 78.43,25.43 68.08,15.07 68.08,9.77 69.47,8.37 69.47,5.96 69.83,5.6 70.23,5.6 70.51,5.88 70.51,6.36 v1(70.07,6.8)
  BOTTOM w0.076: v1(106.06,41.08) 105.52,41.61 105.52,43.42 107.47,45.36 107.47,47.77 107.68,47.98 107.68,48.52 108,48.85 UC1.AW52
  BOTTOM w0.168: JDIMM1.122 69.52,6.25 v1(70.07,6.8)
DDR_A_MA8: length 73.3
  IN1 w0.076: v1(106.06,37.94) 106.06,37.46 103.9,35.31 103.9,34.65
  IN1 w0.142: 103.9,34.65 103.9,31.14 97.67,24.91 90.61,24.91 90.2,24.5 90.2,23.92 90.02,23.74 79.13,23.74 70.34,14.95 70.34,10.67 70.66,10.35 70.66,7.79 70.8,7.65 71.12,7.65 71.27,7.79 v1(71.27,9.74)
  BOTTOM w0.076: v1(106.06,37.94) 106.48,38.36 106.48,43.67 107.97,45.16 107.97,46.73 108.17,46.93 108.17,47.19 108.13,47.28 108.13,47.29 108.13,47.54 108.17,47.63 108.17,47.84 108.14,47.92 108.14,47.92 108.1,48.02 108.1,48.28 UC1.AY52
  BOTTOM w0.168: v1(71.27,9.74) 70.35,10.65 70.35,11.88 70.27,11.95 JDIMM1.125
DDR_A_MA9: length 71.8
  IN1 w0.076: v1(106.06,38.59) 105.91,38.74 105.74,38.74 105.62,38.62 105.62,37.48 103.43,35.3 103.43,35.07
  IN1 w0.142: 103.43,35.07 103.43,31.27 97.51,25.34 89.96,25.34 89.81,25.19 89.81,24.72 89.67,24.58 89.43,24.58 89.29,24.72 89.29,25.19 89.13,25.34 88.92,25.34 88.76,25.19 88.76,24.32 88.62,24.18 88.42,24.18 88.24,24.36 88.24,25.19 88.09,25.34 87.87,25.34 87.72,25.19 87.72,24.33 87.56,24.17 87.35,24.17 87.19,24.33 87.19,25.19 87.04,25.34 86.77,25.34 86.42,24.99 86.42,24.4 86.18,24.16 78.96,24.16 69.4,14.6 69.4,14 69.91,13.49 69.91,12.51 69.4,12.01 69.4,11.18 69.54,11.04 v1(69.89,11.04)
  BOTTOM w0.076: UC1.BB54 106.98,46.98 106.98,45.57 104.9,43.49 104.9,41.49 105.27,41.11 105.27,39.38 v1(106.06,38.59)
  BOTTOM w0.168: JDIMM1.121 69.27,11.5 69.74,11.04 v1(69.89,11.04)
DDR_A_MA10: length 75.2
  IN1 w0.076: v1(108.74,50.5) 109.23,50.02 109.23,47.35 111.03,45.55 111.03,39.91 110.14,39.02 110.14,38.24
  IN1 w0.142: v1(76.68,6.54) 76.68,5.88 76.82,5.73 77.45,5.73 77.73,6.01 77.73,13.89 79.16,15.32 79.83,15.32 81.36,16.86 86.64,16.86 86.87,17.09 100.39,17.09 110.14,26.84 110.14,38.24
  BOTTOM w0.076: v1(108.74,50.5) UC1.AT50
  BOTTOM w0.168: v1(76.68,6.54) 77.53,5.69 JDIMM1.146
DDR_A_MA11: length 73.1
  IN1 w0.076: 102.98,35.07 102.98,35.32 105.39,37.74 105.39,39.46 105.49,39.56 105.74,39.56 v1(106.06,39.24)
  IN1 w0.142: 102.98,35.07 102.98,31.42 97.36,25.8 86.29,25.8 85.81,25.32 85.81,25.08 85.97,24.93 85.97,24.73 85.82,24.58 78.78,24.58 68.93,14.74 68.93,13.82 69.47,13.28 69.47,12.72 68.94,12.18 68.94,10.93 69.49,10.38 70,10.38 70.23,10.15 70.23,9.26 69.91,8.93 69.91,8.23 v1(70.07,8.07)
  BOTTOM w0.076: v1(106.06,39.24) 105.44,39.87 105.44,41.18 105.09,41.53 105.09,43.45 105.88,44.24 107.14,45.5 107.14,47.26 106.87,47.52 UC1.BA54
  BOTTOM w0.168: v1(70.07,8.07) 69.03,7.02 JDIMM1.120
DDR_A_MA12: length 73.5
  IN1 w0.076: 102.54,35.07 102.54,35.32 105.15,37.93 105.15,39.66 105.92,40.43 v1(106.06,40.43)
  IN1 w0.142: v1(69.03,10.22) 69.33,9.93 69.61,9.93 69.76,9.78 69.76,9.39 69.56,9.19 69.3,9.19 68.51,9.97 68.51,12.44 68.7,12.63 68.78,12.63 68.97,12.83 68.97,13.09 68.78,13.29 68.7,13.29 68.51,13.48 68.51,14.91 78.61,25.01 83.54,25.01 83.77,25.24 83.77,25.42 83.95,25.6 84.29,25.6 84.46,25.43 84.46,25.17 84.63,25.01 84.86,25.01 85.03,25.17 85.03,25.43 85.2,25.6 85.48,25.6 86.11,26.23 97.18,26.23 102.54,31.6 102.54,35.07
  BOTTOM w0.076: UC1.AW54 106.77,48.82 107.08,48.51 107.08,47.96 107.31,47.74 107.31,45.43 105.28,43.4 105.28,41.57 105.6,41.25 105.6,40.88 v1(106.06,40.43)
  BOTTOM w0.168: v1(69.03,10.22) 68.78,10.48 JDIMM1.119
DDR_A_MA13: length 77.7
  IN1 w0.076: v1(110.57,49.87) 110.71,49.74 110.71,49.33 112.29,47.74 112.29,46.14 112.81,45.63 112.81,41.16 112.58,40.93 112.58,39.62 112.04,39.08 112.04,37.67
  IN1 w0.142: v1(80.61,6.03) 80.14,6.5 80.14,7.23 79.55,7.83 79.55,10.14 80.14,10.73 80.14,12.31 81.79,13.96 83.4,13.96 84.24,14.8 87.3,14.8 87.74,15.23 102.98,15.23 103.97,16.23 104.24,16.23 104.42,16.05 104.69,16.05 104.88,16.24 104.88,16.51 104.7,16.69 104.7,16.96 104.89,17.15 105.16,17.15 105.48,16.84 105.73,16.84 105.92,17.03 105.92,17.31 105.62,17.61 105.62,17.88 105.81,18.07 106.08,18.07 106.39,17.76 106.67,17.76 106.86,17.95 106.86,18.21 106.54,18.53 106.54,18.8 106.73,18.99 107,18.99 107.33,18.66 107.55,18.66 107.74,18.85 107.74,19.17 107.46,19.45 107.46,19.72 107.65,19.91 107.92,19.91 108.1,19.73 108.37,19.73 108.56,19.92 108.56,20.19 108.38,20.37 108.38,20.64 112.04,24.3 112.04,37.67
  BOTTOM w0.076: v1(110.57,49.87) UC1.AU46
  BOTTOM w0.168: JDIMM1.158 80.53,5.95 v1(80.61,6.03)
