# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDD_EN: length 172.9
  IN1 w0.089: v1(135.01,58.13) 135.52,58.13 136.34,57.32 141.04,57.32 141.78,56.58 143.76,56.58 148.16,52.18 151.71,52.18 156.17,47.73 156.17,44.9 158.37,42.71 158.37,40.51 158.72,40.16 160.4,40.16 165.54,35.02 179.25,35.02 180.25,34.03 189.31,34.03 190.19,34.9 192.47,34.9 200.75,26.62 219.35,26.62 219.97,26 227.41,26 230.53,29.12 237.18,29.12 238.28,30.23 247.54,30.23 252.15,34.84 256.03,34.84 257.34,36.15 273.68,36.15 274.38,35.45 275.26,35.45 277,37.19 v1(277,38.63)
  BOTTOM w0.102: v2(277.28,43.16) 276.98,42.86 276.98,42.54 RN5.1 ; RN5.1 RN4.2 276.36,40.93 276.81,40.47 276.81,39.93 277,39.74 v1(277,38.63) ; RN5.1 276.42,41.85 277.27,41.85 277.39,41.73 UZ23.3 ; UC1.AB4 135.13,58.25 v1(135.01,58.13)
HDD_FALL_INT: length 188.8
  TOP w0.102: RC370.1 151.64,40.38 v1(151.23,40.79)
  IN1 w0.089: v1(135.06,53.9) 136.96,52 141.75,52 142.55,51.2 142.55,49.52 141.46,48.43 141.46,48.41 141.05,48 141.05,46.14 141.55,45.64 142.04,45.64 145.46,42.23 149.69,42.23 151.13,40.79 v1(151.23,40.79) 151.38,40.64 151.55,40.64 152.48,39.71 152.48,39.46 156.08,35.86 159.82,35.86 160.81,34.87 162.06,34.87 164.95,31.98 173.33,31.98 173.78,31.54 194.45,31.54 201.98,24.01 209.94,24.01 211.13,25.2 215.53,25.2 216.77,23.96 217.64,23.96 218.53,24.85 224.02,24.85 224.31,25.14 226.82,25.14 230.61,28.93 237.25,28.93 238.36,30.04 247.62,30.04 252.23,34.65 256.11,34.65 257.27,35.81 270.99,35.81 271.57,35.23 275.43,35.23 278.66,38.47 278.89,38.47 279.6,39.18 279.6,40.15 277.67,42.08 276.67,42.08 276.42,41.83 274.51,41.83 273.61,42.73 271.91,42.73 271.62,43.02 269.88,43.02 v1(269.6,43.3)
  BOTTOM w0.102: v1(269.6,43.3) 269.78,43.48 272.19,43.48 v2(272.45,43.73) 273.39,44.68 LGA1.12 ; v1(135.06,53.9) 134.8,53.64 UC1.AM5
HDD_UN4_UN5_EN: length 4
  TOP w0.102: v2(246.28,40.58) RN229.2 RN230.2 RN228.2 248.93,40.39 QN7.1
HDD_UN4_UN5_EN_R: length 73.7
  TOP w0.102: RN229.1 RN230.1 248.3,41.5 249.31,42.5 250,42.5 v2(250.68,43.17) 251.11,43.6 v1(251.44,43.6) ; v1(260.15,46.96) 260.66,46.96 260.96,47.26 UN4.3 ; v1(286.8,54.53) 286.8,53.41 287.84,52.37 289.65,52.37 289.89,52.6 UN5.3
  IN3 w0.122: v1(286.8,54.53) 286.49,54.83 286.09,54.83 284.82,53.56 284.82,52.7 281.59,49.48 281.59,47.94 275.84,42.18 275.84,41.15 273.14,38.45 270.62,38.45 269.93,37.76 v1(269.93,37.36) ; v1(251.44,43.6) 252.13,43.6 255.78,47.26 259.53,47.26 259.83,46.96 v1(260.15,46.96)
  BOTTOM w0.102: v1(260.15,46.96) 258.91,45.71 258.91,42.33 256.16,39.59 256.16,38.42 256.39,38.19 256.82,38.19 256.98,38.35 268.99,38.35 269.93,37.41 v1(269.93,37.36)
HDD_UN7_EN: length 3.2
  TOP w0.102: QN6.1 RN227.1 ; RN227.1 v2(252.68,41.22) ; RN227.1 RN226.2
HDD_UN7_EN_R: length 38.9
  TOP w0.102: UN7.7 275.75,63.82 275.87,63.7 275.87,62.1 275.54,61.77 275.54,60.65 274.63,59.73 274.12,59.73 272.93,58.54 272.93,57.37 269.74,54.18 265.6,54.18 264.65,55.14 261.52,55.14 259.42,53.03 259.42,52.23 255.66,48.47 255.66,46.25 v2(253.46,44.05) 251.54,42.13 RN227.2
HDMI_CEC: length 16.3
  TOP w0.102: v2(117.86,106.39) 117.35,106.9 RV19.1 116.03,107.52 115.7,107.52 115.32,107.9 v1(115.11,107.9)
  BOTTOM w0.102: v1(115.11,107.9) 114.6,107.4 110.05,107.4 108.15,109.3 108.15,110.17 107.73,110.58 105.42,110.58 104.68,111.32 JHDMI1.13
HDMI_CLKN: length 3.2
  TOP w0.094: RV34.1 106.24,104.4 LV12.2 105.89,104.05 105.89,103.54 RV17.1 106.05,103.08 105.9,102.92 105.9,102.48 CV38.1
HDMI_CLKP: length 3.2
  TOP w0.094: RV33.1 105.35,104.4 LV12.1 105.7,104.05 105.7,103.54 RV16.1 105.51,103.08 105.71,102.87 105.71,102.5 CV37.1
HDMI_CTRL_CLK: length 15
  IN1 w0.089: v1(112.5,110.66) 112.53,110.66 113.04,110.15 113.04,109.1 112.36,108.42 109.11,108.42 108.53,109.01 108.53,110.22 108.05,110.69 106.18,110.69 JHDMI1.15
  BOTTOM w0.102: v2(113.35,113.62) 113.11,113.38 RV22.1 113.11,110.98 QV3.6 112.78,110.97 112.5,110.69 v1(112.5,110.66)
HDMI_CTRL_DATA: length 14.6
  IN1 w0.089: v1(115,109.09) 113.33,109.09 112.45,108.21 109.02,108.21 108.31,108.92 108.31,110.13 107.96,110.48 106.31,110.48 106.05,110.22 JHDMI1.16
  BOTTOM w0.102: v2(116.39,111.14) 116.39,110.25 RV23.1 115.8,109.67 QV3.3 v1(115,109.09)
HDMI_HPD: length 13.9
  TOP w0.102: v2(117.89,107.69) 116.78,107.69 QV5.1 115.99,108.48 114.56,108.48 114.33,108.71 RV21.1 114.25,108.15 v1(114.5,107.9)
  BOTTOM w0.102: v1(114.5,107.9) 109.92,107.9 108.36,109.47 108.36,110.51 JHDMI1.19
HDMI_L_CLKN: length 6.4
  TOP w0.094: RV34.2 106.24,105.31 LV12.3 105.89,105.66 105.89,106.03 106.05,106.19 106.05,106.19 RV35.1 105.89,106.76 105.89,107.16 105.82,107.22 105.82,107.27 105.41,107.68 105.36,107.68 v4(104.67,108.37) 104.24,108.81 103.81,108.81 103.64,108.98 103.64,109.2 103.64,109.2 103.64,109.41 JHDMI1.12
HDMI_L_CLKP: length 6.4
  TOP w0.094: JHDMI1.10 103.46,109.41 103.46,109.28 103.45,109.27 103.45,108.91 103.74,108.62 104.16,108.62 104.31,108.47 104.31,108.42 104.8,107.94 104.85,107.94 v4(105.46,107.32) 105.7,107.08 105.7,106.76 RV35.2 105.7,106.03 105.7,105.66 LV12.4 105.35,105.31 RV33.2
HDMI_L_TX_N0: length 12.5
  TOP w0.094: JHDMI1.9 102.16,110.93 102.16,110.81 102.29,110.69 107.54,110.69 108.73,109.49 v4(108.73,108.77) 108.73,107.76 108.77,107.73 108.77,107.14 108.73,107.11 108.73,106.76 RV32.1 108.71,106 108.71,105.64 LV9.3 109.03,105.31 RV31.2
HDMI_L_TX_N1: length 6
  TOP w0.094: JHDMI1.6 100.59,109.36 100.59,108.9 100.7,108.79 100.74,108.79 101.16,108.38 101.16,108.33 v4(101.88,107.61) 102.33,107.16 102.33,106.78 RV29.1 102.33,106.05 102.33,105.66 LV6.3 102.68,105.31 RV28.2
HDMI_L_TX_N2: length 7.6
  TOP w0.094: RV25.2 99.13,105.31 LV3.3 98.78,105.66 98.78,106.08 RV26.1 98.85,106.74 98.85,107.56 v4(98.43,107.97) 98.11,108.3 98.11,108.91 98.14,108.95 98.14,109.53 98.11,109.56 98.11,110.05 98.51,110.45 98.89,110.45 99.16,110.72 99.16,110.93 JHDMI1.3
HDMI_L_TX_P0: length 12.5
  TOP w0.094: RV30.2 108.15,105.31 LV9.4 108.52,105.68 108.52,106.05 108.5,106.07 108.5,106.08 RV32.2 108.55,106.76 v4(108.55,107.43) 108.55,108.44 108.52,108.48 108.52,109.06 108.55,109.09 108.55,109.41 107.46,110.5 102.21,110.5 101.98,110.73 101.98,110.89 JHDMI1.7
HDMI_L_TX_P1: length 5.9
  TOP w0.094: RV27.2 101.8,105.31 LV6.4 102.15,105.66 102.15,106.05 RV29.2 102.15,106.78 102.15,107.08 101.98,107.25 101.93,107.25 101.52,107.66 101.52,107.71 v4(100.8,108.43) 100.4,108.82 100.4,109.47 JHDMI1.4
HDMI_L_TX_P2: length 7.7
  TOP w0.094: RV24.2 98.24,105.31 LV3.4 98.59,105.66 98.59,106.08 RV26.2 98.66,106.88 98.66,107.48 98.53,107.61 98.49,107.61 98.07,108.02 98.07,108.07 97.92,108.22 v4(97.92,109.24) 97.92,110.13 98.43,110.64 98.81,110.64 98.97,110.79 98.97,110.9 JHDMI1.1
HDMI_OB: length 23.6
  TOP w0.102: v1(107.27,103.99) RV17.2 107.27,102.16 RV14.2 ; RV15.2 111.13,103.13 QV4.1 111.13,103.61 v1(110.75,103.99) ; RV10.2 v1(97.21,104.05) ; RV11.2 RV12.2 101,103.3 v1(101,104.04) ; RV16.2 RV13.2 103.46,103.92 v1(103.58,104.04)
  BOTTOM w0.102: v1(97.21,104.05) 97.53,104.05 97.97,104.48 v2(98.51,104.48) 100.55,104.48 v1(101,104.04) v1(103.58,104.04) 104.07,104.53 106.66,104.53 107.2,103.99 v1(107.27,103.99) v1(110.75,103.99)
HDMI_TX_N0: length 4
  TOP w0.094: RV31.1 109.03,104.4 LV9.2 108.68,104.04 108.68,103.84 108.83,103.69 v4(108.83,103.04) 108.83,102.38 RV15.1 108.88,101.79 108.88,101.59 CV36.2
HDMI_TX_N1: length 2.6
  TOP w0.094: RV28.1 102.68,104.4 LV6.2 102.3,104.02 102.3,103.23 102.45,103.08 RV13.1 102.54,102.21 CV34.2
HDMI_TX_N2: length 2.6
  TOP w0.094: RV25.1 99.13,104.4 LV3.2 98.75,104.02 98.75,103.23 98.9,103.08 RV11.1 98.99,102.21 CV32.2
HDMI_TX_P0: length 4
  TOP w0.094: RV30.1 108.15,104.4 LV9.1 108.47,104.07 108.47,103.78 108.64,103.61 108.64,103.37 108.61,103.33 108.61,102.75 108.64,102.72 108.64,102.41 RV14.1 108.69,101.65 108.69,101.48 CV35.2
HDMI_TX_P1: length 2.6
  TOP w0.094: CV33.2 101.68,102.21 RV12.1 102.12,103.51 102.12,104.08 LV6.1 101.8,104.4 RV27.1
HDMI_TX_P2: length 2.6
  TOP w0.094: RV24.1 98.24,104.4 LV3.1 98.56,104.08 98.56,103.51 RV10.1 98.13,102.21 CV31.2
HOST_DEBUG_TX: length 75.9
  TOP w0.102: v1(299.6,50.88) 299.53,50.82 RZ132.1
  TOP w0.112: v1(300.74,80.35) 300.74,80.31 UE1.G11
  IN3 w0.122: v1(300.74,80.35) 301.14,80.75 305.96,80.75 308.43,78.28 308.43,75.32 307.84,74.73 307.84,67.34 307.55,67.05 307.55,65.31 306.8,64.55 306.8,63.81 305.85,62.87 305.85,62.11 303.14,59.4 303.14,54.73 299.6,51.19 v1(299.6,50.88)
  BOTTOM w0.102: RE73.2 RE306.2 274.58,73.95 275.15,73.95 275.6,74.4 JDEG1.8 276.45,74.4 276.92,73.93 279.38,73.93 279.66,74.21 279.66,76.11 281.61,78.05 281.98,78.05 284.33,80.4 286.46,80.4 289.16,83.1 v3(289.26,83.1) 290.56,83.1 291.23,82.42 292.04,82.42 293.79,80.67 295.26,80.67 295.83,81.24 298.34,81.24 299.23,80.35 v1(300.74,80.35)
HOST_SD_WP#: length 159.9
  TOP w0.102: v1(133.61,87.13) 133.61,86.99 133.61,86.98 RC292.1 ; v1(34.37,59.73) v2(34.37,57.68) 34.37,55.63 QR1.2
  IN2 w0.122: v1(34.37,59.73) 35.11,60.48 35.11,64.58 46.77,76.25 48.98,76.25 54.49,81.76 54.78,81.76 58.12,85.09 58.78,85.09 61.42,87.72 62.85,87.72 65.41,90.28 67.81,90.28 68.36,90.82 86.82,90.82 87.97,89.68 90.3,89.68 91.64,88.35 99.07,88.35 99.8,87.61 100.43,87.61 101.3,88.48 104,88.48 104.51,87.98 107.52,87.98 108.06,87.43 113.46,87.43 113.6,87.58 117.68,87.58 118.7,86.57 133.04,86.57 v1(133.61,87.13)
  IN4 w0.089: v1(131.76,60.04) 133,60.04 133.42,59.61 136.47,59.61 136.93,60.08 136.93,65.19 138.64,66.9 138.64,68.66 137.7,69.6 137.7,77.53 137.26,77.96 136.67,77.96 135.45,79.19 135.45,82.83 135.64,83.02 135.64,85.55 134.68,86.51 134.2,86.51 133.61,87.1 v1(133.61,87.13)
  BOTTOM w0.102: UC1.W10 132.13,59.66 v1(131.76,60.04)
HP_OUT_L: length 17.2
  TOP w0.127: v2(307.45,39.39) 307.79,39.05 v1(307.79,38.82)
  TOP w0.203: UA1.32 303.7,35.92 304.37,36.59 v1(304.56,36.59)
  TOP w0.381: v1(307.79,38.82) 307.29,38.32 RA7.1 ; CA43.2 306.77,29.86 v1(306.33,29.86)
  IN2 w0.381: 307.28,36.59 307.79,36.09 307.79,31.32 v1(306.33,29.86) ; 307.28,36.59 307.79,37.1 v1(307.79,38.82) ; 307.28,36.59 v1(304.56,36.59)
HP_OUT_R: length 12.9
  TOP w0.203: UA1.33 303.39,36.32 v1(303.47,36.4)
  TOP w0.381: RA8.1 306.82,35.63 306.39,35.2 v1(306.2,35.2) ; CA44.2 304.49,29.93 v1(303.98,29.93)
  IN1 w0.381: v1(303.47,36.4) 304.17,35.71 305.12,35.71 305.63,35.2 v1(306.2,35.2)
  IN2 w0.381: v1(306.2,35.2) 306.68,34.71 306.68,32 304.61,29.93 v1(303.98,29.93)
HSYNC_CONN: length 5.2
  TOP w0.102: RV122.1 RV650.2 CV133.1 v2(319.05,78.64) 319.78,78.64 319.82,78.6 JCRT1.13
HSYNC_CRT: length 71.8
  TOP w0.102: v1(316.22,77.11) 316.44,77.11 316.62,77.28 RV650.1 ; v1(280.7,54.61) 280.56,54.47 UV6.19
  IN2 w0.122: v1(316.22,77.11) 316.22,80.47 315.22,81.48 314.55,81.48 313.19,82.83 313.19,83.32 311.59,84.93 301.3,84.93 300.41,85.82 298.71,85.82 297.46,84.57 292.32,84.57 291.86,84.12 291.86,82.66 289.08,79.88 288.55,79.88 287.19,78.52 287.19,75.98 285.17,73.96 283.88,73.96 280.14,70.23 280.14,67.17 280.73,66.58 280.73,65.89 281.05,65.57 282.71,65.57 283.52,64.76 283.52,59.12 282.81,58.41 282.81,56.72 v1(280.7,54.61)
HV_GATE1_A: length 3.3
  TOP w0.076: v2(36.41,79) 36.2,79.22 35.39,79.22 35.32,79.29 34.89,79.29 UT5.B9
  TOP w0.102: v2(36.41,79) 36.5,78.91 36.61,78.91 RT64.1
HV_GATE2_A: length 5.8
  TOP w0.102: v2(39.68,76.8) 37.83,76.8 RT65.1 36.93,77.7 36.93,78.22 36.52,78.63 36.23,78.63 35.9,78.96 35.22,78.96 UT5.A9
HW_ACAVIN_NB: length 461.7
  TOP w0.102: v1(306.08,76.35) 306.02,76.29 305.53,76.29 UE1.N6 ; v1(32.96,36.15) 32.96,35.82 PR1241.1 PR1258.1 ; v1(66.3,108.48) 66.96,109.14 PR1203.2 ; PR941.1 v1(33.9,28.72) ; v1(24.74,41.83) v2(24.74,40.53) 24.74,37.13 25.6,36.28 v1(27.5,36.28)
  IN1 w0.089: v1(27.5,36.28) 32.83,36.28 v1(32.96,36.15) 32.96,33.74 33.9,32.8 v1(33.9,28.72) ; v1(66.3,108.48) 66.11,108.48 64.09,106.46 64.09,103.73 61.19,100.83 61.19,92.5 61.4,92.3 61.4,91.31 v1(61.24,91.15)
  IN2 w0.122: v1(61.24,91.15) 60.95,90.86 54.73,90.86 53.55,89.68 49,89.68 47.74,88.42 44.67,88.42 41.28,85.03 37.52,85.03 36.9,84.41 36.9,81.81 36.39,81.3 36.39,80.85 37.41,79.84 37.41,70.95 25.51,59.05 25.51,56.84 22.94,54.27 22.94,50.5 21.65,49.21 21.65,47.13 23.8,44.98 23.8,42.77 v1(24.74,41.83)
  IN3 w0.122: v1(66.5,89.67) 67.3,89.67 68.33,90.7 71.44,90.7 72.38,89.76 86.73,89.76 88.59,87.9 92.17,87.9 95.84,91.56 99.47,91.56 101.58,89.45 108.73,89.45 109.16,89.02 120.71,89.02 121.76,87.96 128.87,87.96 129.23,88.32 133.26,88.32 133.56,88.63 151.73,88.63 156.94,83.42 156.94,75.17 158.63,73.47 158.63,69.03 161.32,66.34 161.32,61.67 176.11,46.88 176.11,45.88 184.66,37.33 186,37.33 186.45,36.88 187.92,36.88 188.52,36.28 191.51,36.28 199.83,27.96 202.24,27.96 206.01,24.19 207.78,24.19 208.88,23.09 209.65,23.09 210.33,22.42 211.99,22.42 213.69,20.72 217.14,20.72 218.95,22.53 220.91,22.53 222.45,21 224.07,21 225.02,20.04 230.16,20.04 232.33,22.21 240.2,22.21 245.03,27.04 248.37,27.04 249.4,28.08 254.3,28.08 255.16,28.95 258.89,28.95 260.26,30.32 278.47,30.32 281.82,33.67 281.97,33.67 284.63,36.33 284.63,37.53 289.08,41.97 289.08,43.38 290.72,45.02 291.59,45.02 293.89,47.32 293.89,48.68 295.44,50.23 296.73,50.23 297.57,51.07 297.57,51.9 297.95,52.28 297.95,53.8 299.88,55.73 299.88,58.24 302.04,60.39 302.04,62.48 302.27,62.71 302.7,62.71 304.06,64.06 304.06,65.08 303.62,65.51 303.07,65.51 302.7,65.88 302.7,67.16 304.25,68.71 305.35,68.71 305.97,69.33 305.97,71.42 305.62,71.77 305.62,75.89 v1(306.08,76.35)
  BOTTOM w0.102: PR21.1 61.7,94.35 61.47,94.12 61.47,91.38 v1(61.24,91.15) 65.99,91.15 66.5,90.65 v1(66.5,89.67) ; PU1201.1 66.92,110.27 66.55,110.64 65.53,110.64 PC1207.1 65.43,109.61 PR1206.2 66.3,108.75 v1(66.3,108.48)
I2C1_SCK_TP: length 130.9
  TOP w0.102: RZ21.2 219.44,24.78 217.78,24.78 v1(217.4,25.16) RZ29.1
  IN1 w0.089: v1(132.45,61.28) 131.98,61.75 125.34,61.75 124.23,60.65 124.23,58.13 126.5,55.86 130.65,55.86 131.37,55.14 132.25,55.14 132.92,54.46 135.91,54.46 136.67,53.7 136.67,52.98 137.24,52.41 141.83,52.41 142.97,51.26 142.97,49.44 141.5,47.97 141.5,46.92 142.02,46.4 142.02,45.94 145.54,42.42 150.19,42.42 156.28,36.33 159.62,36.33 160.89,35.06 162.14,35.06 164.19,33.01 167.16,33.01 167.9,32.28 172.04,32.28 172.36,32.59 176.8,32.59 177.41,31.98 194.46,31.98 202.2,24.24 209.9,24.24 211.05,25.39 215.61,25.39 216.85,24.15 217.56,24.15 217.81,24.4 217.81,24.76 v1(217.4,25.16)
  BOTTOM w0.076: UC1.U9 132.78,60.68 132.45,61.01 v1(132.45,61.28)
I2C1_SCK_TP_R: length 9.6
  TOP w0.102: JKBTP1.2 213.65,22.15 214.05,22.55 214.05,24.1 RZ347.1 215.63,24.96 RZ29.2 215.83,25.42 216.08,25.67 217.78,25.67 RZ117.2 218.67,25.8 218.67,26.61 v3(218.39,26.89)
I2C1_SDA_TP: length 118.5
  TOP w0.102: RZ20.2 219.54,24.55 217.78,24.55 217.75,24.53 v1(217.4,24.53) 217.28,24.66 216.76,24.66 216.65,24.55 216.65,24.24 RZ26.1
  IN1 w0.089: v1(217.4,24.53) 217.24,24.36 216.94,24.36 215.7,25.61 210.96,25.61 209.81,24.46 202.29,24.46 194.54,32.2 177.5,32.2 176.89,32.81 172.27,32.81 171.95,32.49 167.99,32.49 167.25,33.23 164.28,33.23 162.23,35.28 160.98,35.28 159.71,36.54 156.37,36.54 150.28,42.63 145.63,42.63 142.23,46.03 142.23,46.49 141.71,47.01 141.71,47.88 143.18,49.35 143.18,51.35 141.91,52.62 137.33,52.62 136.89,53.07 136.89,53.79 135.31,55.36 131.69,55.36 130.22,56.83 130.22,59.22 130.51,59.51 132.71,59.51 v1(133.11,59.11)
  BOTTOM w0.102: v1(133.11,59.11) 133.11,60.34 UC1.U8
I2C1_SDA_TP_R: length 7.6
  TOP w0.102: JKBTP1.3 213.66,21.65 214.15,22.14 214.3,22.14 v2(214.46,22.29) 214.46,22.47 214.37,22.56 214.37,23.89 214.57,24.1 RZ346.1 215.35,24.1 215.4,24.15 RZ26.2 215.83,23.92 216.11,23.64 217.78,23.64 RZ116.2
I_ADP: length 358
  TOP w0.102: v1(209.72,2.3) 210.52,3.1 210.52,9.25 210.8,9.54 210.8,11.8 209.78,12.82 209.78,13.67 208.87,14.58 208.87,26.51 v2(209.19,26.83) 209.33,26.97 v1(209.33,27.77) ; PR935.2 19.44,9.16 v1(19.69,9.42)
  TOP w0.107: v1(295.96,80.33) UE1.B11
  IN3 w0.122: v1(295.96,80.33) 295.96,80.32 290.23,74.59 290.23,73.87 289.59,73.23 289.59,67.73 291.96,65.36 291.96,64.24 290.86,63.14 290.86,62.55 290.4,62.1 290.4,61.36 289.54,60.49 288.66,60.49 287.26,59.09 287.26,58.67 287.89,58.04 287.89,54.71 286.47,53.29 286.47,52.1 285.72,51.36 284.1,51.36 282.05,49.31 282.05,47.77 277.96,43.68 277.96,42.58 277.43,42.05 277.43,41 277.27,40.84 277.09,40.84 276.79,40.53 276.79,39.95 276.89,39.85 276.89,39.14 276.51,38.76 276.51,38.22 276.07,37.78 271.42,37.78 270.13,36.49 268.36,36.49 267.67,35.81 258.57,35.81 256.85,34.09 248.33,34.09 246.9,32.66 242.12,32.66 237.73,28.27 228.37,28.27 227.61,27.51 222.81,27.51 222.13,28.19 213.62,28.19 213.44,28.36 209.92,28.36 v1(209.33,27.77) ; v1(19.69,9.42) 19.09,8.82 19.09,7.24 24.77,1.57 107.56,1.57 111.85,5.86 117.3,5.86 120.66,2.49 141.53,2.49 142.55,1.47 160.01,1.47 163.25,4.72 165.93,4.72 169.13,1.52 185.02,1.52 185.93,2.43 188.98,2.43 189.94,3.39 196.98,3.39 197.48,2.89 200.39,2.89 200.73,3.23 204.23,3.23 204.81,2.66 208.57,2.66 208.72,2.8 209.22,2.8 v1(209.72,2.3)
I_BATT: length 350.8
  TOP w0.102: v1(209.35,21.61) 209.35,14.39 210.01,13.73 210.01,12.88 211.01,11.88 211.01,9.45 210.9,9.34 v2(210.9,8.78) 210.9,2.78 v1(210.41,2.28) ; v1(305.44,67.52) 305.26,67.52 RE64.2 ; v1(19.71,8.57) 19.42,8.27 PR947.2
  IN3 w0.122: v1(209.35,21.61) 210.18,21.61 211.51,20.29 212.67,20.29 213.02,19.93 220.45,19.93 220.68,20.16 223.96,20.16 224.74,19.37 230.44,19.37 232.52,21.46 240.43,21.46 245.29,26.32 248.59,26.32 249.57,27.3 255.61,27.3 256.54,28.23 259.18,28.23 260.51,29.56 278.95,29.56 285.34,35.95 285.34,37.27 290.25,42.18 290.48,42.18 290.97,42.67 290.97,43.14 291.44,43.6 291.44,43.92 294.58,47.06 294.58,48.43 295.72,49.56 297.01,49.56 298.27,50.83 298.27,51.32 301.21,54.26 301.21,58.49 305.11,62.39 305.11,65.42 304.2,66.32 304.2,66.69 305.03,67.52 v1(305.44,67.52) ; v1(19.71,8.57) 19.35,8.2 19.35,7.31 24.86,1.79 104.65,1.79 105.48,2.62 108.27,2.62 111.77,6.11 117.46,6.11 120.83,2.75 141.59,2.75 142.65,1.7 159.92,1.7 163.19,4.97 166.18,4.97 169.38,1.77 184.89,1.77 185.81,2.69 188.87,2.69 189.81,3.62 197.07,3.62 197.56,3.12 199.33,3.12 200.22,4.01 203.83,4.01 204.93,2.91 208.46,2.91 208.58,3.03 209.65,3.03 v1(210.41,2.28)
I_BATT_R: length 9.6
  TOP w0.102: v1(304.86,69.61) 304.84,69.6 CE3.1 304.82,68.87 RE64.1 ; v1(302.36,73.93) UE1.J4
  IN1 w0.089: v1(304.86,69.61) 306,70.75 306,71.44 305.14,72.31 303.92,72.31 303.56,72.66 303.56,73.35 303.38,73.53 302.76,73.53 v1(302.36,73.93)
I_SYS: length 462.7
  TOP w0.102: PR620.1 73.17,55.63 73.69,55.11 73.69,54.45 73.43,54.18 72.73,54.18 v1(72.27,53.72) ; v1(211.4,2.29) 211.69,2.59 211.69,9.31 211.56,9.44 211.56,13.41 211.24,13.73 v1(211.24,14.83) ; v1(310.63,67) 310.63,67.17 RE312.2 ; v1(19.11,10.69) PR936.2
  IN3 w0.122: v1(19.11,10.69) 19.55,10.24 20.72,10.24 22.18,8.78 22.18,5.4 25.56,2.02 85.49,2.02 86.44,2.96 90.02,2.96 90.53,2.46 103.1,2.46 103.51,2.88 108.15,2.88 111.64,6.37 117.56,6.37 120.92,3 141.67,3 142.75,1.92 159.83,1.92 163.13,5.23 166.38,5.23 168.72,2.88 185.01,2.88 185.09,2.79 185.53,2.79 185.68,2.94 188.73,2.94 189.63,3.84 198.42,3.84 198.79,3.47 199.36,3.47 200.13,4.23 207.8,4.23 208.73,3.31 210.38,3.31 v1(211.4,2.29) ; v1(310.63,67) 310.63,64.77 307.85,61.99 307.85,60.95 307.28,60.38 307.28,55.19 304.74,52.65 303.99,52.65 302.77,51.43 302.77,50.69 301.57,49.48 299.41,49.48 299.03,49.1 299.03,48.11 299.24,47.9 299.24,47.31 297.87,45.94 297.87,44.64 297.14,43.92 296.13,43.92 296.01,43.79 296.01,42.84 294.16,40.99 294.16,40.3 293.71,39.85 293.71,39.58 293.09,38.95 293.09,37.96 292.2,37.07 292.2,37.07 290.1,34.97 289.34,34.97 281.7,27.33 266.18,27.33 265.96,27.55 261.35,27.55 259.09,25.29 250.66,25.29 249.57,24.2 246.65,24.2 240.88,18.43 232.48,18.43 229.76,15.72 223.83,15.72 222.8,14.69 219.52,14.69 219.23,14.98 211.39,14.98 v1(211.24,14.83)
  IN4 w0.089: v1(19.11,10.69) 19.11,8.27 20.58,6.8 28.86,6.8 30.73,4.94 36.63,4.94 39.79,8.09 39.79,12.19 40,12.41 40,41.86 39.02,42.84 39.02,54.22 40.62,55.82 51.86,55.82 53.28,54.4 58.96,54.4 59.55,54.99 70.99,54.99 v1(72.27,53.72)
  BOTTOM w0.102: v2(72.65,54.2) 72.65,54.15 72.27,53.76 v1(72.27,53.72)
I_SYS_R: length 13.6
  TOP w0.102: RE312.1 RE313.1 CE4.1 309.78,69.49 v1(309.64,69.62) v2(309.64,70.37)
  TOP w0.107: v1(302.34,74.74) UE1.J5
  IN1 w0.089: v1(309.64,69.62) 309.64,69.7 307.88,71.46 307.88,71.54 307.11,72.31 305.65,72.31 304.49,73.47 304.49,74.06 304.26,74.29 303.83,74.29 303.79,74.33 302.95,74.33 302.55,74.74 v1(302.34,74.74)
IA1N: length 8.4
  TOP w0.102: v1(67.63,73.3) 67.61,73.32 67.19,73.32 v2(67.09,73.42)
  TOP w0.254: PR677.1 v1(68.98,68.46) ; PR666.1 v1(67.63,73.3)
  BOTTOM w0.254: 69.35,70.12 68.98,69.75 v1(68.98,68.46) ; 69.35,70.12 68.14,71.33 68.14,72.79 v1(67.63,73.3) ; 69.35,70.12 PL610.2
IA1P: length 3.6
  TOP w0.102: v1(66.77,70.12) 67.01,69.88 v2(67.01,69.59)
  TOP w0.254: PR667.2 66.63,70.95 PR668.1 66.62,70.27 v1(66.77,70.12)
  BOTTOM w0.254: PL610.3 v1(66.77,70.12)
IA2N: length 26.7
  TOP w0.102: v2(73.36,59.33) 73.36,59.09 v1(72.84,58.57)
  TOP w0.254: v1(72.84,58.57) 72.5,58.57 PR670.2
  IN2 w0.254: v1(72.84,58.57) 72.84,59.33 73.35,59.84 v1(73.35,74.95)
  BOTTOM w0.254: v1(72.84,58.57) 72.78,58.57 72.22,58.01 PR673.1 ; PL613.2 76.59,78.95 76.21,78.57 76.21,75.77 75.38,74.95 v1(73.35,74.95)
IA2P: length 12.8
  TOP w0.254: v1(73.74,78.95) 72.95,78.16 72.95,75.23 71.51,73.78 v2(71.51,73.3) 71.51,71.58 70.87,70.95 PR674.2 68.98,70.93 PR675.1
  BOTTOM w0.254: PL613.3 v1(73.74,78.95)
IA_SNUB1: length 3.2
  TOP w0.102: v2(66.22,68.52) 65.89,68.85 PR663.2
  TOP w0.508: PC662.1 PR663.2
IA_SNUB2: length 5.2
  TOP w0.102: PR676.2 70.01,75.76 v2(69.8,75.96)
  TOP w0.508: PC678.1 70.87,77.23 71.76,76.35 PR676.2
IA_SW1: length 4.1
  TOP w0.102: v2(64.58,73.03) 64.69,72.93 PR663.1
  TOP w0.508: PR663.1 64.69,70.73 64.16,70.21 v1(63.1,70.21)
IA_SW2: length 3.4
  TOP w0.102: PR676.1 71.76,79.47 v2(71.02,80.21)
  TOP w0.508: PR676.1 v1(70.46,78.43)
IFDET_SATA_PCIE#: length 21.5
  TOP w0.102: RN186.1 226.14,31.21 225.66,30.73 219.03,30.73 218.04,31.72 218.04,34.08 ; RN189.1 218.27,34.31 218.04,34.08 ; QN4.6 211.59,35.72 RN192.1 RN171.2 v2(214.95,35.84) 216.27,35.84 218.04,34.08
ILIM_SEL: length 3.1
  TOP w0.102: RI13.1 305.97,62.78 v2(306.77,62.78) 307.46,62.78 307.99,62.25 UI3.4
ILMT_+1VALWP: length 6
  BOTTOM w0.102: v2(186.25,97.74) 186.25,97.49 185.96,97.2 184.62,97.2 PR307.2
  BOTTOM w0.254: PU301.13 183.32,94.38 183.6,94.66 183.6,95.29 PR310.1 PR307.2
ILMT_DDR: length 5.7
  BOTTOM w0.102: PR205.1 v2(41.15,45.56)
  BOTTOM w0.203: PU200.17 45.74,46.47 45.54,46.27 43.78,46.27 43.5,45.99 PR207.2
  BOTTOM w0.254: PR207.2 PR205.1
IMON_GT: length 4.5
  TOP w0.102: v2(63.99,51.2) 64.04,51.25 v1(64.62,51.25)
  TOP w0.203: v1(64.62,51.25) 64.83,51.25 65.29,50.78 PU602.14
  BOTTOM w0.254: v1(64.62,51.25) 64.87,51.25 65.21,50.91 PC625.2 PR629.2
IMON_VSA: length 4.4
  TOP w0.102: v1(67.06,46.38) 66.95,46.27 v2(66.5,46.27)
  TOP w0.203: PU602.23 67.76,47.08 v1(67.06,46.38)
  BOTTOM w0.254: v1(67.06,46.38) 67.75,47.07 PR651.1 68.08,47.05 PC643.1
IMVP_VR_ON: length 428.4
  TOP w0.102: v1(303.79,90.7) 304.21,90.28 v2(304.91,90.28) 305.66,90.28 305.8,90.42 305.8,92.08 306.06,92.35 UE3.4 306.81,93.54 RE304.1 ; UE4.2 v1(290.66,86.38) ; PR616.1 74.45,53.71 v1(74.04,54.12)
  IN3 w0.122: v1(41.88,57.62) 40.52,58.98 40.52,70.14 42.2,71.83 42.2,72.19 55.9,85.89 57.03,85.89 59.46,88.31 61.2,88.31 64.42,91.54 66.89,91.54 67.91,92.56 72.24,92.56 73.09,91.71 87.69,91.71 88.02,91.38 91.02,91.38 92.72,93.08 93.43,93.08 95.74,95.4 97.26,95.4 97.72,94.93 106.05,94.93 106.51,95.4 107.76,95.4 108.27,94.89 119.58,94.89 122.38,97.69 125.53,97.69 128.12,95.1 148.87,95.1 v1(149.29,95.52)
  IN4 w0.089: v1(41.88,57.62) 42.54,56.96 52.09,56.96 53.68,55.36 58.12,55.36 58.97,56.21 71.7,56.21 73.79,54.12 v1(74.04,54.12) ; v1(303.79,90.7) 303.79,90.33 303.28,89.83 299.13,89.83 298,90.96 294.81,90.96 292.42,88.57 292.42,87.45 291.34,86.38 v1(290.66,86.38) 289.11,84.83 288.35,84.83 287.3,85.87 284.99,85.87 283.88,86.98 281.55,86.98 280.95,87.58 276.73,87.58 276.2,87.05 276.2,84.56 275,83.36 274.44,83.36 271.94,80.86 271.94,79.99 270.92,78.97 270.92,71.35 272.03,70.24 272.03,63.07 273.14,61.96 273.14,56.74 272.5,56.1 272.5,54.76 271.46,53.71 270.52,53.71 266.37,49.57 266.37,48.65 265.15,47.43 265.15,47.11 264.67,46.63 264.27,46.63 263.83,46.2 263.83,45.54 260.63,42.34 260.63,42.23 251.59,33.19 251.59,32.66 248.29,29.36 240.5,29.36 236.12,33.74 224.6,33.74 224.1,33.23 219.65,33.23 217.62,31.2 211.36,31.2 208.81,33.75 200.21,33.75 198,35.96 198,37.53 193,42.53 193,46.12 189.95,49.16 184.09,49.16 173.76,59.49 173.76,78.66 156.9,95.52 v1(149.29,95.52)
IMVP_VR_ON_EC: length 28.9
  TOP w0.102: v1(306.88,76.36) 306.51,76.73 UE1.N7 ; RPE10.2 307.48,89.11 307.79,89.43 309,89.43 309.81,88.61 v1(309.81,87.88) ; v1(309.88,91.92) 309.88,92.12 309.38,92.62 v2(309.38,93.08) 309.38,93.57 RE304.2 308.25,94.69 UE3.1
  IN4 w0.089: v1(309.81,87.88) 309.64,88.04 309.64,91.68 v1(309.88,91.92)
  BOTTOM w0.102: v1(309.81,87.88) 309.61,87.67 309.61,85.72 306.97,83.08 306.12,83.08 305.31,82.28 305.31,79.4 305.61,79.1 305.61,78 306.05,77.56 306.3,77.56 306.66,77.2 306.66,76.9 306.88,76.68 v1(306.88,76.36)
INT_SPK_L+: length 11.1
  IN1 w1.016: 290.63,30.5 291.01,30.88 291.01,31.29 291.67,31.95 293.01,31.95 296.55,34.56 297.92,35.93 297.92,36.36 298.72,37.16
  vias: v1(289.5,30.37) v1(289.99,30.02) v1(300.01,40.59) v1(300.01,40) v2(290,30.54)
INT_SPK_L-: length 11.5
  IN1 w1.016: 289.76,31.96 289.76,32.15 291.11,33.51 292.43,33.51 295.35,35.57 296.41,36.63 296.41,37.32 298,38.91 298.1,38.91
  vias: v1(289.48,31.01) v1(290.01,31.26) v1(299.37,40.56) v1(299.34,39.97) v2(299.38,39.46)
INT_SPK_R+: length 5.7
  IN4 w1.016: 295.05,40.4 293.85,40.4 293.21,39.77 290.59,39.77 289.9,39.08
  vias: v1(288.75,38.07) v1(289.18,38.5) v1(298.15,40.68) v1(298.15,40.1) v2(298.09,39.59)
INT_SPK_R-: length 11.8
  IN4 w1.016: 287.81,39.64 289.56,41.39 290.17,41.39 290.52,41.74 293.03,41.74 293.21,41.93 298.71,41.93
  vias: v1(287.53,38.82) v1(287.98,39.26) v1(298.79,40.68) v1(298.73,40.05) v2(287.01,38.14)
INT_SPKR_L+: length 20.2
  TOP w1.016: DA6.2 285.48,28.09 v3(280.17,28.09) 268.49,28.09 268.42,28.15 268.29,28.15 267.09,29.36 266.77,29.36
INT_SPKR_L-: length 18.9
  TOP w1.016: 266.9,30.82 267.91,30.82 269.12,29.61 v3(281.21,29.61) 281.23,29.61 283.08,31.45 284.55,31.45
INT_SPKR_R+: length 18.9
  TOP w1.016: 284.55,33.04 281.18,33.04 v3(280.29,32.15) 279.29,31.14 270.06,31.14 269.25,31.96 267.09,31.96 266.9,32.15
INT_SPKR_R-: length 18.6
  TOP w1.016: 284.74,35.96 283.85,35.96 282.58,34.69 v3(281.18,34.69) 280.1,34.69 278.9,33.48 267.4,33.48 267.21,33.67
INTRUDER#: length 26.8
  TOP w0.102: RC69.1 136.63,36.12 v1(136.63,35.73)
  IN2 w0.122: v1(136.63,35.73) 138.01,35.73 138.47,36.19 138.47,38.95 136.53,40.89 136.53,42.12 136.72,42.31 136.72,43.87 136.31,44.27 133.04,44.27 131.37,45.94 131.37,45.98 127.91,49.44 127.64,49.44 127.46,49.63 127.46,50.75 127.95,51.24 v1(127.95,51.77)
  BOTTOM w0.076: v1(127.95,51.77) UC1.AP16
IR_CAM_DET#: length 100.1
  TOP w0.102: v1(134.36,65.35) 134.66,65.04 136.28,65.04 137.67,63.65 138.74,63.65 144.06,68.97 RC345.1
  IN2 w0.122: v1(120.62,91.9) 117.51,95.01 109.14,95.01 108,96.16 95.73,96.16 93.96,97.92 91.15,97.92 90.89,98.18 87.81,98.18 84.78,95.15 v1(84.78,94.25)
  IN4 w0.089: v1(134.36,65.35) 134.8,65.8 134.8,68.58 135.18,68.96 135.18,70.99 135.56,71.36 135.56,78 134.69,78.87 134.69,80.16 133.42,81.43 133.42,84.08 132.62,84.88 132.62,86.76 129.59,89.79 124.13,89.79 122.22,91.7 120.82,91.7 v1(120.62,91.9)
  BOTTOM w0.102: UC1.H5 134.5,65.35 v1(134.36,65.35) ; v1(84.78,94.25) 83.57,94.25 81.81,92.49 v2(80,92.49) JIR1.1
ISEN1_IA: length 36.4
  TOP w0.203: PU602.9 67.36,53.29 66.15,54.5 v1(65.54,54.5) 65.54,54.69 65.09,55.14 PR634.1 ; PC635.2 v1(65.09,58.82)
  TOP w0.254: PR668.2 v1(66.62,72.54) ; PR670.1 71.3,58.77 70.59,59.48 67.15,59.48 v2(66.68,59.01) 65.28,59.01 v1(65.09,58.82)
  IN2 w0.254: v1(65.54,54.5) 65.54,55.33 65.09,55.77 v1(65.09,58.82)
  IN3 w0.254: v1(65.09,58.82) 64.94,58.97 63.2,58.97 62.59,59.58 62.59,71.52 63.61,72.54 v1(66.62,72.54)
ISEN2_IA: length 26.6
  TOP w0.102: v1(64.2,58.5) v2(64.2,59.15)
  TOP w0.203: PU602.10 66.96,53.2 66.17,53.99 65.41,53.99 v1(64.9,54.5) 64.89,54.5 PR615.1 ; PC638.2 v1(64.2,58.5)
  TOP w0.254: v1(68.06,68.47) PR677.2 PR675.2
  IN2 w0.254: v1(64.9,54.5) 64.9,55.14 64.46,55.58 64.46,58.25 v1(64.2,58.5)
  IN3 w0.254: v1(68.06,68.47) 68.08,68.47 69.54,67.01 69.54,59.58 68.97,59.01 65.98,59.01 65.31,58.34 64.36,58.34 v1(64.2,58.5)
ISH_I2C2_SCL: length 213.5
  TOP w0.102: RC362.1 147.68,55.03 146.69,55.03 145.94,54.28 144.71,54.28 v1(144.6,54.17) ; v1(296.2,48.12) 296.55,48.47 RZ76.1
  IN1 w0.089: v1(156.58,42.11) 156.72,41.97 156.88,41.97 157.02,42.11 157.02,42.6 155.01,44.61 155.01,47.76 151.44,51.33 147.97,51.33 144.95,54.35 144.78,54.35 v1(144.6,54.17) 144.41,54.35 144.14,54.35 142.88,55.62 138.05,55.62 137.1,56.57 135.73,56.57 135.51,56.36 131.59,56.36 131.21,56.74 131.21,58.05 v1(131.18,58.08)
  IN2 w0.122: v1(156.58,42.11) 156.75,41.94 157.09,41.94 157.36,41.67 157.36,39.9 158.25,39.01 158.25,36.72 169.93,25.04 175.9,25.04 176.65,25.79 177.65,25.79 178.17,25.27 180.58,25.27 180.78,25.07 183.47,25.07 183.57,25.16 192.97,25.16 194.97,23.16 194.97,20.48 196.45,19 197.02,19 198.63,17.39 201.58,17.39 202.06,16.91 204.09,16.91 205.49,15.51 208.58,15.51 209.72,16.65 214.11,16.65 215.02,15.74 217.46,15.74 217.79,16.07 222.09,16.07 222.32,15.84 226.09,15.84 232.59,22.34 242.14,22.34 245.7,25.9 256.37,25.9 258.6,28.14 261.54,28.14 263.34,29.93 278.06,29.93 284.84,36.71 286.28,36.71 289,39.43 289,40.93 290.76,42.68 290.76,43.28 291.09,43.61 291.09,44.23 294.44,47.59 296.23,47.59 296.35,47.71 296.35,47.96 v1(296.2,48.12)
  BOTTOM w0.076: v1(131.18,58.08) 130.83,57.73 UC1.AD12
ISH_I2C2_SCL_R: length 3.4
  TOP w0.102: RZ76.2 296.61,49.81 296.61,51.15 v1(296.5,51.26)
  BOTTOM w0.102: JNGFF2.40 296.55,51.21 v1(296.5,51.26)
ISH_I2C2_SDA: length 214.7
  TOP w0.102: RZ77.1 296.78,48.18 v1(296.78,48.12) ; v1(144.6,54.75) 144.84,54.51 145.84,54.51 146.59,55.26 147.58,55.26 RC363.1
  IN1 w0.089: v1(131.82,58.08) 131.82,57.99 131.43,57.6 131.43,56.83 131.68,56.57 135.43,56.57 135.64,56.79 137.19,56.79 138.14,55.84 142.97,55.84 144.23,54.57 144.42,54.57 v1(144.6,54.75) 144.79,54.56 145.04,54.56 148.06,51.54 151.53,51.54 155.22,47.85 155.22,44.7 157.23,42.69 157.23,42.02 156.97,41.75 156.81,41.75 v1(156.58,41.52)
  IN2 w0.122: v1(156.58,41.52) 156.75,41.69 156.99,41.69 157.11,41.57 157.11,39.79 158,38.9 158,36.61 169.82,24.79 176,24.79 176.75,25.54 177.55,25.54 178.07,25.02 180.48,25.02 180.68,24.82 183.58,24.82 183.67,24.91 192.87,24.91 194.72,23.06 194.72,20.38 196.35,18.75 196.92,18.75 198.53,17.14 201.47,17.14 201.96,16.66 203.99,16.66 205.39,15.26 208.68,15.26 209.82,16.4 214,16.4 214.91,15.49 217.56,15.49 217.89,15.82 221.98,15.82 222.21,15.59 226.19,15.59 232.69,22.09 242.24,22.09 245.8,25.65 256.47,25.65 258.71,27.89 261.64,27.89 263.44,29.69 278.16,29.69 284.94,36.46 286.39,36.46 289.25,39.33 289.25,40.82 291.01,42.58 291.01,43.18 291.34,43.5 291.34,44.13 294.55,47.34 296.33,47.34 296.6,47.6 296.6,47.94 v1(296.78,48.12)
  BOTTOM w0.076: UC1.AD11 131.48,57.74 v1(131.82,58.08)
ISH_I2C2_SDA_R: length 4.4
  TOP w0.102: RZ77.2 297.09,50.1 297.09,51.25 v1(297.08,51.26) 297.63,51.26 v2(297.87,51.02)
  BOTTOM w0.102: JNGFF2.42 297.05,50.88 297.03,50.89 297.03,51.22 v1(297.08,51.26)
ISH_UART0_CTS#: length 94.3
  TOP w0.102: v1(196.92,20.82) 196.92,19.15 197.36,18.71 v2(197.36,17.7) 197.36,15.61 196.3,14.54 196.3,11.86 196.68,11.48 196.68,10.91 RZ80.1
  IN3 w0.122: v1(196.92,20.82) 196.75,20.82 196.2,21.38 196.2,23.98 191.03,29.15 187.57,29.15 183.05,33.67 181.97,33.67 179.27,36.38 179.27,37.61 169.98,46.9 169.98,48.31 163.81,54.47 160.97,54.47 154.74,60.7 151.94,60.7 150.89,61.76 149.91,61.76 149.01,62.65 142.31,62.65 v1(142.15,62.49)
  BOTTOM w0.076: v1(142.15,62.49) 141.88,62.22 140.51,62.22 138.89,60.61 137.5,60.61 137.33,60.65 137.31,60.66 136.97,60.66 136.97,60.65 136.96,60.65 136.7,60.65 136.67,60.66 136.65,60.66 136.64,60.67 136.34,60.67 136.24,60.64 136.15,60.64 136.06,60.65 UC1.U4
ISH_UART0_CTS#_R: length 12
  TOP w0.102: RZ80.2 v2(199.1,11.21) 199.12,11.21 199.24,11.33 200.61,11.33 200.7,11.42 205.48,11.42 v1(205.68,11.22)
  BOTTOM w0.102: JNGFF1.62 208.05,9.5 208.05,9.5 206.76,10.79 206.76,10.99 206.54,11.22 v1(205.68,11.22)
ISH_UART0_RTS#: length 96.1
  TOP w0.102: RZ81.1 196.81,9.77 196.81,10.21 196.38,10.64 196.38,11.31 v2(196.09,11.6) 196.09,14.62 197.11,15.64 197.11,17.46 197.03,17.54 197.03,17.87 196.47,18.43 196.47,21.42 v1(197.05,21.99)
  IN3 w0.122: v1(141.4,63.43) 141.7,63.74 143.61,63.74 143.95,63.4 150.19,63.4 152.16,61.44 155.05,61.44 160.53,55.95 164.17,55.95 171.07,49.04 171.07,47.74 171.94,46.88 172.24,46.88 176.28,42.84 176.28,41.74 187.98,30.04 191.13,30.04 196.98,24.19 196.98,22.05 v1(197.05,21.99)
  BOTTOM w0.076: UC1.U3 136.42,60.9 136.52,60.99 136.52,61 136.66,61.15 136.67,61.15 136.8,61.27 137.14,61.27 arc(137.18,61.28) 137.22,61.28 arc(137.31,61.32) 137.4,61.33 138.21,61.33 139.48,62.6
  BOTTOM w0.102: 139.48,62.6 140.32,63.43 v1(141.4,63.43)
ISH_UART0_RTS#_R: length 12.6
  TOP w0.102: RZ81.2 198.47,9.29 v2(199.12,9.94) 199.46,10.28 199.46,10.8 199.79,11.13 200.69,11.13 200.78,11.22 204.69,11.22 205.08,10.82 v1(206.33,10.82)
  BOTTOM w0.102: JNGFF1.64 208.15,9 v1(206.33,10.82)
ISH_UART0_RXD: length 91
  TOP w0.102: RZ78.1 196.7,12.92 196.7,14.19 v2(196.99,14.48) 198.09,15.58 198.09,20.93 197.52,21.5 v1(197.39,21.5)
  IN3 w0.122: v1(197.39,21.5) 196.93,21.5 196.65,21.78 196.65,24.16 191.03,29.79 187.79,29.79 170.43,47.15 170.43,48.52 163.23,55.72 160.43,55.72 154.97,61.18 152.09,61.18 150.1,63.18 143.86,63.18 143.71,63.33 142.02,63.33 v1(141.97,63.27)
  BOTTOM w0.076: UC1.U1 138.26,60.9
  BOTTOM w0.102: v1(141.97,63.27) 141.97,62.85 141.59,62.47 140.31,62.47 138.74,60.9 138.26,60.9
ISH_UART0_RXD_R: length 12
  TOP w0.102: v1(205.87,12.04) 205.69,11.87 204.48,11.87 200.7,11.87 199.9,12.67 199.27,12.67 v2(199.12,12.51) 198.94,12.34 RZ78.2
  BOTTOM w0.102: v1(205.87,12.04) 206.64,12.04 207.19,11.49 207.19,11.22 207.91,10.5 JNGFF1.58
ISH_UART0_TXD: length 91.7
  TOP w0.102: v1(197.54,20.92) 197.71,20.75 v2(197.71,19.36) 197.79,19.28 197.79,15.75 196.5,14.45 196.5,12.11 RZ79.1
  IN3 w0.122: v1(141.33,62.86) 141.36,62.88 143.58,62.88 143.58,62.88 150.08,62.88 152.03,60.93 154.89,60.93 161.03,54.8 163.82,54.8 170.2,48.41 170.2,47.02 187.85,29.37 191.13,29.37 196.42,24.08 196.42,21.64 196.8,21.25 197.06,21.25 197.39,20.92 v1(197.54,20.92)
  BOTTOM w0.076: 139.01,61.68 138.49,61.16 137.4,61.16 arc(137.34,61.15) 137.28,61.13 arc(137.21,61.11) 137.14,61.11 137.02,61.11 UC1.U2
  BOTTOM w0.102: v1(141.33,62.86) 140.18,62.86 139.01,61.68
ISH_UART0_TXD_R: length 11.7
  TOP w0.102: v1(206.33,11.62) 200.47,11.62 v2(200.22,11.87) 200,11.65 198.53,11.65 RZ79.2
  BOTTOM w0.102: JNGFF1.60 207.96,10 206.96,10.99 206.96,11.2 206.54,11.62 v1(206.33,11.62)
ISPSCL: length 4
  TOP w0.102: UV6.30 277.09,57.51 277.2,57.63 277.2,57.79 276.84,58.15 276.41,58.15 275.91,58.65 275.91,58.97 v1(275.7,59.18)
  BOTTOM w0.102: v1(275.7,59.18) 275.89,59.37 275.89,59.6 275.66,59.82 RV106.1
ISPSDA: length 4.1
  TOP w0.102: UV6.29 277.49,57.5 277.43,57.56 277.43,57.89 276.94,58.38 v4(276.73,58.38) 276.5,58.38 276.14,58.74 276.14,59.04 v1(276.29,59.18)
  BOTTOM w0.102: RV107.1 276.33,59.82 276.12,59.61 276.12,59.35 v1(276.29,59.18)
ISUMN_GT: length 44.2
  TOP w0.102: v2(59.11,46.78) 59.11,46.91 v1(59.42,47.22)
  TOP w0.203: PR644.2 61.03,47 PC645.1 59.64,47 v1(59.42,47.22) ; PR644.2 61.03,47 PR640.2 ; PR644.2 61.04,47.01 PR656.2 PC646.2 PC642.2
  IN2 w0.254: v1(59.42,47.22) 60.34,47.22 63.22,44.34 70.3,44.34 71.89,45.93 71.89,47.01 71.44,47.45 71.44,55.26 72.27,56.09 72.27,57.74 71.7,58.31 71.7,59.2 71.19,59.71 68.39,59.71 v1(68.14,59.96)
  BOTTOM w0.203: PH605.2 67.39,59.21 v1(68.14,59.96)
  BOTTOM w0.254: PL612.2 68.46,62.5 68.14,62.18 v1(68.14,59.96)
ISUMN_IA: length 36.2
  TOP w0.102: v2(63.25,58.06) 63.25,57.92 PC638.1
  TOP w0.254: PR638.1 66.87,56.96 PR632.1 v1(66.88,57.63) 65.73,57.63 65.09,56.99 PC635.1 PC638.1 ; PR666.2 69.17,73.82 69.61,74.26 v1(70.92,74.26)
  IN3 w0.254: v1(66.88,57.63) 67.4,57.1 69.79,57.1 70.68,57.99 v1(70.68,58.5) 71.13,58.5 72.59,59.96 72.59,72.85 71.18,74.26 v1(70.92,74.26)
  BOTTOM w0.254: PH602.2 v1(70.92,74.26) ; PR633.2 PC626.2 ; PC626.2 PC624.2 ; PC626.2 66.88,56.95 PC641.1 66.86,57.6 v1(66.88,57.63) ; PR673.2 71.3,58.2 71,58.5 v1(70.68,58.5)
ISUMN_VSA: length 55
  TOP w0.102: v1(75.13,43.77) 75.13,43.11 v2(74.86,42.84)
  TOP w0.254: PR636.2 72.71,43.88 PR641.2 ; PC633.2 PR643.1 PC637.2 73.57,43.08 PR641.2 ; v1(75.13,43.77) 75.02,43.87 PC644.1 73.57,43.87 PR641.2
  IN2 w0.203: v1(75.13,43.77) 75.24,43.88 75.24,44.84 73.58,46.5 73.58,53.2 73.11,53.66 73.11,54.84 73.98,55.71 73.98,76.52 80.27,82.81 80.27,83.01 v1(80.71,83.46)
  BOTTOM w0.254: PH604.2 80.95,83.46 v1(80.71,83.46) 80.14,83.46 79.84,83.76 79.84,86.13 80.02,86.31 PL614.2
ISUMP_GT: length 8.6
  TOP w0.203: PU602.19 65.28,48.78 64.84,48.35 v2(63.77,48.35) 63.2,48.35 PC642.1 PC646.1 PR656.1 60.51,48.76 PR657.1 60.1,49.02 PR661.2
  TOP w0.254: PR657.1 60.17,49.82 PR653.2
ISUMP_IA: length 34.3
  TOP w0.102: v2(69.8,59.02) 69.8,58.83 v1(69.47,58.5)
  TOP w0.254: PU602.7 68.16,53.78 v1(67.73,54.21) ; v1(69.92,73.61) 69.92,72.6 69.66,72.34 PR674.1 PR667.1
  IN2 w0.254: v1(69.47,58.5) 69.47,56.72 67.73,54.98 v1(67.73,54.21)
  IN3 w0.254: v1(69.92,73.61) 71.25,73.61 72.14,72.73 72.14,60.15 71,59.01 69.79,59.01 69.47,58.69 v1(69.47,58.5)
  BOTTOM w0.254: PR628.1 68.65,55.21 PR658.2 67.78,55.19 PR633.1 ; PR633.1 67.73,55.14 v1(67.73,54.21) ; PR633.1 PC626.1 PC624.1
ISUMP_VSA: length 59.8
  TOP w0.102: v2(71.81,41.15) PC633.1
  TOP w0.203: PC633.1 71.05,42.13 69.36,43.82 PU602.27
  TOP w0.254: 78.81,84.22 78.81,83.39 79.38,82.82 v1(80.71,82.82) 81.21,82.82 PR642.1 ; PC633.1 PR643.2 PC637.1 74.88,42.13 75.76,43.01 v1(75.76,43.77)
  IN2 w0.203: v1(80.71,82.82) 74.32,76.42 74.32,55.57 73.45,54.7 73.45,53.8 73.91,53.33 73.91,46.64 75.57,44.98 75.57,43.96 v1(75.76,43.77)
ITP_PMODE: length 201.8
  TOP w0.102: JXDP1.46 64.45,31.96 63.76,32.66 59.31,32.66 56.04,35.93 v1(56.04,37.36) ; v1(133.15,74.87) 131.7,76.32 131.7,77.87 129.77,79.8 129.77,82.8 130.82,83.84 RC115.1
  IN3 w0.122: v1(56.04,37.36) 55.28,38.12 45.66,38.12 39.25,44.53 39.25,50.63 40.89,52.27 42.41,52.27 43.69,53.54 43.69,71.96 47.5,75.77 48.3,75.77 53.83,81.3 54.84,81.3 56.47,82.92 58.65,82.92 64.78,89.05 67.45,89.05 68.59,90.19 71.19,90.19 72.1,89.27 86.52,89.27 88.4,87.39 93.04,87.39 94.65,89 98.1,89 98.87,89.77 100.63,89.77 101.4,89 108.54,89 109.94,87.61 112.89,87.61 113.88,86.62 115.94,86.62 116.92,87.61 118.47,87.61 119.08,87 128.98,87 129.8,86.17 134.75,86.17 135.83,85.1 135.83,77.05 134.24,75.46 133.74,75.46 v1(133.15,74.87)
  BOTTOM w0.076: UC1.E8 132.98,67.04 132.5,67.51 132.5,68.85 132.31,69.04 131.99,69.04 131.8,69.23 131.8,69.84 132.31,70.36 132.31,71.26
  BOTTOM w0.102: 132.31,71.26 133.15,72.1 v2(133.15,73.74) v1(133.15,74.87)
JCRT-11: length 2.8
  BOTTOM w0.102: T87.1 318.66,83.18 JCRT1.11
JDIMM1_EVENT#: length 3.5
  TOP w0.102: v1(72.78,3.19) v2(72.78,2.66)
  TOP w0.381: RD14.1 73.03,3.45 v1(72.78,3.19)
  BOTTOM w0.254: JDIMM1.134 72.53,3.44 v1(72.78,3.19)
JDIMM2_EVENT#: length 15
  TOP w0.102: v2(141.46,1.49) RD27.1 142.07,2.49 142.47,2.09 151.89,2.09 v1(153.36,3.56)
  BOTTOM w0.102: v1(153.36,3.56) 153.53,3.73 JDIMM2.134
JTAG_CLK: length 37
  TOP w0.102: v1(296.78,77.9) UE1.C8
  IN4 w0.089: v1(296.78,77.9) 296.57,77.9 295.81,78.66 289.44,78.66 288.76,77.98 285.04,77.98 284.3,77.24 v1(278.56,77.24)
  BOTTOM w0.102: RPE7.3 274.04,81.24 273.7,80.9 273.7,80.56 274.01,80.26 274.82,80.26 274.86,80.29 276.33,80.29 276.53,80.5 278.96,80.5 279.21,80.26 281.09,80.26 v3(281.49,79.86) 281.45,79.82 281.11,79.82 280.4,79.11 280.4,77.94 279.41,76.95 278.85,76.95 v1(278.56,77.24) 278.31,77 278.31,76.62 278.08,76.4 JDEG1.4
JTAG_RST#: length 8.7
  TOP w0.102: UE1.G13 300.36,83.48 300.63,83.75 CE302.1 CE301.1 300.63,85.81 RE65.1 299.73,86.71 JTAG1.1 299.74,87.13 RE63.1 301,86.22 v2(301.27,85.95)
JTAG_TDI: length 33.5
  TOP w0.112: UE1.E9 298.36,78.73 v1(298.33,78.73)
  IN1 w0.089: v1(275.13,81.94) 275.85,81.22 276.63,81.22 278.92,78.92 278.92,78.43 277.93,77.44 v1(277.93,77.39)
  IN4 w0.089: v1(277.93,77.39) 277.93,77.47 278.79,78.33 279.89,78.33 279.97,78.24 284.15,78.24 284.36,78.45 287.48,78.45 288.17,79.14 295.76,79.14 296.58,78.33 297.92,78.33 v1(298.33,78.73)
  BOTTOM w0.102: v1(277.93,77.39) 277.93,77.4 JDEG1.2 ; v1(275.13,81.94) 275.06,82.01 274.82,82.01 274.59,82.24 RPE7.1 v3(274.27,83.51)
JTAG_TDO: length 42.3
  TOP w0.102: v1(299.16,75.53) UE1.F6
  IN4 w0.089: v1(299.16,75.53) 298.75,75.12 296.59,75.12 296.36,75.34 296.36,75.72 295.51,76.57 292.71,76.57 292.18,76.04 290.25,76.04 289.54,76.75 288.17,76.75 287.63,76.22 285.44,76.22 285.06,75.84 282.96,75.84 282.33,76.47 v1(279,76.47)
  BOTTOM w0.102: RPE7.4 274.62,80.74 274.68,80.8 276.15,80.8 276.33,80.98 279.16,80.98 279.4,80.74 282.96,80.74 v3(283.38,80.32) 283.38,80.19 282.53,79.34 281.41,79.34 281.21,79.14 281.21,78.07 279.61,76.47 v1(279,76.47) 278.85,76.47 278.29,75.91 276,75.91 JDEG1.5
JTAG_TMS: length 33.5
  TOP w0.102: UE1.C5 297.16,75.1 v1(296.76,74.7)
  IN1 w0.089: v1(275.06,81.31) 275.59,80.78 276.8,80.78 278.73,78.84 278.73,78.53 278.17,77.97 277.99,77.97 277.52,77.51 277.52,76.99 v1(277.7,76.81)
  IN4 w0.089: v1(277.7,76.81) 278.21,76.3 278.21,75.18 278.55,74.84 279.63,74.84 280.12,75.33 283.22,75.33 284.23,74.31 287.09,74.31 288.17,75.4 294.33,75.4 294.99,74.73 296.74,74.73 v1(296.76,74.7)
  BOTTOM w0.102: RPE7.2 274.63,81.74 v1(275.06,81.31) 275.15,81.22 v3(275.9,81.22) ; v1(277.7,76.81) 277.62,76.9 JDEG1.3
KB_DET#: length 142.6
  TOP w0.102: CZ84.1 213.95,11.96 213.72,12.18 213.72,13 213.57,13.15 JKBTP1.20 212.68,13.15 212.37,12.85 v1(212.37,11.3) ; v1(142.65,75.94) 144.58,75.94 145.06,75.46 v3(145.42,75.46) 145.42,76.68 148.55,79.08 153.17,79.08 153.93,78.31 153.93,77.23 v1(155.71,75.46)
  IN2 w0.122: v1(134.56,74.88) 141.6,74.88 v1(142.65,75.94)
  IN4 w0.089: v1(134.56,74.88) 134.56,69.61 133.38,68.43 v1(133.38,67.58) ; v1(155.71,75.46) 158.18,72.98 158.18,68.22 161.04,65.36 161.04,57.74 163.19,55.59 163.19,54.91 163.17,54.91 161.58,53.31 161.58,51.74 164.4,48.92 164.4,47.84 165.43,46.8 166.15,46.8 179.56,33.39 179.56,29.39 183.84,25.11 183.84,21.2 187.2,17.84 187.2,16.57 191.12,12.64 196.67,12.64 197.49,11.83 204.28,11.83 205.81,13.35 206.38,13.35 206.82,12.91 209.11,12.91 210.72,11.3 v1(212.37,11.3)
  BOTTOM w0.076: UC1.D8 v1(133.38,67.58)
  BOTTOM w0.102: RC288.1 156.15,75.9 v1(155.71,75.46)
LAN_ACTLED_YEL#: length 5.5
  TOP w0.102: QL1.6 v1(281.91,97.67) ; RL14.1 v1(279.21,99.9)
  BOTTOM w0.102: v1(279.21,99.9) 281.45,97.67 v1(281.91,97.67) 281.91,97.51 v2(282.25,97.17)
LAN_ACTLED_YEL_R#: length 14.6
  TOP w0.102: RL14.2 279.21,102.51 279.71,103 284.22,103 v3(285.65,104.43) 285.8,104.58 JLOM1.10
LAN_DISABLE#_R: length 6.6
  TOP w0.102: RL5.1 RL9.1 RL7.2 282.21,81.09 v1(282.15,81.15) ; v1(282.3,84.04) 282.13,84.22 UL1.3
  BOTTOM w0.102: v1(282.15,81.15) 282.15,82.41 v2(282.15,82.42) 282.15,82.42 282.15,83.89 v1(282.3,84.04)
LAN_MDIN0: length 5.3
  TOP w0.089: UL1.14 280.06,89.3 280.11,89.35 280.11,89.63 280.42,89.93 v4(280.79,89.93) 281.69,89.93 282.83,91.08 282.83,91.27 RL72.1
LAN_MDIN0_L: length 13.3
  TOP w0.089: RL72.2 282.33,94.46 282.93,95.06 285.1,95.06 285.42,95.38 v4(288.42,95.38) 291.08,95.38 291.37,95.09 291.37,94.78 v1(291.49,94.67)
  BOTTOM w0.089: v1(291.49,94.67) 291.43,94.61 291.43,94.13 291.71,93.86 TL1.11
LAN_MDIN1: length 4.8
  TOP w0.089: RL74.1 280.26,91.3 280.26,91.04 280.17,90.95 279.02,90.95 278.51,90.44 278.51,89.35 278.46,89.3 UL1.18
LAN_MDIN1_L: length 24.4
  TOP w0.089: RL74.2 280.21,93.6 280.21,93.95 v1(280.12,94.04)
  BOTTOM w0.089: TL1.5 297.71,95.21 297.18,95.73 289.14,95.73 288.56,95.15 288.56,94.01 288.04,93.49 284.04,93.49 v4(283.02,94.51) 282.44,95.09 280.48,95.09 280.12,94.73 v1(280.12,94.04)
LAN_MDIN2: length 3.6
  TOP w0.089: UL1.21 277.26,89.3 277.31,89.35 v4(277.31,89.97) 277.31,90.7 277.75,91.14 277.75,91.27 RL76.1
LAN_MDIN2_L: length 22.6
  TOP w0.089: v1(294.48,94.72) 294.48,95.79 293.98,96.28 285.06,96.28 284.75,95.98 278.88,95.98 277.57,94.67 277.57,93.49 RL76.2
  BOTTOM w0.089: v1(294.48,94.72) 294.44,94.68 294.44,94.24 294.71,93.97 TL1.8
LAN_MDIN3: length 3.8
  TOP w0.089: RL78.1 275.17,91.31 275.17,90.73 v4(275.96,89.94) 276.11,89.78 276.11,89.35 276.06,89.3 UL1.24
LAN_MDIN3_L: length 32.1
  TOP w0.089: v1(300.52,94.67) 300.52,95.74 299.07,97.18 v4(296.89,97.18) 284.64,97.18 284.35,96.89 276.82,96.89 275.04,95.11 275.04,93.5 RL78.2
  BOTTOM w0.089: TL1.2 300.71,93.99 300.44,94.25 300.44,94.59 v1(300.52,94.67)
LAN_MDIP0: length 5.3
  TOP w0.089: UL1.13 280.46,89.3 280.41,89.35 280.41,89.5 280.55,89.63 281.82,89.63 v4(282.32,90.14) 283.13,90.95 283.13,91.31 RL71.1
LAN_MDIP0_L: length 13.3
  TOP w0.089: v1(290.9,94.67) 291.07,94.84 291.07,94.96 290.95,95.08 v4(286.16,95.08) 285.55,95.08 285.23,94.76 283.05,94.76 282.63,94.33 282.63,93.89 282.95,93.57 282.95,93.4 283.17,93.17 RL71.2
  BOTTOM w0.089: v1(290.9,94.67) 290.94,94.67 291.13,94.47 291.13,94.25 291.04,94.16 290.78,94.16 290.71,94.09 TL1.12
LAN_MDIP1: length 4.8
  TOP w0.089: RL73.1 280.56,91.28 280.56,90.91 280.3,90.65 279.15,90.65 278.81,90.31 v4(278.81,89.78) 278.81,89.35 278.86,89.3 UL1.17
LAN_MDIP1_L: length 24.4
  TOP w0.089: v1(280.71,94.04) 280.51,93.85 280.51,93.36 280.7,93.17 RL73.2
  BOTTOM w0.089: TL1.6 296.71,94.3 296.79,94.39 297.3,94.39 297.41,94.49 297.41,95.09 297.06,95.43 289.27,95.43 288.86,95.03 288.86,93.89 288.17,93.19 283.92,93.19 282.32,94.79 280.6,94.79 280.42,94.61 280.42,94.33 v1(280.71,94.04)
LAN_MDIP2: length 3.6
  TOP w0.089: UL1.20 277.66,89.3 277.61,89.35 277.61,90.58 278.05,91.02 278.05,91.31 RL75.1
LAN_MDIP2_L: length 22.5
  TOP w0.089: v1(293.89,94.72) 293.89,94.93 293.94,94.98 294.09,94.98 294.18,95.07 294.18,95.67 293.86,95.98 285.18,95.98 284.88,95.68 v4(281.51,95.68) 279,95.68 277.87,94.55 277.87,93.28 277.97,93.17 RL75.2
  BOTTOM w0.089: v1(293.89,94.72) 294.14,94.48 294.14,94.36 294.05,94.28 293.78,94.28 293.71,94.21 TL1.9
LAN_MDIP3: length 3.8
  TOP w0.089: RL77.1 275.47,91.27 275.47,90.85 275.79,90.53 275.98,90.34 276.41,89.91 276.41,89.35 276.46,89.3 UL1.23
LAN_MDIP3_L: length 32.1
  TOP w0.089: v1(299.93,94.67) 299.93,94.94 299.98,94.99 300.13,94.99 300.22,95.08 300.22,95.61 298.95,96.88 284.76,96.88 284.47,96.59 276.94,96.59 275.34,94.98 275.34,93.28 275.45,93.17 RL77.2
  BOTTOM w0.089: TL1.3 299.71,94.17 299.79,94.26 300.05,94.26 300.14,94.34 300.14,94.53 300,94.67 v1(299.93,94.67)
LAN_TEST_EN: length 3.4
  TOP w0.102: v2(273.13,86.1) RL12.1
  TOP w0.112: UL1.30 274.73,85.82 274.59,85.68 273.71,85.68 RL12.1
LAN_WAKE#: length 265
  TOP w0.102: RL70.1 RC323.1 144.41,34.45 v1(144.81,34.45)
  TOP w0.107: v1(303.96,73.13) UE1.L3
  TOP w0.112: UL1.2 281.95,83.82 v1(282.57,83.19)
  IN2 w0.122: v1(144.81,34.45) 145.21,34.85 145.21,36.04 145.04,36.21 145.04,39.01 141.2,42.85 140.01,42.85 135.86,47 133.17,47 131.04,49.14 131.04,51.44 130.23,52.25 130.23,52.64 v1(129.81,53.07)
  IN3 w0.122: v1(179.37,50.98) 179.33,50.94 179.33,49.69 182.76,46.27 186.59,46.27 200.81,32.05 203.38,32.05 204.45,30.98 214.99,30.98 215.09,31.08 217.48,31.08 218.14,31.74 225.86,31.74 226.6,31.01 228.39,31.01 229.25,31.87 236.41,31.87 241.03,36.49 255.81,36.49 258.07,38.75 266.25,38.75 268.29,40.8 270.36,40.8 274.67,45.11 275.25,45.11 277.52,47.38 277.52,49.09 278.59,50.15 278.59,51.73 279.51,52.65 279.51,53.12 279.83,53.44 280.77,53.44 281.01,53.2 281.66,53.2 282.63,54.16 282.83,54.16 284.82,56.16 284.82,57.39 283.47,58.74 283.47,65.28 281.72,67.03 281.72,70.1 282.25,70.63 282.25,73.06 v1(283.05,73.86) 283.05,76.94 283.75,77.64 283.75,79.37 284.33,79.96 284.33,81.43 v1(282.57,83.19)
  IN4 w0.089: v1(303.96,73.13) 303.54,73.54 303.54,74.1 303.31,74.33 300.99,74.33 300.64,73.98 300.64,72.92 298.76,71.04 295,71.04 293.86,69.89 292.49,69.89 291.22,68.62 285.88,68.62 284.76,69.74 284.76,70.78 283.82,71.72 283.82,73.08 v1(283.05,73.86)
  BOTTOM w0.102: v1(129.81,53.07) 129.7,53.07 UC1.AM15 ; v1(179.37,50.98) 178.84,50.45 v2(178.84,49.47) 178.84,48.32 169.68,39.16 169.68,35.96 166.76,33.04 146.02,33.04 144.81,34.24 v1(144.81,34.45)
LCD_CBL_DET#: length 108.3
  IN2 w0.122: v1(96.3,92.65) 97.13,93.49 105.52,93.49 105.83,93.81 106.75,93.81 107.29,93.26 108.59,93.26 109.25,92.6 117.35,92.6 119.42,90.53 123.37,90.53 124.12,89.78 125.36,89.78 125.6,90.03 132.86,90.03 133.9,91.07 145.68,91.07 146.28,90.47 151.74,90.47 153.61,88.6 153.61,81.26 v1(154.03,80.84)
  IN4 w0.089: v1(154.03,80.84) 153.4,80.21 153.4,78.05 150.37,75.03 150.37,68.79 149.8,68.22 149.8,64.98 149.22,64.4 149.22,60.21 148.88,59.87 148.88,59.49 148.74,59.35 148.41,59.35 148.1,59.03 v1(148.1,58.98)
  BOTTOM w0.076: UC1.AC3 136.4,57.9 136.59,57.9 137.18,57.85 137.2,57.85 137.63,57.69 138.91,57.69 139.42,58.2 140.84,58.2 140.87,58.23
  BOTTOM w0.102: JEDP1.40 96.8,92.55 96.7,92.65 v1(96.3,92.65) ; 140.87,58.23 141.1,58.46 142.5,58.46 142.78,58.18 143.95,58.18 144.84,57.3 RC287.1 145.61,57.3 146.04,57.73 146.87,57.73 148.1,58.96 v1(148.1,58.98)
LCD_TST: length 282.4
  TOP w0.102: RE20.1 307.27,70.31 306.65,70.31 306.33,70.63 305.36,70.63 304.74,71.25 v1(304.74,71.44) 304.74,72.34 UE1.M2
  IN3 w0.122: v1(103.38,91.03) 107.35,91.03 108.26,90.11 119.93,90.11 121.85,88.19 126.53,88.19 128.05,89.71 133.46,89.71 134.44,90.69 138,90.69 139.42,89.28 142.43,89.28 143.36,90.21 150.51,90.21 157.16,83.56 157.16,75.37 159.01,73.53 159.01,69 161.55,66.46 161.55,61.76 181.78,41.52 182.58,41.52 184.33,39.77 185.45,39.77 185.93,39.29 185.93,38.03 186.64,37.32 188.1,37.32 188.7,36.73 191.69,36.73 199.75,28.67 202.16,28.67 206.19,24.64 207.97,24.64 209.07,23.54 210.16,23.54 210.72,22.98 212.67,22.98 213.23,22.42 218.21,22.42 218.77,22.98 221.1,22.98 222.61,21.47 224.23,21.47 225.21,20.49 229.97,20.49 232.14,22.66 239.64,22.66 244.52,27.53 248.22,27.53 249.72,29.03 252.87,29.03 253.3,29.46 258.77,29.46 260.14,30.83 278.11,30.83 281.49,34.21 281.84,34.21 284.15,36.51 284.15,37.68 288.59,42.12 288.59,43.53 290.59,45.53 291.47,45.53 292.59,46.65 292.59,47.5 292.24,47.84 292.24,48.23 295.27,51.25 295.27,51.73 295.59,52.05 295.59,52.94 295.81,53.17 296.5,53.17 298.51,55.18 298.51,59.81 300.09,61.39 300.09,62.46 301.09,63.46 301.09,67.78 304.74,71.43 v1(304.74,71.44)
  BOTTOM w0.102: JEDP1.29 102.3,91.63 102.9,91.03 v1(103.38,91.03)
