# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DIMM1_SA2: length 9.9
  TOP w0.102: v1(82.45,3.54) 82.45,3.14 83.66,1.92 87.24,1.92 v2(87.33,2.01) RD8.2 RD9.1
  BOTTOM w0.102: JDIMM1.166 82.45,4.72 v1(82.45,3.54)
DIMM2_SA0: length 4.2
  TOP w0.102: RD21.1 RD20.2 185.35,3.21 v1(185.31,3.24) 185.31,3.24 v2(184.94,2.87)
  BOTTOM w0.102: JDIMM2.256 186.03,3.96 v1(185.31,3.24)
DIMM2_SA1: length 4.5
  TOP w0.102: v1(188.09,3.92) 188.09,3.92 RD23.1 RD22.2 v2(190.05,3.2)
  BOTTOM w0.102: v1(188.09,3.92) 187.18,3.92 187.03,4.07 JDIMM2.260
DIMM2_SA2: length 12.1
  TOP w0.102: v1(163.85,6.87) 164.41,7.43 164.41,7.98 164.78,8.35 165.26,8.35 165.46,8.15 165.46,7.37 166.47,6.36 166.47,6.21 166.85,5.83 166.96,5.83 v2(167.07,5.72) 167.72,5.07 167.72,4.14 168.41,3.45 RD25.1 RD24.2
  BOTTOM w0.102: JDIMM2.166 163.53,6.55 v1(163.85,6.87)
DISP_ON: length 8.3
  BOTTOM w0.102: DV2.1 103.97,85.87 104.72,86.62 v2(104.72,86.76) 104.72,87.64 RV2.1 104.63,88.49 104.63,90.37 105.8,91.54 JEDP1.22
DMIC0: length 247.4
  TOP w0.102: UA1.2 296.09,37.12 295.61,37.61 294.98,37.61 294.85,37.74 v1(294.58,37.74) 293.82,38.5 293.65,38.5 RA52.2 ; v1(142.52,94.4) 142.52,94.69 141.91,95.3 v2(131.79,95.3) 129.96,95.3 125.56,90.9 122.26,90.9 122.03,90.67 115.61,90.67 v1(114.5,89.55)
  IN4 w0.089: v1(142.52,94.4) 142.52,93.71 145.72,90.51 146.43,90.51 148.37,88.58 150,88.58 150.7,87.88 150.7,87.14 152.56,85.29 152.81,85.29 159.1,79 159.1,69.06 162,66.15 162,60.85 164.2,58.65 164.2,54.13 169.83,48.51 169.83,47.39 171.51,45.71 171.51,44.7 173.28,42.92 174.77,42.92 180.32,37.36 182.31,37.36 187.69,31.98 188.33,31.98 199.2,21.11 208.3,21.11 209.12,20.29 214.76,20.29 215.22,20.74 218.09,20.74 218.75,20.08 220.22,20.08 221.11,20.97 226.7,20.97 227.67,20.01 249.33,20.01 250.09,19.25 262.73,19.25 263.97,20.49 263.97,22.12 265.61,23.76 265.61,24.85 266.89,26.13 268.24,26.13 270.39,28.28 280.56,28.28 282.48,30.2 284.34,30.2 288.88,34.74 290.2,34.74 293.2,37.74 v1(294.58,37.74)
  BOTTOM w0.102: v1(114.5,89.55) 114.5,88.99 CA6.1 114.94,89.06 114.94,89.74 114.45,90.24 114,90.24 113.3,90.94 JEDP1.7
DMIC_CLK0: length 244.1
  TOP w0.102: v1(291.75,38.64) 291.73,38.62 291.73,38.01 CA54.1 RA14.1 ; v1(143.26,94.4) 143.26,94.65 142,95.9 129.53,95.9 v2(128.25,94.63) 125.01,91.38 121.91,91.38 121.81,91.28 115.33,91.28 113.87,89.82 v1(113.87,89.55)
  IN4 w0.089: v1(291.75,38.64) 291.76,38.64 291.85,38.55 291.85,37.18 289.88,35.21 288.69,35.21 284.23,30.75 282.34,30.75 280.37,28.78 268.62,28.78 265.14,25.3 265.14,23.95 263.5,22.32 263.5,20.68 262.55,19.73 250.37,19.73 249.61,20.49 227.88,20.49 226.89,21.48 221.14,21.48 220.55,22.07 218.83,22.07 218.06,21.3 215.05,21.3 214.51,20.76 209.34,20.76 208.48,21.62 199.36,21.62 188.49,32.49 187.94,32.49 182.56,37.87 180.48,37.87 174.96,43.39 173.6,43.39 171.99,45 171.99,46.09 170.31,47.77 170.31,48.85 164.72,54.44 164.72,59.1 162.53,61.29 162.53,66.4 159.6,69.33 159.6,79.18 153.48,85.3 153.48,86.37 151.31,88.54 150.73,88.54 150.22,89.05 148.57,89.05 146.55,91.06 145.84,91.06 143.26,93.64 v1(143.26,94.4)
  BOTTOM w0.102: JEDP1.9 112.3,91.55 112.78,91.06 112.78,90.76 113.45,90.09 113.45,89.02 CA5.1 113.87,89 v1(113.87,89.55)
DMIC_CLK_CODEC: length 3.7
  TOP w0.102: UA1.3 296.17,36.72 295.51,37.38 295,37.38 v2(294.85,37.23) 294.39,37.23 293.63,37.99 RA14.2
EC_FPM_EN: length 135.5
  TOP w0.102: v1(297.56,75.53) UE1.D6 ; v3(222.71,26.69) v1(222.71,25.57) 222.71,24.86 222.32,24.47 222.32,23.96 222.57,23.7 222.57,21.49 226.6,17.47 226.6,11.33 224.42,9.15 JUSH1.5
  IN3 w0.122: v1(297.56,75.53) 297.17,75.13 296.35,75.13 295.51,74.29 295.51,73.47 295.33,73.3 295.33,70.66 294.72,70.05 294.72,66.36 294.9,66.19 294.9,63.31 293.7,62.11 293.7,60.06 294.13,59.63 294.13,59.02 293.91,58.8 293.91,56.7 292.96,55.75 292.96,54.12 292.06,53.21 292.06,53 291.57,52.51 290.45,52.51 289.83,51.9 288.8,51.9 287.63,50.73 287.63,47.51 286.41,46.29 283.4,46.29 282.27,45.16 282.27,44.38 281.08,43.19 281.08,41.29 280.47,40.68 280.47,38.47 279.95,37.94 279.95,37.38 279.32,36.76 279.32,35.88 277.98,34.54 271.05,34.54 270.21,33.7 258.99,33.7 257.44,32.15 249.22,32.15 247.41,30.35 243.26,30.35 238.06,25.14 236.77,25.14 236.13,25.78 227.97,25.78 227.2,25.01 223.27,25.01 v1(222.71,25.57)
EDP_AUXN: length 51
  IN4 w0.089: v1(98.28,87.18) 98.05,86.95 98.05,86.59 97.85,86.39 97.09,86.39 96.9,86.59 96.9,87.4 96.59,87.71 91.79,87.71 90.78,86.71 90.78,81.43 92.69,79.52 98.43,79.52 99.29,78.66 99.29,77.6 100.69,76.2 100.69,74.35 100.2,73.85 100.2,71.1 101.92,69.38 101.92,66.69 103.06,65.56 110.71,65.56 110.94,65.79 110.94,66.28 110.92,66.31 110.92,66.68 111.11,66.87 111.29,66.87 111.45,67.03 v1(111.45,67.32)
  BOTTOM w0.094: CV1.1 98,87.59 98,87.27 98.1,87.18 v1(98.28,87.18) ; UC1.E45 111.88,66.99 111.71,67.05 v1(111.45,67.32)
EDP_AUXN_C: length 4.9
  BOTTOM w0.094: JEDP1.33 100.3,91.5 100.17,91.37 100.17,90.75 98.79,89.37 97.99,89.37 97.95,89.33 97.95,89.16 CV1.2
EDP_AUXP: length 51
  IN4 w0.089: v1(111.47,66.54) 111.47,66.6 111.38,66.69 111.18,66.69 111.1,66.6 111.1,66.38 111.12,66.36 111.12,65.71 110.79,65.38 102.98,65.38 101.74,66.62 101.74,69.31 100.02,71.03 100.02,73.93 100.51,74.42 100.51,76.12 99.11,77.52 99.11,78.58 98.35,79.34 92.61,79.34 90.6,81.35 90.6,86.78 91.71,87.89 96.66,87.89 97.08,87.47 97.08,86.66 97.17,86.57 97.78,86.57 97.87,86.66 97.87,86.88 v1(97.57,87.18)
  BOTTOM w0.094: CV2.1 97.49,87.89 97.78,87.6 97.78,87.38 97.58,87.18 v1(97.57,87.18) ; UC1.F45 111.68,66.6 111.53,66.6 v1(111.47,66.54)
EDP_AUXP_C: length 4.9
  BOTTOM w0.094: CV2.2 97.77,89.16 97.77,89.41 97.91,89.55 98.71,89.55 99.98,90.83 99.98,91.36 99.8,91.54 JEDP1.34
EDP_BIA_PWM: length 58.4
  IN2 w0.122: v1(134.69,81.36) 134.64,81.31 131.82,81.31 131.67,81.46 129.64,81.46 129.49,81.31 128.58,81.31 127.7,80.43 120.1,80.43 119.97,80.3 114.47,80.3 108.88,85.9 105.95,85.9 v1(105.16,85.11)
  IN4 w0.089: v1(131.18,61.28) 131.83,61.93 134.53,61.93 135.26,62.65 135.26,67.76 135.59,68.09 135.59,70.81 135.94,71.15 135.94,78.16 135.07,79.03 135.07,80.98 v1(134.69,81.36)
  BOTTOM w0.076: v1(131.18,61.28) 131.48,61.58 UC1.R11
  BOTTOM w0.102: v1(105.16,85.11) 105.02,84.97 DV1.3
EDP_COMP: length 3.1
  TOP w0.127: v2(107.5,69) 107.8,68.7 107.8,68.04 107.71,67.95 RC2.1
  TOP w0.457: v1(107.87,66.65) 107.87,67.16 RC2.1
  BOTTOM w0.254: v1(107.87,66.65) 108.21,66.99 UC1.E52
EDP_HPD: length 62.8
  TOP w0.102: RC1.1 132.42,63.25 v1(132.45,63.28) v2(132.45,63.82)
  IN2 w0.122: v1(122.68,89.78) 122.15,90.31 119.06,90.31 117.85,91.52 104.9,91.52 v1(104.02,90.64)
  IN4 w0.089: v1(122.68,89.78) 122.9,89.57 129.51,89.57 132.07,87 132.07,82.61 133.1,81.58 133.1,78.28 133.29,78.09 133.29,77.31 133.73,76.87 133.78,76.87 134.98,75.67 134.98,69.26 133.87,68.15 133.87,64.53 133.09,63.76 132.93,63.76 132.46,63.28 v1(132.45,63.28)
  BOTTOM w0.076: v1(132.45,63.28) UC1.L10
  BOTTOM w0.102: RV7.1 104.37,88.5 104.37,90.28 v1(104.02,90.64) 103.99,90.66 103.99,91.36 103.8,91.55 JEDP1.26
EDP_TXN0: length 50.9
  IN4 w0.089: v1(95.66,85.85) 95.72,85.79 95.72,84.65 95.5,84.43 91.57,84.43 91.28,84.15 91.28,83.59 91.6,83.28 94.76,83.28 94.85,83.19 94.85,82.58 94.76,82.49 93.3,82.49 92.84,82.03 92.84,80.26 93.15,79.95 93.92,79.95 94.2,80.23 94.2,80.97 94.38,81.14 94.62,81.14 94.8,80.97 94.8,80.23 95.08,79.95 100.91,79.95 101,79.86 101,79.32 100.33,78.65 100.33,78.23 101,77.56 101,76.9 101.09,76.8 101.09,74.01 100.61,73.53 100.61,71.83 101.36,71.08 102.36,71.08 103.78,69.66 108.37,69.66 109.48,70.77 109.48,70.98 109.62,71.12 109.75,71.12 v1(109.93,70.94)
  BOTTOM w0.076: UC1.C47 110.79,68.91 110.79,69.42 110.94,69.56 110.94,70.95 110.76,71.13 110.12,71.13 v1(109.93,70.94)
  BOTTOM w0.094: CV4.1 95.99,87.54 95.99,87.44 95.82,87.26 95.82,86.01 v1(95.66,85.85)
EDP_TXN0_C: length 5.7
  BOTTOM w0.094: JEDP1.36 98.8,91.59 98.96,91.43 98.96,90.91 98.6,90.55 97.88,90.55 97.39,90.06 96.48,90.06 95.99,89.57 95.99,89.16 CV4.2
EDP_TXN1: length 46.9
  IN4 w0.089: v1(109.88,73.55) 109.66,73.32 109.55,73.32 109.12,72.9 109.12,71.44 108.27,70.59 107.93,70.59 107.18,71.34 106.15,71.34 104.48,73.02 103.92,73.02 103.44,73.5 103.44,74.32 102.24,75.52 102.24,81.25 101.61,81.88 96.09,81.88 95.76,82.21 95.76,82.75 95.97,82.96 99.4,82.96 99.6,83.16 99.6,84.12 99.28,84.44 98.54,84.44 98.37,84.61 98.37,84.79 97.67,85.49 97.42,85.49 96.48,86.43 95.82,86.43 95.19,87.05 94.83,87.05 94.63,86.86 94.63,86.46 v1(94.46,86.29)
  BOTTOM w0.076: UC1.D46 111.6,68.09 111.79,68.16 111.9,68.26 111.93,68.34 111.93,68.47 112.07,68.96 112.07,69.2 112.04,69.29 112.04,69.48 112.07,69.58 112.07,70.02 111.92,70.17 111.92,72.34 110.85,73.41 110.02,73.41 v1(109.88,73.55)
  BOTTOM w0.094: v1(94.46,86.29) 94.62,86.45 94.62,86.81 94.21,87.22 94.21,87.53 CV6.1
EDP_TXN1_C: length 6.3
  BOTTOM w0.094: JEDP1.38 97.8,91.58 97.94,91.44 97.94,91.31 97.77,91.14 96.6,91.14 95.55,90.09 94.69,90.09 94.21,89.6 94.21,89.16 CV6.2
EDP_TXP0: length 51
  IN4 w0.089: v1(109.93,71.59) 109.93,71.4 109.83,71.3 109.54,71.3 109.3,71.06 109.3,70.84 108.3,69.84 103.86,69.84 102.44,71.26 101.44,71.26 100.8,71.9 100.8,73.45 101.27,73.93 101.27,76.88 101.18,76.98 101.18,77.64 100.51,78.3 100.51,78.58 101.18,79.24 101.18,79.94 100.98,80.13 95.15,80.13 94.98,80.31 94.98,81.04 94.7,81.32 94.3,81.32 94.02,81.04 94.02,80.31 93.85,80.13 93.22,80.13 93.02,80.33 93.02,81.96 93.38,82.31 94.84,82.31 95.03,82.51 95.03,83.26 94.84,83.46 91.67,83.46 91.46,83.67 91.46,84.07 91.64,84.25 95.57,84.25 95.9,84.57 95.9,85.5 v1(96.24,85.85)
  BOTTOM w0.076: v1(109.93,71.59) 109.93,71.56 110.19,71.3 110.83,71.3 111.1,71.02 111.1,69.49 110.96,69.35 110.96,68.81 111.03,68.74 UC1.C46
  BOTTOM w0.094: v1(96.24,85.85) 96,86.09 96,87.19 96.17,87.36 96.17,87.54 CV3.1
EDP_TXP0_C: length 5.7
  BOTTOM w0.094: CV3.2 96.17,89.16 96.17,89.49 96.55,89.87 97.46,89.87 97.96,90.37 98.68,90.37 99.14,90.83 99.14,91.42 99.3,91.57 JEDP1.35
EDP_TXP1: length 46.9
  IN4 w0.089: v1(109.88,72.8) 109.98,72.9 109.98,73.04 109.87,73.14 109.62,73.14 109.3,72.82 109.3,71.37 108.35,70.41 107.86,70.41 107.11,71.16 106.08,71.16 104.4,72.84 103.85,72.84 103.26,73.43 103.26,74.24 102.06,75.44 102.06,81.17 101.53,81.7 96.02,81.7 95.58,82.14 95.58,82.83 95.89,83.14 99.32,83.14 99.42,83.24 99.42,84.04 99.2,84.26 98.47,84.26 98.19,84.54 98.19,84.72 97.59,85.31 97.35,85.31 96.4,86.25 95.74,86.25 95.12,86.87 94.9,86.87 94.81,86.79 94.81,86.54 95.01,86.34 v1(95.06,86.34)
  BOTTOM w0.076: UC1.C45 111.5,68.28 111.34,68.28 111.25,68.37 111.25,68.48 111.5,68.73 111.76,68.73 111.85,68.8 111.91,68.98 111.91,69.17 111.87,69.26 111.87,69.51 111.91,69.61 111.91,69.95 111.75,70.11 111.75,72.27 110.78,73.24 110.14,73.24 110.05,73.15 109.9,73.15 109.82,73.08 109.82,72.86 v1(109.88,72.8)
  BOTTOM w0.094: CV5.1 94.4,87.54 94.4,87.3 94.81,86.89 94.81,86.59 v1(95.06,86.34)
EDP_TXP1_C: length 6.3
  BOTTOM w0.094: CV5.2 94.4,89.16 94.4,89.53 94.77,89.9 95.63,89.9 96.68,90.95 97.85,90.95 98.13,91.23 98.13,91.43 98.3,91.61 JEDP1.37
EDRAM_OPIO_RCOMP: length 10.9
  IN1 w0.381: v1(91.64,66.95) 92.14,66.95 92.27,66.82 97.03,66.82 98.56,65.29 v1(99.29,65.29)
  BOTTOM w0.127: v2(90.86,68.38) RC90.1
  BOTTOM w0.254: v1(99.29,65.29) 99.49,65.1 UC1.H66
  BOTTOM w0.381: v1(91.64,66.95) 91.16,67.42 RC90.1
EMMC_RCOMP: length 11.3
  IN2 w0.381: v1(144.53,53.49) 144.15,53.49 141.86,51.2 v1(141.74,51.2)
  BOTTOM w0.203: UC1.AT1 137.7,50.96 138.38,51.63
  BOTTOM w0.381: v1(141.74,51.2) 141.22,51.2 v2(140.79,51.63) 140.49,51.94 138.69,51.94 138.38,51.63 ; RC4.1 145.04,51.96 144.53,52.47 v1(144.53,53.49)
EN_0.6V: length 6
  BOTTOM w0.102: v2(42.36,53.49) 42.51,53.33 42.51,51.45 42.82,51.15 PR210.2
  BOTTOM w0.203: PU200.2 45.29,50.57 PR212.1
  BOTTOM w0.254: PR210.2 PC222.1 43.85,51.14 PR212.1
EN_1.0V_PRIM_COREP: length 5.1
  TOP w0.102: PR407.1 126.6,114.21 v2(126.6,115.55)
  TOP w0.254: PU402.13 127.98,112.84 PR406.2 127.96,113.73 PC411.1 127.06,113.77 PR407.1
EN_1.2V: length 6.4
  BOTTOM w0.203: v2(39.31,51.16) 39.34,51.19 PR208.2 PR209.1 PC221.1 42.65,50.57 44.52,50.57 44.84,50.25 PU200.1
EN_1.8VALW: length 3.3
  TOP w0.203: PR504.2 PR505.1 PC505.1 122.05,105.84 PU501.1
EN_1VS_VCCIO: length 4.1
  TOP w0.254: PU401.13 139.25,110.48 139.13,110.6 v2(138.5,110.6) 137.56,110.6 PR402.2 137.46,110.53 PC402.1 137.46,112.3 PR403.1
EN_2.5V: length 4.4
  TOP w0.102: v2(196.29,1.65) PU503.5
  TOP w0.381: PR513.2 197.61,3.95 PC513.1 ; PC513.1 198.48,3.11 PR514.1 ; PC513.1 197.36,2.86 PU503.5
EN_+1VALWP: length 5.1
  BOTTOM w0.102: v2(184.14,99.59) PR302.1
  BOTTOM w0.254: PR302.1 PR312.2 183.6,97.13 183.6,95.85 183.02,95.28 PU301.11
EN_INVPWR: length 299
  TOP w0.102: RE55.1 293.79,70.03 294.26,70.5 294.81,70.5 295.99,71.68 v1(295.99,72.3) 295.99,72.32 296.36,72.69 UE1.B2 ; v1(190.18,28.43) 190.18,38.75 188.67,40.26 184.28,40.26 174.43,50.11 174.43,59.47 166.92,66.97 164.75,66.97 158.12,73.6 158.12,75.27 156.66,76.73 156.66,83.79 149.68,90.77 v2(147.83,90.77) 145.88,90.77 145.04,91.61 131.54,91.61 126.99,87.06 117.26,87.06 116.58,86.38 115.24,86.38 113.06,84.19 113.06,82.18 109.64,78.76 105.09,78.76 103.93,79.93 102.6,79.93 v1(101.22,81.3)
  IN1 w0.089: v1(295.99,72.3) 296.96,71.33 296.96,69.27 297.44,68.79 298.54,68.79 298.94,68.39 298.94,64.46 300.01,63.38 300.01,60.78 298.89,59.66 298.89,56.05 300.26,54.67 300.26,50.77 299.97,50.48 298.77,50.48 297.18,48.89 295.75,48.89 295.32,48.46 295.32,46.89 292.02,43.59 292.02,42.72 290.5,41.2 289.62,41.2 288.68,40.26 288.68,39.39 287.78,38.5 287.78,37.89 282.15,32.25 257.88,32.25 257.15,31.53 254.36,31.53 249.93,27.09 240.34,27.09 238.48,25.23 237.01,25.23 236.28,25.96 232.75,25.96 227.57,20.78 220.9,20.78 219.99,19.87 218.89,19.87 218.53,20.23 214.71,20.23 214.57,20.09 212.93,20.09 212.37,20.64 208.57,20.64 207.6,21.61 200.75,21.61 193.93,28.43 v1(190.18,28.43)
  BOTTOM w0.102: v1(101.22,81.3) 101.18,81.34 QV2.2
EN_LCDPWR: length 4.3
  BOTTOM w0.102: v2(92.02,83.34) 92.45,83.78 DV3.1 92.97,83.34 RV3.2 94.71,82.5 UV24.4
EN_PD_HV_1: length 172.3
  TOP w0.102: PR1211.1 18.03,38.61 PR1254.1 v1(18.04,39.64) 19.06,40.66 23.25,40.66 23.89,40.01 v2(23.89,38.64) 23.89,35.82 25.02,34.69 PR1260.1 ; v1(12.74,38.88) 12.57,38.71 PR1210.1 12.57,37.6 11.94,36.98 PQ1214.5 ; v1(39.54,75.33) 40.33,76.12 40.33,84.7 39.45,85.58 39.45,87.44 38.97,87.93 36.99,87.93 36.66,87.6 36.43,87.6 35.77,86.94 RT70.2 ; PR1250.2 v1(70.85,111.93)
  IN1 w0.089: v1(66.02,91.93) 69.89,95.8 69.89,99.05 72.52,101.68 72.52,105.62 70.85,107.29 v1(70.85,111.93) ; v1(18.04,39.64) 18.04,38.98 18.33,38.69 30.55,38.69 32.9,41.04 32.9,43.9 37.81,48.81 37.81,56.85 v1(36.81,57.85)
  IN3 w0.122: v1(36.81,57.85) 36.81,60.39 40.01,63.59 40.01,70.27 41.76,72.01 41.76,72.74 53.17,84.15 53.17,85.55 54.9,87.28 58.11,87.28 59.4,88.57 61.07,88.57 64.32,91.81 65.9,91.81 v1(66.02,91.93)
  BOTTOM w0.102: v1(12.74,38.88) 13.75,39.9 17.79,39.9 v1(18.04,39.64) ; v1(36.81,57.85) 36.81,71.93 38.97,74.08 39.57,74.08 39.96,74.48 39.96,74.91 v1(39.54,75.33)
EN_PD_HV_1#: length 3.4
  TOP w0.102: v2(11.52,32.66) 11.97,33.1 PR1253.2
  TOP w0.254: PR1253.2 11.94,33.57 PQ1214.2 11.94,34.82 12.13,35.01 12.45,35.01 12.59,34.86 PQ1214.3
EN_PD_HV_1_R: length 3.8
  TOP w0.076: 34.47,83.98 34.24,83.74 34.24,83.35 34.39,83.19 34.39,82.79 UT5.C2
  TOP w0.102: 34.47,83.98 34.89,83.98 35.36,84.45 35.36,84.85 RT70.1
ENABLE_DS#: length 8.2
  TOP w0.102: UE1.L2 303.96,72.33 303.96,71.16 305.19,69.93 305.82,69.93 306.65,69.11 RE550.1 RE549.2 307.47,68.22 307.09,68.6 v2(306.68,68.6)
ENLDO_3V5V: length 30.7
  TOP w0.254: PU100.11 153.64,113.06 153.14,113.56 v1(153.14,113.68)
  IN4 w0.254: v1(170.95,119.02) 170.95,118.83 170.63,118.51 169.52,118.51 168.57,119.46 154.56,119.46 153.52,118.43 153.52,114.06 v1(153.14,113.68)
  BOTTOM w0.102: v1(153.14,113.68) v2(153.68,113.68)
  BOTTOM w0.254: PU102.11 169.6,115.52 170.6,116.52 170.6,117.4 171.14,117.94 PR102.1 PR103.1 171.14,118.83 v1(170.95,119.02)
ENVDD_PCH: length 79.1
  IN3 w0.122: v1(92.95,85) 93.1,84.85 96.02,84.85 96.66,85.5 96.66,85.53 97.64,86.51 99.86,86.51 101.45,88.1 107.84,88.1 109.83,86.1 110.75,86.1 111.97,84.88 112.6,84.88 112.78,85.06 116.54,85.06 117.63,86.15 125.95,86.15 128.14,83.97 130.97,83.97 132.39,85.39 v1(134.24,85.39)
  IN4 w0.089: v1(134.24,85.39) 134.24,84.4 133.86,84.02 133.86,83.27 135.26,81.87 135.26,79.11 136.13,78.24 136.13,76.24 136.45,75.91 136.45,66.39 135.5,65.44 135.5,62.62 134.63,61.74 133.24,61.74 132.83,61.32 132.83,61.12 132.6,60.9 130.39,60.9 130.02,61.27 v1(129.96,61.27)
  BOTTOM w0.102: DV3.3 v1(92.95,85) ; v1(129.96,61.27) 130.18,61.04 UC1.U13 ; v1(134.24,85.39) v2(133.74,85.39)
EOPIO_RCOMP: length 11.1
  IN1 w0.381: v1(91.64,66.12) 91.83,65.93 96.97,65.93 98.34,64.56 99.58,64.56 v1(100.31,65.29)
  BOTTOM w0.254: UC1.H65 100.5,65.1 v1(100.31,65.29)
  BOTTOM w0.381: v1(91.64,66.12) 91.14,66.12 RC91.1
ESPI_ALERT#: length 253.2
  TOP w0.102: RC21.1 137.5,39.81 v1(137.5,40.66)
  TOP w0.107: v1(301.54,76.36) 301.54,76.37 301.19,76.73 UE1.H7
  IN2 w0.122: v1(137.5,40.66) 138.79,39.37 138.96,39.37 140.09,38.24 140.09,36.57 141.61,35.04 142.18,35.04 145.31,31.91 145.31,31.66 154.5,22.47 176.99,22.47 177.69,23.17 181.73,23.17 182.24,22.66 188.23,22.66 193.58,17.31 194.61,17.31 198.79,13.13 199.99,13.13 200.92,12.21 203.97,12.21 205.82,10.35 209.48,10.35 211.06,11.93 214.74,11.93 215.63,11.05 224.65,11.05 225.09,10.61 225.93,10.61 227.69,12.38 227.69,14.27 233.51,20.08 243.13,20.08 246.84,23.79 253.6,23.79 254.22,23.17 256.18,23.17 258.05,25.04 258.81,25.04 260.15,26.38 262.48,26.38 264.27,28.16 279.94,28.16 282.6,30.83 282.6,31.15 286.18,34.73 287.63,34.73 290.38,37.48 291.62,37.48 292.48,38.35 292.48,39.42 293.27,40.2 293.27,41.17 294.65,42.55 294.65,43.73 295.33,44.42 296.88,44.42 297.31,44.85 297.31,45.53 299.06,47.29 299.06,47.8 298.84,48.02 298.84,49.27 299.5,49.93 302.04,49.93 302.66,50.55 302.66,50.81 307.56,55.72 307.56,58.35 307.71,58.49 307.71,60.46 308.45,61.21 308.45,64.76 307.66,65.55 307.66,67 307.33,67.33 306.62,67.33 306.08,67.87 306.08,69.68 305.63,70.12 303.41,70.12 303.03,69.74 303.03,69.23 302.46,68.66 301.19,68.66 299.97,69.88 299.97,71.19 301.1,72.32 301.1,75.92 v1(301.54,76.36)
  BOTTOM w0.076: 134.76,43.51 134.76,43.59 133.34,45.01 132.71,45.01 130.91,46.81 130.91,47.82 131.02,47.93 UC1.AY11
  BOTTOM w0.102: v1(137.5,40.66) 137.01,40.66 v2(136.07,41.6) 136.07,42.2 134.76,43.51
ESPI_CLK: length 13.2
  TOP w0.102: RC16.1 138.82,41.29 v1(138.94,41.17)
  BOTTOM w0.076: UC1.AW9 132.57,48.92 132.17,48.52 132.17,47.95 132.13,47.87 132.13,47.59 132.19,47.48 132.19,47.34 132.13,47.23 132.13,46.85 132.97,46.02 133.48,46.02 134.83,44.66 135.39,44.66
  BOTTOM w0.102: v1(138.94,41.17) v2(138.94,42.7) 136.99,44.66 135.39,44.66
ESPI_CLK_5105: length 235.7
  TOP w0.102: RE350.1 286.06,78.71 287.56,78.71 288.65,77.62 v2(288.65,77.03) v1(288.65,76.35) ; v1(299.96,76.33) UE1.G7 ; v1(140.98,40.4) 140.98,40.81 140.21,41.57 140.21,42.32 CC316.1 RC16.2
  IN2 w0.122: v1(179.99,51.33) 179.99,52.41 183.11,55.54 190.28,55.54 202.42,43.4 204.22,43.4 205.47,42.64 208.87,40.83 211.07,39.97 216.74,38.37 221.27,37.74 234.46,37.74 241.33,39.85 243.85,40.81 249.46,40.81 255.78,47.13 255.78,47.95 260.3,52.47 260.3,54.01 262.45,56.15 265.38,56.15 265.97,55.57 269.04,55.57 271,57.52 271,62.07 269.14,63.93 v1(269.14,65.34)
  BOTTOM w0.102: v1(140.98,40.4) 140.98,39.69 143.9,36.77 148.63,36.77 148.74,36.67 148.74,35.63 148.84,35.53 149.04,35.53 149.14,35.63 149.14,36.81 149.24,36.91 149.6,36.91 149.7,36.81 149.7,35.45 149.8,35.35 150.01,35.35 150.11,35.45 150.11,37.83 150.21,37.93 150.41,37.93 150.51,37.83 150.51,34.94 150.61,34.84 150.82,34.84 150.92,34.94 150.92,37.76 151.02,37.86 151.22,37.86 151.33,37.76 151.33,34.87 151.43,34.77 151.63,34.77 151.73,34.87 151.73,36.67 151.86,36.8 152.07,36.8 152.2,36.67 152.2,34.97 153.17,34 166.1,34 169.14,37.05 169.14,39.97 169.8,40.63 170.41,40.63 178.16,48.38 178.16,50.54 179.1,51.48 179.84,51.48 v1(179.99,51.33) ; v1(299.96,76.33) 299.16,76.33 298.77,75.94 295.15,75.94 294.33,76.76 292.45,76.76 292.08,76.4 290.73,76.4 290.25,75.91 289.08,75.91 v1(288.65,76.35) 288.52,76.22 285.42,76.22 284.42,75.21 284.42,73.03 283.98,72.59 283.98,72.05 280.24,68.32 273.26,68.32 272.84,67.9 272.84,66.81 271.64,65.6 270.44,65.6 270.2,65.84 JESPI.10 269.64,65.84 v1(269.14,65.34)
ESPI_CS#: length 253.3
  TOP w0.102: v1(301.56,75.52) 301.16,75.92 UE1.H6
  IN2 w0.122: v1(180.46,50.73) 182.32,52.59 183.2,52.59 183.34,52.74 183.34,54.03 183.49,54.18 183.7,54.18 183.85,54.03 183.85,52.74 183.99,52.59 184.2,52.59 184.35,52.74 184.35,54.03 184.5,54.18 184.7,54.18 184.85,54.03 184.85,52.74 185,52.59 185.21,52.59 185.35,52.74 185.35,54.03 185.5,54.18 185.71,54.18 185.86,54.03 185.86,52.74 186,52.59 186.21,52.59 186.36,52.74 186.36,54.03 186.51,54.18 186.72,54.18 186.86,54.03 186.86,52.74 187.01,52.59 187.22,52.59 187.37,52.74 187.37,53.78 187.5,53.91 187.7,53.91 187.87,53.75 187.87,52.74 188.02,52.59 188.22,52.59 188.37,52.74 188.37,53.78 188.5,53.91 188.71,53.91 188.87,53.75 188.87,52.74 189.02,52.59 190.89,52.59 200.96,42.53 204.66,42.53 208.58,38.6 213.96,38.6 214.79,37.76 215.7,37.76 216.87,36.59 220.55,36.59 221.19,37.23 235.88,37.23 240.91,39.09 242.14,39.09 242.66,39.62 243.62,39.62 244.28,40.28 249.69,40.28 256.34,46.93 256.34,47.79 260.81,52.26 260.81,53.75 262.7,55.64 265.12,55.64 265.7,55.06 269.27,55.06 271.51,57.3 271.51,62.27 269.83,63.95 269.83,66.49 v1(268.86,67.46)
  BOTTOM w0.076: UC1.BA12 130.72,47.77 130.74,47.74 130.74,46.73 132.78,44.69 132.93,44.69
  BOTTOM w0.102: 132.93,44.69 133.29,44.69 135.72,42.26 135.72,41.37 137.83,39.26 139.32,39.26 141.4,37.18 141.4,31.34 144.12,28.62 145.71,28.62 147.05,29.96 164.36,29.96 170.16,35.76 170.16,38.82 v2(176.99,45.65) 180.22,48.87 180.22,50.48 v1(180.46,50.73) ; v1(301.56,75.52) 301.17,75.13 299.75,75.13 299.56,75.32 299.56,75.7 299.79,75.93 300.17,75.93 300.39,76.14 300.39,76.5 300.15,76.73 295.25,76.73 293.92,78.06 289.38,78.06 289.09,77.78 284.98,77.78 283.19,75.99 283.19,75.63 282.63,75.08 282.63,73.22 278.46,69.05 272.49,69.05 271.93,68.49 271.93,67.44 271.68,67.2 270.62,67.2 270.48,67.34 JESPI.7 268.98,67.34 v1(268.86,67.46)
ESPI_IO0: length 227.3
  TOP w0.102: UE1.K5 v1(303.14,74.74) ; RC366.2 v1(138.69,35.1)
  IN2 w0.122: v1(182.02,49.6) 183.24,50.81 190.64,50.81 199.92,41.53 204.24,41.53 208.17,37.6 211.74,37.6 212.6,36.75 215.13,36.75 216.35,35.53 235.15,35.53 241.26,38.1 242.55,38.1 243.07,38.62 244.03,38.62 244.7,39.29 250.25,39.29 260.51,49.55 261.94,49.55 263.44,51.05 265.47,51.05 266.25,51.82 266.25,52.96 267.33,54.04 269.68,54.04 272.52,56.89 272.52,62.48 272.93,62.88 272.93,68.93 271.04,70.81 269.94,70.81 v1(268.86,69.74)
  BOTTOM w0.102: v1(182.02,49.6) 182.02,49.27 v2(181.22,48.47) 170.97,38.22 170.97,35.29 170.19,34.5 170.19,32.66 166.66,29.13 147.37,29.13 146.17,27.93 143.67,27.93 138.69,32.91 v1(138.69,35.1) ; v1(303.14,74.74) 302.75,75.14 302.75,76.6 302.15,77.2 300.74,77.2 300.52,77.42 295.78,77.42 294.22,78.98 289.58,78.98 289.32,79.23 288.32,79.23 287.63,78.55 284.7,78.55 282.43,76.27 282.43,75.86 281.95,75.38 281.95,73.53 278.2,69.78 271.67,69.78 271.13,69.24 270.36,69.24 270.26,69.34 JESPI.3 269.27,69.34 v1(268.86,69.74)
ESPI_IO0_R: length 16.5
  TOP w0.102: RC366.1 138.69,37.1 v1(138.94,37.36)
  BOTTOM w0.076: UC1.AY13 130.15,48.23 130.04,48.12 129.94,48.01 129.87,47.8 129.87,47.68 129.93,47.45 129.93,47.31 129.88,47.19 129.88,46.92 130,46.79 130,46.04 132.84,43.2
  BOTTOM w0.102: v1(138.94,37.36) 138.04,37.36 136.27,39.13 136.08,39.13 135.31,39.9 134.86,39.9 134.61,40.15 134.61,40.63 v2(133.61,41.62) 133.61,42.26 133.15,42.72 133.15,42.89 132.84,43.2
ESPI_IO1: length 226.2
  TOP w0.102: UE1.L4 303.56,74.23 v1(303.94,73.85) ; RC367.2 v1(139.58,35.05)
  IN2 w0.122: v1(181.37,49.67) 182.91,51.21 190.67,51.21 200.1,41.78 204.35,41.78 208.27,37.85 213.65,37.85 214.5,37 215.37,37 216.59,35.78 235.06,35.78 241.18,38.35 242.44,38.35 242.97,38.87 243.93,38.87 244.59,39.54 250.12,39.54 260.44,49.87 261.88,49.87 263.42,51.4 265.45,51.4 265.99,51.95 265.99,53.09 267.2,54.3 269.58,54.3 272.27,56.99 272.27,62.71 272.62,63.06 272.62,68.48 271.86,69.24 269,69.24 v1(268.86,69.11)
  BOTTOM w0.102: v1(268.86,69.11) 269.13,68.84 JESPI.4 270.41,68.84 270.58,69.01 271.39,69.01 271.92,69.54 278.29,69.54 282.17,73.42 282.17,75.28 282.68,75.79 282.68,76.21 284.8,78.32 287.73,78.32 288.33,78.93 289.25,78.93 289.44,78.73 294.04,78.73 295.59,77.19 300.41,77.19 300.63,76.97 301.64,76.97 301.96,76.65 301.96,74.57 302.19,74.34 303,74.34 303,74.34 303.33,74.34 303.81,73.85 v1(303.94,73.85) ; v1(139.58,35.05) 139.58,32.52 143.94,28.16 145.9,28.16 147.24,29.5 166.65,29.5 169.93,32.78 169.93,34.69 170.62,35.38 170.62,38.34 v2(179.51,47.22) 181.37,49.09 v1(181.37,49.67)
ESPI_IO1_R: length 15.6
  TOP w0.102: RC367.1 v1(139.58,37.36)
  BOTTOM w0.076: 132.84,44.12 130.41,46.55 130.41,47.27 130.15,47.53 UC1.BA13
  BOTTOM w0.102: 132.84,44.12 132.99,44.12 134.85,42.26 v2(134.85,41.98) 134.85,41.27 138.36,37.76 139.32,37.76 139.58,37.51 v1(139.58,37.36)
ESPI_IO2: length 226.9
  TOP w0.102: UE1.G6 v1(299.96,75.53) ; v1(144.74,29.03) v2(143.52,29.03) 142.95,29.03 140.47,31.51 138.92,31.51 137.16,33.27 137.16,36.97 136.96,37.17 136.96,38.51 136.66,38.82 RC368.2
  IN2 w0.122: v1(179.81,50.28) 179.81,49.97 180.27,49.51 180.61,49.51 182.77,51.66 190.6,51.66 200.24,42.03 204.45,42.03 208.38,38.1 213.75,38.1 214.6,37.25 215.47,37.25 216.66,36.06 235.05,36.06 241.04,38.59 242.34,38.59 242.87,39.12 243.82,39.12 244.49,39.79 249.96,39.79 258.31,48.14 258.31,49.06 261.32,52.07 261.32,53.5 262.96,55.14 264.86,55.14 265.45,54.55 269.47,54.55 272.01,57.09 272.01,63.14 272.14,63.26 272.14,68.43 271.65,68.92 269.32,68.92 v1(268.86,68.47)
  BOTTOM w0.102: v1(268.86,68.47) 269,68.34 JESPI.5 270.23,68.34 270.67,68.78 271.51,68.78 272.03,69.31 278.39,69.31 282.4,73.32 282.4,75.18 282.94,75.71 282.94,76.06 284.89,78.01 289,78.01 289.28,78.3 294.09,78.3 295.43,76.96 300.3,76.96 300.64,76.62 300.64,75.84 300.33,75.53 v1(299.96,75.53) ; v1(179.81,50.28) 179.81,48.92 169.93,39.05 169.93,35.85 164.35,30.27 146.75,30.27 145.51,29.03 v1(144.74,29.03)
ESPI_IO2_R: length 10.5
  TOP w0.102: RC368.1 136.08,40.35 135.22,40.35 v1(135.1,40.47)
  BOTTOM w0.076: UC1.BB13 130.15,46.9 130.24,46.8 130.24,46.29 v2(133.46,43.07)
  BOTTOM w0.102: v2(133.46,43.07) 134.32,42.21 134.32,41.54 135.1,40.76 v1(135.1,40.47)
ESPI_IO3: length 226.6
  TOP w0.102: UE1.L5 v1(303.96,74.73) ; RC369.2 v1(140.59,34.64)
  IN2 w0.122: v1(180.63,50.14) 182.67,52.18 190.8,52.18 200.7,42.28 204.55,42.28 208.48,38.35 213.85,38.35 214.7,37.51 215.57,37.51 216.76,36.31 220.69,36.31 221.35,36.98 235.93,36.98 240.98,38.84 242.24,38.84 242.76,39.37 243.72,39.37 244.39,40.04 249.83,40.04 257.92,48.13 257.92,49.01 261.07,52.16 261.07,53.62 262.83,55.39 264.99,55.39 265.57,54.81 269.37,54.81 271.76,57.19 271.76,63.47 270.18,65.04 270.18,67.17 v1(270.76,67.75)
  BOTTOM w0.102: v1(270.76,67.75) 270.67,67.84 JESPI.6 269.12,67.84 268.96,68 268.7,68 268.14,68.56 v2(268.14,68.99) 268.14,69.9 269.06,70.82 270.72,70.82 271.53,70.01 277.22,70.01 279.16,71.95 279.99,71.95 281.72,73.68 281.72,75.48 282.2,75.96 282.2,76.37 284.61,78.78 287.54,78.78 288.34,79.58 289.82,79.58 290.11,79.29 295.25,79.29 296.22,78.32 300.29,78.32 301.14,77.47 302.85,77.47 303.58,76.75 303.58,75.11 v1(303.96,74.73) ; v1(140.59,34.64) 140.59,31.83 144.03,28.39 145.81,28.39 147.15,29.73 164.46,29.73 170.39,35.66 170.39,38.58 180.63,48.82 v1(180.63,50.14)
ESPI_IO3_R: length 18.2
  TOP w0.102: v2(141.51,36.72) RC369.1 v1(140.59,37.36)
  BOTTOM w0.076: UC1.AY12 130.72,48.52 130.41,48.22 130.41,47.79 130.58,47.63 130.58,46.64 132.76,44.45 133.03,44.45
  BOTTOM w0.102: v1(140.59,37.36) 139.96,37.99 138.66,37.99 135.49,41.17 135.49,42.02 133.06,44.45 133.03,44.45
ESPI_RESET#: length 266.8
  TOP w0.102: v2(142.13,31.29) v1(142.54,30.88)
  TOP w0.107: v1(303.16,75.53) UE1.K6
  IN2 w0.122: v1(142.54,30.88) 145,30.88 153.63,22.25 177.09,22.25 177.78,22.94 181.64,22.94 182.14,22.44 188.14,22.44 193.49,17.09 194.52,17.09 198.7,12.91 199.9,12.91 200.82,11.98 203.81,11.98 205.67,10.13 209.57,10.13 211.15,11.71 214.65,11.71 215.54,10.82 224.56,10.82 225.13,10.25 227.57,10.25 231.25,13.93 231.25,17.11 233.94,19.8 243.18,19.8 246.94,23.56 253.45,23.56 254.06,22.95 256.27,22.95 258.14,24.82 258.9,24.82 260.24,26.15 262.59,26.15 264.34,27.91 280.01,27.91 282.83,30.72 282.83,31.06 286.2,34.43 287.96,34.43 288.9,35.37 289.92,35.37 292.71,38.16 292.71,39.32 293.49,40.11 293.49,40.97 295.79,43.27 295.79,43.67 296.3,44.18 297,44.18 298.81,45.99 298.81,46.58 299.45,47.21 299.45,47.9 299.22,48.13 299.22,48.74 299.75,49.27 302.01,49.27 302.93,50.19 304.76,50.19 308.21,53.64 308.21,58.36 309.86,60.01 309.86,60.98 309.25,61.59 309.25,63.04 309.58,63.37 309.58,64.89 308.67,65.81 308.67,67.02 306.71,68.98 306.71,70.12 306.25,70.58 306.25,71.4 305.49,72.16 305.49,73.53 305.23,73.78 305.23,74.43 304.54,75.13 303.56,75.13 v1(303.16,75.53)
  IN4 w0.089: v1(303.16,75.53) UE1.K6 297.32,75.93 297.16,76.09 297.16,76.68 297.01,76.83 292.69,76.83 292.21,76.35 291.52,76.35 291.29,76.57 291.29,76.88 v1(290.76,77.41)
  BOTTOM w0.076: UC1.BA11 131.07,47.47 131.07,46.9 132.63,45.34 133.26,45.34 134.99,43.61 134.99,43.56
  BOTTOM w0.102: v1(290.76,77.41) 289.64,77.41 289.4,77.17 RE560.2 ; v1(142.54,30.88) 141.75,31.66 141.75,37.6 139.45,39.9 138.18,39.9 138.01,40.07 138.01,41.24 136.37,42.88 135.67,42.88 134.99,43.56
FB_1.8VALW: length 4.8
  TOP w0.102: PR506.1 120.1,111.5 v2(120.1,111.93)
  TOP w0.254: PU501.6 121.29,108.49 PR501.2 PC503.2 120.99,110.51 PR506.1
FB_+1VALWP: length 6.5
  BOTTOM w0.102: PR311.1 184.14,95 184.5,95.36 185.9,95.36 186.21,95.67 v2(186.21,96.41)
  BOTTOM w0.254: PR311.1 PR308.2 ; PR308.2 184.07,93.93 PU301.14 ; PR308.2 PR306.2
FB_GT: length 7.6
  TOP w0.203: PR645.2 61.98,53.6 PR650.1 PR648.2 63.23,52.25 63.23,51.59 63.45,51.36 63.45,50.59 63.96,50.09 v2(63.96,49.88) 64.25,49.58 PU602.17
FB_VSA: length 7.2
  TOP w0.203: PU602.25 68.56,46.35 67.95,45.74 v1(67.34,45.74)
  BOTTOM w0.102: v2(66.11,42.75) 67.1,43.75 PR646.1
  BOTTOM w0.203: PR646.1 67.08,43.86 PR649.1 ; PR652.1 67.07,44.7 PR649.1 ; PR649.1 67.08,45.48 v1(67.34,45.74)
FCCM_GT: length 24.9
  TOP w0.203: PU602.21 66.96,47.33 v1(66.3,47.33)
  IN2 w0.254: v1(66.3,47.33) 66.24,47.39 66.24,52.98 65.47,53.74 64.27,53.74 63.44,54.56 63.44,57.69 62.24,58.9 v1(53.68,58.9)
  BOTTOM w0.102: v2(66.93,47.52) 66.74,47.33 v1(66.3,47.33)
  BOTTOM w0.254: PR662.1 v1(53.68,58.9)
FCCM_IA: length 28.1
  TOP w0.203: PU602.11 65.89,51.98 65.85,52.02 65.85,52.22 65.41,52.66 65.41,53.17 v2(65.03,53.55) 64.27,54.31 v1(64.27,54.5)
  TOP w0.254: v1(62.13,73.09) 62.13,73.04 62.12,73.03 PR659.1
  IN2 w0.254: v1(64.27,54.5) 63.89,54.88 63.89,57.8 62.13,59.56 v1(62.13,73.09) 62.51,73.47 62.51,75.2 v1(61.57,76.14)
  BOTTOM w0.254: PR671.1 v1(61.57,76.14)
FCCM_VSA: length 72.1
  TOP w0.203: PU602.29 70.16,46.45 v1(70.36,46.24)
  IN3 w0.254: v1(66.68,83.33) 65.59,84.42 62.41,84.42 59.42,81.43 58.43,81.43 50.23,73.23 50.23,71.46 46.84,68.06 46.84,58.76 48.87,56.72 51.82,56.72 57.54,51.01 57.54,48.98 57.98,48.53 59.95,48.53 63.82,44.66 69.66,44.66 70.36,45.36 v1(70.36,46.24)
  BOTTOM w0.102: v2(69.86,45.84) 69.96,45.84 70.36,46.24 v1(70.36,46.24)
  BOTTOM w0.254: PR679.2 66.93,83.58 v1(66.68,83.33)
FFS_INT2: length 214.4
  TOP w0.102: v1(134.4,64.74) 135.75,63.39 138.94,63.39 143.74,68.19 RC404.1 ; QN1.2 280.6,38.57 280.6,38.12 278.76,36.28 275.46,36.28 v1(275.29,36.11)
  IN1 w0.089: v1(269.22,42.79) 270.2,42.79 270.24,42.83 271.54,42.83 271.85,42.52 273.5,42.52 274.43,41.6 276.48,41.6 276.76,41.88 277.6,41.88 279.29,40.19 279.29,39.33 278.72,38.76 277.9,38.76 277.57,39.09 276.82,39.09 276.53,38.8 276.53,37.36 v1(275.29,36.11) 274.87,36.53 257.45,36.53 255.95,35.03 252.07,35.03 247.46,30.42 238.21,30.42 237.1,29.31 230.24,29.31 227.19,26.27 220.3,26.27 219.74,26.83 211.95,26.83 211.94,26.81 200.83,26.81 192.55,35.09 190.04,35.09 189.24,34.3 180.43,34.3 178.52,36.21 173.88,36.21 171.91,38.19 171.91,38.82 167.34,43.39 163.39,43.39 162.82,43.96 161.57,43.96 157.23,48.3 157.23,60.31 154.45,63.1 152.76,63.1 150.88,64.98 144.7,64.98 144.07,65.6 140.89,65.6 139.92,64.62 134.52,64.62 v1(134.4,64.74)
  BOTTOM w0.102: LGA1.11 273.4,44.18 272.37,43.15 270.79,43.15 v2(270.65,43.01) 270.44,42.79 v1(269.22,42.79) ; UC1.J5 134.75,64.39 v1(134.4,64.74)
FFS_INT2_Q: length 11.5
  TOP w0.102: 283.09,39.39 282.68,39.8 QN1.3 ; 283.09,39.39 283.55,39.85 283.55,40.57 v1(283.39,40.73) ; 283.09,39.39 v2(283.09,37.57) 283.09,36.7 282.17,35.79 281.11,35.79 v1(281.04,35.85)
  BOTTOM w0.102: JSATA1.19 280.9,35.71 v1(281.04,35.85) ; RN1.2 282.63,41.5 v1(283.39,40.73)
FIVR_EN: length 3
  TOP w0.102: RC219.1 RC218.1 ; RC218.1 RC217.1 ; RC218.1 v2(64.39,42.51)
FIVR_EN_R: length 20.4
  TOP w0.102: v1(72.83,39.98) RC126.2 ; JXDP1.45 64.45,36.84 63.89,37.4 63.4,37.4 v1(63.2,37.59) 63.2,38.18 RC132.1 63.37,38.36 62.9,38.83 62.9,40.16 RC217.2 63.38,40.65 62.95,41.08 v2(62.95,42.49)
  BOTTOM w0.102: v1(72.83,39.98) 72.83,39.26 71.81,38.25 63.48,38.25 63.38,38.14 63.37,38.14 63.2,37.97 v1(63.2,37.59)
GPIO011: length 8.3
  TOP w0.102: T143.1 v1(309.5,76.15)
  TOP w0.107: v1(303.16,76.33) UE1.K7
  IN4 w0.089: v1(309.5,76.15) 309.14,75.79 305.92,75.79 304.94,76.76 303.6,76.76 v1(303.16,76.33)
GPIO051: length 2.8
  TOP w0.102: UE1.D1 297.96,71.02 297.79,70.86 T141.1
GPIO054: length 3.5
  TOP w0.107: v1(303.96,80.33) UE1.L11
  BOTTOM w0.102: v1(303.96,80.33) 304.37,80.74 304.37,82.62 T142.1
GPIO100: length 3.6
  TOP w0.102: T144.1 306.14,70.31 305.19,70.31 304.23,71.27 304.23,71.8 UE1.M1
GPIO202: length 11.2
  TOP w0.102: T262.1 v1(312.11,75.58)
  TOP w0.107: v1(302.36,75.53) UE1.J6
  IN4 w0.089: v1(302.36,75.53) 302.75,75.13 311.02,75.13 311.47,75.58 v1(312.11,75.58)
GPP_B23: length 17.6
  IN3 w0.122: v1(148.67,56.28) 147.6,55.21 143.52,55.21 v1(142.22,53.91)
  BOTTOM w0.102: v1(148.67,56.28) 148.66,56.27 RC317.1 ; UC1.AM7 133.94,53.45 134.25,53.14 135.19,53.14 135.32,53.27 135.62,53.27 135.83,53.06 135.83,52.73 135.95,52.61 137.75,52.61 137.95,52.8 139.65,52.8 139.93,53.08 v2(140.85,53.08) 141.4,53.08 v1(142.22,53.91)
GPP_C5: length 8.9
  BOTTOM w0.076: UC1.W1 138.34,59.57 138.45,59.68 139.7,59.68 140.14,60.13 140.57,60.13 140.91,60.47 v2(141.99,60.47) 142.25,60.47 142.78,61
  BOTTOM w0.102: RC25.1 143.24,61.46 142.78,61
GPP_C8: length 8.7
  BOTTOM w0.076: 139.22,58.29 138.33,58.29 138.18,58.44 137.65,58.44 UC1.AB1
  BOTTOM w0.102: 139.22,58.29 139.31,58.38 140.63,58.38 140.95,58.69 142.65,58.69 142.91,58.44 v2(144.25,58.44) 144.53,58.16 RC405.1
GPP_E23: length 1.2
  TOP w0.254: v1(130.55,62.34) 130.55,62.35 T120.1
  BOTTOM w0.254: UC1.N12 130.83,62.63 v1(130.55,62.34)
GPS_DISABLE#: length 53.1
  TOP w0.102: v1(294.12,44.27) 293.69,44.7 v2(293.43,44.7) 293.43,45.65 DZ6.1 ; RE12.1 v1(308.11,66.56)
  TOP w0.107: v1(301.56,74.73) UE1.H5
  IN1 w0.089: v1(294.12,44.27) 294.17,44.22 295.56,44.22 295.79,44.46 296.93,44.46 297.26,44.79 297.26,46.96 297.94,47.64 297.94,48.31 299.11,49.48 301.01,49.48 302.47,50.94 302.47,51.6 303.73,52.86 303.73,57.93 302.9,58.76 302.9,60.21 303.77,61.09 303.77,61.72 304.19,62.13 304.57,62.51 304.57,63.69 305.73,64.85 305.9,64.85 307.61,66.56 v1(308.11,66.56)
  IN2 w0.122: v1(308.11,66.56) 308.11,66.94 307.47,67.58 306.71,67.58 306.33,67.96 306.33,69.8 305.76,70.38 303.28,70.38 302.77,69.87 302.77,69.36 302.33,68.92 301.25,68.92 300.19,69.97 300.19,71.07 300.51,71.39 301,71.39 301.96,72.36 301.96,74.33 v1(301.56,74.73)
GPS_DISABLE#_R: length 2.8
  TOP w0.102: v2(293.79,48.46) 293.61,48.46 v1(293.27,48.12) 293.27,47.71 DZ6.2
  BOTTOM w0.102: v1(293.27,48.12) 293.05,48.35 JNGFF2.26
GPU_B+:
  vias: v1(55.94,66.46) v1(55.94,65.83) v1(55.94,65.19) v1(56.57,66.46) v1(56.57,65.83) v1(56.57,65.19) v1(57.21,66.46) v1(57.21,65.83) v1(57.21,65.19) v1(58.15,62.82) v1(58.15,61.61) v1(58.82,62.82) v1(58.82,61.61) v3(56.19,64.48)
GPU_PWR_LEVEL: length 3.6
  TOP w0.102: RE5.1 298.77,83.67 298.77,82.08 298.36,81.67 298.36,81.13 UE1.E12
GPU_SMCLK: length 18.1
  TOP w0.102: UE1.F7 299.16,77.13 296.28,77.13 295.96,77.44 v1(295.96,77.93) ; v1(284.04,76.22) 283.93,76.22 RE525.1
  IN4 w0.089: v1(295.96,77.93) 295.71,78.17 289.77,78.17 289.11,77.51 285.65,77.51 284.36,76.22 v1(284.04,76.22)
GPU_SMDAT: length 15.2
  TOP w0.102: v2(283.47,74.85) 283.7,74.85 284.04,75.19 v1(284.04,75.46) 283.74,75.46 RE524.1
  TOP w0.107: v1(295.96,75.53) UE1.B6
  IN4 w0.089: v1(295.96,75.53) 295.17,76.32 292.75,76.32 292.27,75.84 287.96,75.84 287.38,75.25 284.24,75.25 v1(284.04,75.46)
GREEN: length 12.6
  BOTTOM w0.102: LV17.2 316.11,87.63 CV130.1 316.06,87.06 315.35,86.35 315.35,85.12 DV5.3 316.39,83.9 v2(318.15,82.14) 318.23,82.06 320.98,82.06 JCRT1.2
GREEN_CRT: length 86.7
  TOP w0.102: RV117.1 281.49,57.8 v1(280.83,57.14) 280.68,56.99 280.68,56.18 280.45,55.95 280.45,55.85 280.27,55.67 UV6.22
  IN2 w0.122: v1(280.83,57.14) 281.18,57.49 281.18,58.97 281.59,59.38 281.59,61.15 280.62,62.11 280.62,62.83 280.68,62.88 280.68,64.03 280.24,64.46 279.72,64.46 279.47,64.21 279.47,63.39 279.29,63.2 278.98,63.2 278.57,63.61 278.57,66.62 278.77,66.82 278.77,71.65 279.53,72.41 279.53,73.04 280.1,73.61 280.36,73.61 280.59,73.37 280.91,73.37 281.1,73.56 281.1,73.75 280.8,74.05 280.8,76.47 281.38,77.05 282.58,77.05 285.82,80.28 286.17,80.28 287.16,81.28 287.16,81.83 290.73,85.4 291.22,85.4 292.11,86.28 292.11,89.68 294.15,91.72 297.46,91.72 301.37,87.81 302.33,87.81 302.51,88 302.51,88.23 302.68,88.41 302.94,88.41 303.14,88.21 303.14,88 303.32,87.81 304.13,87.81 304.43,87.51 308.7,87.51 308.88,87.34 310.09,87.34 310.28,87.52 310.28,88.65 310.48,88.85 310.74,88.85 310.91,88.69 310.91,87.52 311.09,87.34 311.35,87.34 311.54,87.52 311.54,88.63 311.73,88.82 311.99,88.82 312.17,88.64 312.17,87.52 312.35,87.34 313.21,87.34 314.34,86.21 315.13,86.21 315.63,86.71 315.63,89.02 315.22,89.43 v1(315.03,89.43)
  BOTTOM w0.102: v1(315.03,89.43) 316.03,90.43 CV127.1 316.11,90.4 LV17.1
GT_SNUB: length 4.3
  TOP w0.102: PR669.2 65.85,65.45 v2(66.53,65.45)
  TOP w0.508: PR669.2 63.7,67.61 PC670.1
GT_SW: length 3.4
  TOP w0.508: v1(66.87,64.41) 67.1,64.41 v2(67.8,65.11) 67.8,66.17 PR669.1
H_CATERR#: length 8.8
  BOTTOM w0.076: 100.81,73.45 100.81,73.17 101.08,72.91 101.08,72.59 102.19,71.48 102.19,70.73 102.01,70.55 102.01,70.09 102.16,69.94 102.16,69.58 102.12,69.48 102.12,69.29 102.16,69.2 102.16,68.95 102.15,68.91 102.1,68.75 102.02,68.47 102.02,68.36 101.94,68.09 UC1.D63
  BOTTOM w0.102: 100.81,73.45 101.35,73.98 101.35,74.4 101.45,74.51 v2(101.45,74.54) 101.61,74.69 RC79.1
H_CPU_SVIDALRT#: length 12.7
  BOTTOM w0.076: 100.01,73.01 100.47,72.55 100.47,72.35 101.19,71.63 101.19,71.29 101.27,71.2 101.57,71.2 101.66,71.11 101.66,70.99 101.57,70.9 101.27,70.9 101.19,70.81 101.19,70.28 101.4,70.06 101.4,69.17 101.51,69.06 UC1.B63
  BOTTOM w0.102: RC153.1 98.66,75.46 97.31,74.11 97.31,73.92 97.46,73.77 97.68,73.77 v2(98.23,74.33) 98.4,74.5 98.56,74.5 98.7,74.36 98.7,74.16 98.32,73.78 98.32,73.61 98.44,73.49 98.61,73.49 98.98,73.87 99.15,73.87 100.01,73.01
H_CPUPWRGD: length 16.1
  BOTTOM w0.076: 95.29,70.47 95.47,70.29 97.53,70.29 97.77,70.05 98.34,70.05 98.6,69.79 UC1.A68
  BOTTOM w0.102: RC77.2 CC300.1 91.25,79.46 93.69,77.02 v2(93.69,74.47) 93.69,72.07 95.29,70.47
H_CPUPWRGD_R: length 1.4
  BOTTOM w0.102: RC77.1 90.24,82.5 T9.1
H_THERMTRIP#: length 476.2
  TOP w0.102: v1(277.83,73.33) 278.82,72.34 278.82,71.05 278.92,70.95 279.49,70.95 279.74,71.2 281.14,71.2 QE4.3 ; RD14.2 73.03,5.99 v1(73.15,6.12) ; v1(212.1,2.35) 212.1,9.49 211.97,9.62 211.97,13.58 211.74,13.81 211.74,16.35 210.46,17.62 210.46,22.75 211.74,24.02 v1(211.74,29.44) ; v1(147.45,96.41) 147.3,96.41 v2(146.71,95.82) 145.48,94.59 144.49,94.59 143.71,93.82 141.84,93.82 140.98,94.68 130.79,94.68 125.4,89.29 122.51,89.29 122.07,89.73 116.26,89.73 114.79,88.26 112.73,88.26 110.98,86.51 110.98,85.92 111.28,85.62 111.28,83.81 109.4,81.93 108.3,81.93 107.79,81.43 104.97,81.43 103.5,82.9 100.67,82.9 100.06,82.3 v1(99.14,82.3) ; RD27.2 140.53,2.49 v1(140.53,1.54)
  IN1 w0.089: v1(212.1,2.35) 212.1,2.31 211.11,1.33 191.4,1.33 191.19,1.54 190.21,1.54 189.13,2.61 186.37,2.61 185.04,1.29 168.98,1.29 165.79,4.48 163.48,4.48 160.55,1.54 v1(140.53,1.54)
  IN2 w0.122: v1(73.15,6.12) 74.48,4.79 75.09,4.79 78.25,1.63 106.84,1.63 111.4,6.19 115.63,6.19 120.28,1.54 v1(140.53,1.54)
  IN4 w0.089: v1(277.83,73.33) 277.7,73.33 276.39,72.01 276.39,71.39 280.67,67.11 280.67,62.8 281.28,62.19 281.28,61.71 281.58,61.41 281.58,61.09 282.48,60.19 282.48,58.36 283.34,57.5 283.34,54.86 278.17,49.69 277.8,49.69 275.02,46.9 274.77,46.9 274.23,46.36 274.23,46.14 273.9,45.81 273.9,45.68 273.35,45.12 270.99,45.12 270.21,44.34 269.84,44.34 268.46,42.96 268.46,41.78 266.13,39.45 263.61,39.45 259.13,34.96 259.13,32.73 254.16,27.76 240,27.76 235.8,31.96 227.91,31.96 227.4,31.45 219.78,31.45 218.19,29.86 212.16,29.86 v1(211.74,29.44) 211.27,29.44 208.75,31.96 199.78,31.96 196.51,35.23 196.51,36.92 185.89,47.54 181.06,47.54 173.21,55.39 173.21,57.48 171.94,58.74 171.94,77.55 155.65,93.85 149.48,93.85 147.45,95.88 v1(147.45,96.41)
  BOTTOM w0.076: 101.08,75.12 101.13,75.08 101.13,74.01 100.56,73.45 ; 100.56,73.41 100.56,73.12 100.89,72.79 100.89,72.49 102.02,71.36 102.02,70.79 101.77,70.55 101.77,70.09 101.99,69.87 101.99,69.61 101.94,69.49 101.94,69.34 101.99,69.15 101.99,68.98 101.91,68.72 UC1.C63
  BOTTOM w0.102: 101.08,75.12 101.08,77.63 100.72,78 CC312.1 100.7,79.01 RC80.1 100.21,79.52 100.21,80.42 99.14,81.49 v1(99.14,82.3) ; 100.56,73.41 100.56,73.45
H_VCCST_PWRGD_XDP: length 7.4
  TOP w0.102: CC307.1 66.93,37.89 65.95,36.91 JXDP1.39 ; CC307.1 67.44,38.86 67.44,39.62 67.63,39.8 v2(67.63,40.48) ; CC307.1 RC123.2 RC124.2
HDA_BIT_CLK: length 13
  TOP w0.102: RC93.2 126.1,37.01 126.29,37.2 126.29,38.59 126.08,38.8 v1(126.08,39.77)
  BOTTOM w0.076: 126,43.94 125.71,44.23 125.71,45.36 125.37,45.7 125.37,46.39 125.04,46.72 125.04,47.19 125.09,47.31 125.09,47.45 125.03,47.68 125.03,47.8 125.1,48.01 125.2,48.12 125.3,48.23 UC1.AY22
  BOTTOM w0.102: v1(126.08,39.77) 126.45,40.14 126.45,41.59 v2(126.3,41.74) 126.12,41.92 126.12,43.82 126,43.94
HDA_BIT_CLK_R: length 204.9
  TOP w0.102: v1(135.97,31.4) 134.61,31.4 133.91,32.1 130.26,32.1 v2(130.25,32.11) 128.24,34.12 127.44,34.12 127.18,34.37 127.18,35.3 127.02,35.46 CC27.1 RC93.1 ; UA1.6 296.05,35.52 295.1,36.47 v1(294.89,36.47) 294.64,36.72 294.14,36.72 293.76,37.1 RA17.1
  IN2 w0.122: v1(135.97,31.4) 135.97,30.28 146.5,19.75 180.9,19.75 181.41,20.26 182.63,20.26 183.38,19.51 187.43,19.51 189.28,17.66 189.28,13.83 194.31,8.8 196.68,8.8 198.72,6.76 202.01,6.76 204.68,4.09 214.35,4.09 215.14,4.87 225.36,4.87 227.19,6.71 232.88,6.71 240.54,14.36 240.54,15.7 241.6,16.76 245.28,16.76 248.64,20.11 257.31,20.11 260.34,23.14 261.56,23.14 262.12,23.7 263.24,23.7 263.65,23.29 265.08,23.29 265.59,23.79 266.6,23.79 267.79,24.98 282.11,24.98 289.93,32.81 292.82,32.81 294.92,34.91 294.92,36.45 v1(294.89,36.47)
HDA_RST#: length 15.4
  TOP w0.102: v1(126.07,40.36) 126.59,40.36 126.84,40.11 126.84,37.37 127.26,36.95 127.46,36.95 CC331.1 RC95.2
  BOTTOM w0.076: v1(126.07,40.36) 125.67,40.77 125.67,43.89 125.37,44.2 v2(125.37,44.47) 125.37,45.46 125.21,45.62 125.21,46.3 124.87,46.64 124.87,47.23 124.89,47.26 124.92,47.34 124.92,47.46 124.85,47.68 124.85,47.82 124.91,47.98 124.91,48.06 125.13,48.76 125.13,48.76 125.3,48.94 UC1.AW22
HDA_RST#_R: length 202.4
  TOP w0.102: RA50.1 296.87,41.34 v1(296.87,40.7) ; v1(136.91,31.92) 134.86,31.92 134.19,32.58 130.76,32.58 v2(129.55,33.8) 128.73,34.61 RC95.1
  IN2 w0.122: v1(136.91,31.92) 137.48,31.92 148.89,20.5 179.51,20.5 180.39,21.38 182.68,21.38 183.8,20.26 188.11,20.26 191.07,17.29 191.07,16.26 199.06,8.28 204.88,8.28 206.12,7.03 211.77,7.03 213.69,8.96 217.76,8.96 219.75,6.97 226.4,6.97 227.01,7.59 231.91,7.59 238.4,14.08 238.4,15.64 241.07,18.31 244.3,18.31 247.66,21.66 252.61,21.66 252.86,21.4 256.65,21.4 258.83,23.59 259.41,23.59 259.72,23.89 261.25,23.89 261.81,24.45 263.7,24.45 264.98,25.73 281.79,25.73 284.88,28.82 284.88,30.43 287.11,32.66 289,32.66 289.65,33.32 292.61,33.32 294.38,35.08 294.38,36.8 295.04,37.46 296.09,37.46 296.87,38.24 v1(296.87,40.7)
HDA_SDIN0: length 216.3
  TOP w0.102: v1(287.35,32.2) 287.35,32.68 RA9.1 ; CC332.1 128.41,31.11 v1(128.53,30.99) 129.38,30.99 v2(129.39,31.01)
  IN2 w0.122: v1(287.35,32.2) 287.35,30.94 281.9,25.49 266.57,25.49 264.88,23.79 263.86,23.79 263.45,24.2 261.91,24.2 261.35,23.65 259.82,23.65 259.52,23.34 258.93,23.34 256.75,21.16 252.7,21.16 252.48,21.38 247.93,21.38 244.34,17.79 241.37,17.79 240.04,16.45 240.04,14.57 232.67,7.21 226.99,7.21 226.5,6.72 219.64,6.72 217.66,8.71 213.8,8.71 211.87,6.79 202.94,6.79 201.71,8.01 198.97,8.01 190.82,16.16 190.82,17.19 188,20.01 183.7,20.01 182.57,21.14 180.5,21.14 179.61,20.25 146.71,20.25 137.42,29.54 137.42,30.74 136.22,31.93 136.22,33.29 136.1,33.41 131.99,33.41 129.59,31.01 128.54,31.01 v1(128.53,30.99)
  BOTTOM w0.076: 126.48,45.17 126.48,45.61 126.04,46.05 126.04,46.66 125.9,46.79 125.9,48.03 UC1.BA21
  BOTTOM w0.102: 126.48,45.17 126.48,45.05 127.71,43.83 127.71,42.99 128.02,42.67 128.02,39.38 127.24,38.59 125.85,38.59 125.38,38.12 125.38,36.86 127.76,34.47 127.76,31.77 128.53,31.01 v1(128.53,30.99)
HDA_SDIN0_R: length 7.6
  TOP w0.102: v2(289.87,36.63) 291.26,36.63 RA9.2 292.17,35.72 292.17,35.46 292.31,35.32 294.65,35.32 295.15,34.82 295.86,34.82 295.96,34.72 UA1.8
HDA_SDOUT: length 15
  TOP w0.102: CC333.1 127.93,40.12 v1(127.59,39.78) ; CC333.1 128.02,41.04 128.02,41.86 v2(127.96,41.93) ; CC333.1 RC94.2 RC223.2 129.85,39.31 130.31,39.77 RC187.1
  BOTTOM w0.076: UC1.BB22 125.3,46.9 125.38,46.82 125.38,46.62 125.54,46.45 125.54,45.84 125.91,45.48 125.91,44.49 126.58,43.81 126.58,43.39 126.58,43.29
  BOTTOM w0.102: v1(127.59,39.78) 127.56,39.81 127.44,39.81 126.83,40.42 126.83,41.85 126.58,42.1 126.58,43.29
HDA_SDOUT_R: length 206.6
  TOP w0.102: UA1.5 296,35.92 295.34,36.59 v1(295.34,36.97) ; RC94.1 128.77,38.23 128.77,37.36 129.42,36.71 129.42,35.07 v2(130.83,33.66) 131.2,33.29 135.4,33.29 v1(135.8,32.89)
  IN2 w0.122: v1(295.34,36.97) 295.58,36.74 295.58,34.48 293.02,31.92 291.37,31.92 290.73,31.29 290.73,29.86 290.44,29.57 289.72,29.57 289.24,30.05 287.88,30.05 282.32,24.48 268.34,24.48 266.5,22.64 260.55,22.64 257.52,19.61 249.01,19.61 245.65,16.25 243.18,16.25 233.1,6.17 227.37,6.17 224.24,3.04 204.99,3.04 201.8,6.22 198.55,6.22 196.48,8.29 194.06,8.29 188.77,13.58 188.77,17.32 187.09,19.01 183.17,19.01 182.42,19.76 181.62,19.76 181.11,19.25 146.26,19.25 135.45,30.05 135.45,32.54 v1(135.8,32.89)
HDA_SYNC: length 13.2
  TOP w0.102: v1(127.57,41.1) 127.13,40.66 127.13,39.34 128.53,37.94 128.53,37.28 128.91,36.9 RC92.2
  BOTTOM w0.076: UC1.BA22 125.3,47.53 125.57,47.27 125.57,46.66 125.71,46.52 125.71,45.91 126.1,45.52 126.1,44.69 126.91,43.88 126.91,43.29
  BOTTOM w0.102: 126.91,43.29 126.91,42.86 127.57,42.2 v2(127.57,41.74) v1(127.57,41.1)
HDA_SYNC_R: length 199.9
  TOP w0.102: UA1.10 296.04,33.92 295.92,33.8 295.92,32.97 v1(295.6,32.66) ; v1(135.01,32.53) 134.57,32.96 v2(132.26,32.96) 131.02,32.96 128.91,35.08 RC92.1
  IN2 w0.122: v1(295.6,32.66) 294.26,32.66 293.17,31.56 291.39,31.56 291.01,31.18 291.01,29.76 290.52,29.27 289.66,29.27 289.13,29.8 287.99,29.8 282.14,23.95 268.16,23.95 266.6,22.39 260.65,22.39 257.62,19.36 249.14,19.36 245.78,15.99 243.44,15.99 233.25,5.81 227.36,5.81 224.34,2.79 204.89,2.79 201.7,5.97 198.44,5.97 196.37,8.04 193.96,8.04 188.52,13.48 188.52,17.07 186.84,18.76 183.07,18.76 182.34,19.48 181.7,19.48 181.21,19 146.15,19 135.01,30.14 v1(135.01,32.53)
HDD_A_EQ: length 3.5
  TOP w0.102: UN7.17 279.96,62.82 v1(280.06,62.72) 280.4,62.38 RN10.1
  BOTTOM w0.102: v2(280.52,62.39) 280.19,62.72 v1(280.06,62.72) 279.95,62.72 279.6,62.38 RN11.2
HDD_A_EQ2: length 3.3
  TOP w0.102: RN20.2 280.36,63.65 v1(280.04,63.32) UN7.18
  BOTTOM w0.102: RN21.1 279.98,63.26 v1(280.04,63.32) 280.05,63.32 v2(280.44,63.72)
HDD_A_PRE: length 3.9
  TOP w0.102: UN7.9 273.85,62.82 273.78,62.76 v1(273.62,62.76) RN6.2
  BOTTOM w0.102: v2(274.12,63.09) 273.79,62.76 v1(273.62,62.76) 273.62,62.59 273.28,62.25 RN7.2
HDD_B_EQ: length 5.2
  TOP w0.102: RN12.2 280.55,64.53 v1(280.04,64.03) 279.84,63.82 UN7.19
  BOTTOM w0.102: v1(280.04,64.03) 279.85,64.22 v2(278.49,64.22) 278.1,64.22 RN13.2
HDD_B_EQ2: length 4.6
  TOP w0.102: v2(280.57,59.2) 280.22,59.2 279.89,59.53 RN18.2 RN19.1 277.14,60.85 UN7.13
HDD_B_PRE: length 3.7
  TOP w0.102: RN8.1 273.27,63.77 v1(273.59,63.46) ; UN7.8 273.72,63.32 v1(273.59,63.46) ; v1(273.59,63.46) v2(273.95,63.81)
  BOTTOM w0.102: RN9.2 273.27,63.46 v1(273.59,63.46)
HDD_DET#: length 218.9
  TOP w0.102: QN6.2 250.88,38.51 250.64,38.75 248.73,38.75 248.28,38.29 QN7.2 246.26,37.61 230.64,31.77 229.49,30.63 228.03,30.63 v1(226.83,29.42)
  IN4 w0.089: v1(162.33,71.97) 163.42,71.97 165.2,70.19 165.2,67.58 165.73,67.05 165.73,54.83 171.26,49.29 171.26,48.29 180.8,38.76 183.04,38.76 188.32,33.48 188.71,33.48 199.05,23.13 205.3,23.13 205.77,22.67 207.39,22.67 207.57,22.85 215.38,22.85 215.55,22.67 218.17,22.67 218.5,23.01 221.37,23.01 221.94,22.43 225.84,22.43 226.28,22.88 v1(227.84,22.88) 230.48,22.88 231.81,21.56 252.18,21.56 253.34,20.4 261.37,20.4 262.77,21.8 262.77,23.72 264.13,25.08 264.13,25.22 272.32,33.42 275.55,33.42 v1(277.9,35.77)
  BOTTOM w0.076: 138.46,65.85 138.39,65.78 137.4,65.78 arc(137.32,65.79) 137.25,65.79 137.16,65.8 arc(137.12,65.8) 137.08,65.8 arc(136.89,65.76) 136.72,65.67 136.6,65.54 UC1.H2
  BOTTOM w0.102: v1(162.33,71.97) 161.93,71.57 v2(148.93,71.57) 148.85,71.65 147.77,71.65 147.39,71.27 146.82,71.27 146.56,71.01 146.56,70.63 146.37,70.43 RPC4.3 145.79,70.43 144.98,69.61 142.82,69.61 139.06,65.85 138.46,65.85 ; JSATA1.13 v1(277.9,35.77) ; v1(226.83,29.42) 226.76,29.36 226.76,23.96 v1(227.84,22.88)
HDD_DEVSLP: length 173.6
  IN1 w0.089: v1(138.8,65.02) 139.86,66.08 144.05,66.08 144.96,65.17 150.98,65.17 152.86,63.29 154.52,63.29 157.42,60.39 157.42,48.38 161.65,44.15 162.95,44.15 163.52,43.58 167.42,43.58 172.1,38.9 172.1,38.27 173.96,36.4 178.76,36.4 180.68,34.49 189.16,34.49 189.96,35.28 192.63,35.28 200.89,27.02 219.82,27.02 220.38,26.46 226.95,26.46 230.01,29.52 237.03,29.52 238.13,30.61 247.39,30.61 252,35.22 255.66,35.22 257.34,36.91 274.65,36.91 v1(275.95,38.22)
  BOTTOM w0.102: v2(139.83,65.23) 139.62,65.02 v1(138.8,65.02) 137.61,65.02 UC1.J1 ; v1(275.95,38.22) 275.95,38.17 RN3.2 276.99,37.13 276.99,36.34 276.81,36.16 276.81,35.56 276.9,35.48 JSATA1.11
