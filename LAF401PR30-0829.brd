# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P9_R: length 9.8
  TOP w0.094: v1(309.42,49.73) 309.42,49.41 DI5.3 309.52,48.74 309.22,48.44 309.22,48.02 308.83,47.64 308.83,47.37 309.04,47.16 LI7.3
  IN1 w0.089: JUSB1.3 313.1,49.93 313,49.83 311.68,49.83 311.02,49.17 309.27,49.17 309.16,49.28 309.16,49.48 v1(309.42,49.73)
USB20_P10: length 131.8
  TOP w0.094: JUSH1.9 223.37,11.15 223.47,11.05 223.47,10.91 223.55,10.84 223.72,10.84 225.09,12.21 225.09,17.4 v1(224.67,17.82)
  IN2 w0.076: 135.86,55.58 135.84,55.58 135.81,55.55 134.12,55.55 133.84,55.28 133.84,55.05 v1(133.67,54.88)
  IN2 w0.122: v1(224.67,17.82) 224.98,17.82 225.11,17.7 225.11,17.35 224.96,17.21 223,17.21 222.05,18.15 220.17,18.15 219.44,17.42 218.03,17.42 217.12,18.33 216.03,18.33 215.4,18.97 210.29,18.97 209.78,18.46 207.09,18.46 206.61,18.94 202.26,18.94 200.52,20.68 199.99,20.68 192.76,27.91 187.04,27.91 185.84,26.71 176.24,26.71 175.52,25.99 170.01,25.99 161.23,34.77 161.23,37.24 158.12,40.35 158.12,41.99 155.3,44.81 155.3,48.17 154.61,48.86 154.61,51.79 155.47,52.65 155.47,53.74 155.19,54.02 153.93,54.02 153.05,53.14 152.35,53.14 151.38,54.11 148.63,54.11 148.16,54.59 146.17,54.59 145.29,55.47 144.38,55.47 142.15,53.23 140.81,53.23 140.2,53.84 140.2,54.41 139.48,55.14 137.59,55.14 137.14,55.58 135.86,55.58
  BOTTOM w0.094: v1(133.67,54.88) UC1.AH8
USB_OC0#: length 262.9
  TOP w0.102: v1(136.78,80.16) 137.4,79.54 139.82,79.54 141.69,77.67 145.62,77.67 148.29,79.71 153.51,79.71 154.55,78.67 154.55,78.2 157.61,75.14 157.61,71.5 162.78,66.34 164.33,66.34 173.82,56.85 173.82,49.85 184.1,39.57 188.36,39.57 189.39,38.54 189.39,31.84 v2(189.11,31.56) 189.11,24.55 v1(189.21,24.45) ; v1(312.06,59.97) 311.56,59.47 UI3.13
  IN1 w0.089: v1(189.21,24.45) 189.59,24.07 189.97,24.07 190.3,24.4 193.42,24.4 194.89,22.93 194.89,20.49 198.29,17.08 203.46,17.08 204.07,16.47 205.75,16.47 208.21,14.01 212.99,14.01 214.08,15.09 219.22,15.09 219.58,14.73 222.87,14.73 223.4,15.26 228.27,15.26 233.39,20.37 244.74,20.37 246.43,22.06 252.24,22.06 254.48,24.3 257.14,24.3 260.57,27.73 285.55,27.73 288.55,30.73 288.55,32.8 290.53,34.78 291.39,34.78 293.89,37.28 294.69,37.28 295.26,37.85 295.26,38.29 297.38,40.41 297.38,40.92 297.7,41.25 298.94,41.25 300.36,42.66 300.36,43.71 300.84,44.18 303.23,44.18 303.51,44.46 303.51,45.11 304.17,45.78 306.89,45.78 307.9,46.79 307.9,50.21 309.21,51.52 309.21,57.38 311.79,59.97 v1(312.06,59.97)
  BOTTOM w0.076: UC1.A9 132.95,69.85 132.95,71 135.22,73.27 135.22,73.56
  BOTTOM w0.102: v1(136.78,80.16) 136.78,80.15 RPC3.2 136.78,78.88 136.53,78.63 136,78.63 135.9,78.53 135.9,74.23 135.22,73.56
USB_OC1#: length 162.7
  TOP w0.102: UI1.3 22.04,74.18 v1(23.02,73.2)
  IN2 w0.122: v1(137.28,80.48) 137.28,80.73 135.88,82.12 134.37,82.12 134.01,81.76 132.01,81.76 131.25,82.52 123.92,82.52 123.02,81.62 122.05,81.62 121.57,82.09 121.57,83.24 120.4,84.42 119.89,84.42 119.13,85.18 117.66,85.18 117.05,84.57 112.2,84.57 110.64,86.13 104.66,86.13 104.23,85.7 101.61,85.7 100.81,84.9 98.35,84.9 98.11,85.15 97.08,85.15 96.47,84.55 94.04,84.55 92.23,86.36 88.74,86.36 88.4,86.7 88.4,88.87 86.67,90.59 68.48,90.59 67.95,90.06 65.5,90.06 62.94,87.5 61.51,87.5 58.87,84.86 58.21,84.86 54.84,81.5 54.61,81.5 49.08,75.96 46.82,75.96 36.2,65.35 v1(36.2,61.49)
  BOTTOM w0.076: 135.41,73.27 135.41,73.23 133.12,70.94 133.12,68.95 132.81,68.64 UC1.C9
  BOTTOM w0.102: 135.41,73.27 138.44,76.3 138.44,78.25 138.05,78.63 137.55,78.63 137.28,78.9 RPC3.3 v1(137.28,80.48) ; v1(23.02,73.2) 23.78,73.2 24.42,72.55 26.75,72.55 27.06,72.25 27.06,67.84 v2(31.69,63.21) 33.41,61.49 v1(36.2,61.49)
USB_OC2#: length 86.6
  TOP w0.102: v1(89.79,86.89) v2(89.79,86.07)
  IN2 w0.122: v1(89.79,86.89) 92.33,86.89 94.45,84.77 96.38,84.77 96.99,85.38 98.21,85.38 98.75,85.92 101.15,85.92 101.22,86 104.02,86 104.38,86.36 110.73,86.36 112.09,85 116.81,85 117.43,85.62 119.52,85.62 121.8,83.34 121.8,82.18 122.14,81.84 122.93,81.84 123.93,82.85 127.49,82.85 128.14,83.5 130.59,83.5 132.1,81.98 133.85,81.98 134.24,82.38 136.11,82.38 137.7,80.79 v1(137.7,79.96)
  BOTTOM w0.076: 133.61,71.01 133.36,70.76 133.36,69.18 133.69,68.85 133.69,68.62 133.48,68.42 133.28,68.42 132.81,67.96 UC1.D9
  BOTTOM w0.102: UI2.3 85.48,98.63 85.48,92.66 89.79,88.35 v1(89.79,86.89) ; v1(137.7,79.96) 137.75,79.91 137.75,79.29 RPC3.4 138.82,78.23 138.82,76.22 133.61,71.01
USB_OC3#: length 11.9
  BOTTOM w0.076: 135.51,74.46 v2(135.04,73.99) 135.04,73.33 132.77,71.06 132.77,70.1 132.5,69.83 132.5,69.38 UC1.B9
  BOTTOM w0.102: 135.51,74.46 135.64,74.59 135.64,78.63 RPC3.1
USB_POWERSHARE_EN#: length 18.5
  TOP w0.102: v1(306.66,61.71) 306.46,61.5 306.46,60.94 306.93,60.47 UI3.6 ; RPE11.2 305.18,66.45 v1(305.29,66.56)
  TOP w0.107: v1(302.36,73.13) UE1.J3
  IN1 w0.089: v1(302.36,73.13) 302.36,71.31 302.79,70.88 302.79,67.58 304.28,66.09 304.8,66.09 305.27,66.56 v1(305.29,66.56)
  BOTTOM w0.102: v1(305.29,66.56) 305.24,66.51 305.24,66.49 305.01,66.26 v2(305.01,65.68) 305.01,65.63 307.39,63.25 307.39,62.31 306.85,61.78 306.73,61.78 v1(306.66,61.71)
USB_POWERSHARE_VBUS_EN: length 28
  TOP w0.102: UI3.5 307.19,61.88 v1(306.8,62.27) ; RPE11.4 304.18,66.74 v1(303.82,67.1) 304.37,67.65 304.37,69.79 303.92,70.25 303.31,70.25 302.34,71.21 302.34,72.34 UE1.J2 ; v1(304.3,53.32) 304.3,53.03 RI81.1
  IN3 w0.122: v1(306.8,62.27) 307.12,61.95 307.12,61.51 306.58,60.97 305.83,60.97 303.91,59.04 303.91,53.86 304.3,53.47 v1(304.3,53.32)
  BOTTOM w0.102: v1(306.8,62.27) 303.82,65.25 v2(303.82,66.41) v1(303.82,67.1)
USB_PWR_EN1#: length 388.3
  TOP w0.102: v1(23.02,73.81) 23.3,73.81 UI1.4 ; v1(304.65,66.5) 304.68,66.47 RPE11.3
  TOP w0.107: v1(303.16,73.13) UE1.K3
  IN1 w0.089: v1(304.65,66.5) 304.65,67.44 303.1,68.99 303.1,70.92 302.65,71.38 302.65,72.6 303.16,73.11 v1(303.16,73.13)
  IN3 w0.122: v1(41.38,67.19) 43.06,68.86 43.06,72.05 47.1,76.1 48.27,76.1 54.06,81.88 54.79,81.88 59.92,87.01 62.03,87.01 65.28,90.26 67.51,90.26 68.2,90.95 71.57,90.95 72.53,89.98 86.89,89.98 88.71,88.16 92.11,88.16 95.74,91.79 100.18,91.79 100.41,91.56 118.8,91.56 121.95,88.41 126.43,88.41 127.96,89.93 133.32,89.93 134.34,90.95 138.35,90.95 138.85,90.45 150.62,90.45 157.38,83.69 157.38,75.76 159.31,73.83 159.31,69.01 161.78,66.54 161.78,61.84 181.82,41.8 182.62,41.8 184.43,39.99 185.54,39.99 186.21,39.32 186.21,38.07 186.73,37.55 188.2,37.55 188.71,37.03 191.74,37.03 199.6,29.17 199.63,29.17 199.88,28.92 202.56,28.92 204.91,26.58 206.93,26.58 208.95,24.55 209.55,24.55 210.9,23.2 212.76,23.2 213.33,22.64 218.11,22.64 218.67,23.2 221.19,23.2 222.7,21.69 224.33,21.69 225.27,20.74 229.91,20.74 232.05,22.88 239.48,22.88 244.35,27.75 248.13,27.75 249.63,29.25 252.78,29.25 253.21,29.68 258.67,29.68 260.08,31.08 277.96,31.08 281.36,34.49 281.74,34.49 283.54,36.29 283.54,39.11 284.07,39.64 285.7,39.64 286.98,40.91 286.98,43.17 289.6,45.79 291.42,45.79 292.25,46.63 292.25,47.52 292.02,47.75 292.02,48.32 295.04,51.34 295.04,51.82 295.36,52.14 295.36,53.03 295.72,53.39 296.41,53.39 298.25,55.24 298.25,59.91 299.87,61.53 299.87,62.59 300.21,62.93 300.21,64.43 300.82,65.04 300.82,69.03 300.08,69.77 300.08,70.91 301.05,71.87 301.91,71.87 v1(303.16,73.13)
  IN4 w0.089: v1(41.38,67.19) 40.63,66.44 v1(29.34,66.44)
  BOTTOM w0.102: v1(23.02,73.81) 23.19,73.63 23.64,73.63 24.52,72.76 26.83,72.76 27.26,72.33 27.26,68.52 v2(28.5,67.28) v1(29.34,66.44)
USB_PWR_EN2#: length 320.4
  TOP w0.102: v1(299.96,74.73) UE1.G5 ; RPE11.1 305.68,66.12 305.88,66.32 v1(305.88,66.54) v2(305.88,67.27)
  IN1 w0.089: v1(305.88,66.54) 305.8,66.54 305.67,66.41 305.67,66.41 305.45,66.19 305.35,66.19 305.05,65.9 304.18,65.9 302.5,67.57 302.5,70.87 301.07,72.3 301.07,73.72 300.07,74.73 v1(299.96,74.73)
  IN3 w0.122: v1(88.91,88.6) 89.04,88.74 92.38,88.74 95.65,92.01 118.66,92.01 122.04,88.63 126.34,88.63 129.15,91.44 138.33,91.44 139.05,90.72 151.24,90.72 160.08,81.88 160.08,69.39 162.31,67.15 162.31,61.94 181.64,42.61 184.87,42.61 188.38,39.1 188.38,38.12 188.9,37.6 191.81,37.6 199.79,29.61 200.13,29.61 200.28,29.46 202.66,29.46 205.09,27.02 207.11,27.02 209.07,25.06 210.05,25.06 211.46,23.65 212.74,23.65 213.24,24.15 215.78,24.15 216.1,23.83 221.19,23.83 222.81,22.21 230.27,22.21 231.61,23.55 239.14,23.55 244.05,28.47 247.89,28.47 249.35,29.92 252.5,29.92 252.95,30.37 257.88,30.37 259.3,31.79 277.47,31.79 280.88,35.2 281.5,35.2 282.86,36.56 282.86,39.38 283.83,40.34 284.52,40.34 286.31,42.13 286.31,43.45 289.57,46.71 289.57,47.79 290.69,48.91 291.66,48.91 294.37,51.62 294.37,52.1 294.69,52.42 294.69,53.31 294.83,53.46 294.83,54.97 295.71,55.85 296.28,55.85 296.89,56.46 296.89,59.44 296.72,59.61 296.72,61.03 298.33,62.63 299.39,62.63 299.93,63.16 299.93,64.56 300.54,65.17 300.54,68.9 299.7,69.74 299.7,71.02 300.46,71.77 300.46,74.22 v1(299.96,74.73)
  BOTTOM w0.102: UI2.4 84.56,99.51 85.22,98.85 85.22,92.28 v1(88.91,88.6)
USBCOMP: length 4.7
  TOP w0.102: RC44.1 130.81,58.59 v2(131.53,58.59) 133.93,58.59 v1(134.38,58.14)
  BOTTOM w0.102: UC1.AB6 134.74,58.5 v1(134.38,58.14)
USH_DET#: length 134.2
  TOP w0.102: v1(220.52,29.21) v2(220.52,28.44) 220.52,27.36 221.49,26.38 221.49,23.7 220.85,23.06 220.15,23.06 DZ7.2 219.61,22.25 LE1.1 ; UE1.C13 297.16,81.93 v1(297.55,82.32)
  IN3 w0.122: v1(220.52,29.21) 220.52,29.47 221.17,30.12 223.97,30.12 225.57,28.52 227.61,28.52 228.03,28.94 236.98,28.94 241.43,33.39 246.54,33.39 247.97,34.83 256.63,34.83 258.3,36.49 267.24,36.49 269.69,38.94 272.94,38.94 275.34,41.34 275.34,42.36 280.34,47.36 280.34,48.87 284.31,52.83 284.31,53.71 285.94,55.34 286.21,55.34 287.05,56.18 287.05,57.94 286.59,58.4 286.59,60.11 286.48,60.23 286.48,62.08 285.68,62.88 285.68,65.29 287.13,66.73 287.13,68.17 287.57,68.62 287.57,71.84 289.78,74.05 289.78,74.78 290.23,75.22 290.23,77.64 290.56,77.97 291.27,77.97 293,79.7 294.07,79.7 295.79,81.43 296.66,81.43 v1(297.55,82.32)
  BOTTOM w0.102: v1(297.55,82.32) 300.23,85 300.23,89.05 299.33,89.95 RE526.1
USH_DET#_L: length 5.2
  TOP w0.102: JUSH1.26 222.51,19.65 222.23,19.93 222.23,20.38 LE1.2 221.23,21.88 221.31,21.96 DZ7.1 221.31,22.98 v2(221.91,23.58)
USH_EXPANDER_SMBCLK: length 147.3
  TOP w0.102: v1(295.96,73.13) UE1.B3 ; JUSH1.11 222.7,12.15 222.56,12.29 222.4,12.29 222.23,12.12 222.23,11.35 221.84,10.97 221.59,10.97 CZ62.1 220.52,10.97 219.31,10.97 RZ8.2 218.27,10.94 217.61,10.94 217.43,10.76 217.43,9.75 218.32,8.86 218.32,6.26 219.19,5.39 223.11,5.39 227.45,9.73 227.45,17.66 223.87,21.25 223.87,24.93 223.28,25.52 223.28,28.01 v1(223.09,28.2)
  IN2 w0.122: v1(295.96,73.13) 297.04,72.05 297.04,71.68 295.81,70.45 295.81,68.25 296.47,67.58 296.47,65.73 295.38,64.64 295.38,60.34 294.88,59.84 294.88,57.82 292.64,55.58 292.64,53.54 290.62,51.53 288.14,51.53 286.57,49.95 286.26,49.95 284.19,47.89 282.73,47.89 281.31,46.47 280.52,46.47 278.42,44.36 277.19,44.36 276.13,43.3 276.13,43.04 272.37,39.29 269.52,39.29 267.11,36.87 260.05,36.87 258.48,35.3 255.94,35.3 255.03,34.39 248.04,34.39 246.41,32.76 241.69,32.76 239.68,30.75 229.93,30.75 229.29,30.11 224.68,30.11 223.25,28.68 223.25,28.36 v1(223.09,28.2)
USH_EXPANDER_SMBDAT: length 150.1
  TOP w0.102: UE1.E5 298.76,75.1 v1(298.36,74.7) ; JUSH1.12 222.75,12.65 222.61,12.51 222.31,12.51 222,12.21 222,11.45 221.75,11.19 221.57,11.19 CZ63.1 220.56,11.2 219.28,11.2 RZ9.2 218.24,11.17 217.52,11.17 217.2,10.85 217.2,9.65 218.09,8.76 218.09,6.16 219.1,5.16 v4(219.63,5.16) 223.21,5.16 227.68,9.64 227.68,17.76 224.1,21.34 224.1,25.03 223.51,25.61 223.51,28.04 v1(223.67,28.2)
  IN2 w0.122: v1(298.36,74.7) 298.21,74.7 297.97,74.46 297.97,72.91 297.29,72.23 297.29,71.58 296.07,70.36 296.07,68.34 296.7,67.71 296.7,65.6 295.61,64.51 295.61,60.21 295.13,59.74 295.13,57.72 292.89,55.47 292.89,53.44 290.73,51.28 288.25,51.28 286.67,49.71 286.34,49.71 284.28,47.64 282.83,47.64 281.41,46.22 280.63,46.22 278.52,44.11 277.29,44.11 276.38,43.2 276.38,42.94 272.48,39.04 269.66,39.04 267.24,36.62 260.15,36.62 258.58,35.05 256.04,35.05 255.13,34.14 248.14,34.14 246.51,32.51 241.79,32.51 239.79,30.5 230.03,30.5 229.39,29.86 224.79,29.86 223.5,28.58 223.5,28.38 v1(223.67,28.2)
USH_PWR_STATE#: length 125.8
  TOP w0.102: UE1.H2 301.56,72.33 301.56,70.57 v2(301.7,70.43) 301.85,70.28 v1(301.85,69.95) ; RZ10.2 221.75,20.01 221.75,19.75 v1(222,19.5) 222,18.18 222.53,17.65 JUSH1.22
  IN1 w0.089: v1(222,19.5) 222.18,19.5 222.64,19.96 228.71,19.96 233.07,24.32 238.38,24.32 240.55,26.5 250.18,26.5 254.63,30.96 258.03,30.96 258.76,31.68 283.32,31.68 285.83,34.18 285.83,35.12 288.35,37.65 288.35,38.26 289.58,39.49 290.35,40.26 291.22,40.26 291.74,40.78 291.74,41.38 292.59,42.24 292.59,43.35 293.96,44.72 294.31,44.72 294.63,44.41 295.48,44.41 295.72,44.65 296.85,44.65 297.07,44.87 297.07,47.04 297.75,47.72 297.75,48.39 299.06,49.69 300.56,49.69 301.59,50.72 301.59,53.66 302.1,54.17 302.1,62.34 303.64,63.87 303.64,64.9 303.32,65.22 301.45,65.22 300.91,65.77 300.91,69 v1(301.85,69.95)
USH_RST#_R: length 3.5
  TOP w0.102: RZ114.2 221.62,19.02 221.62,18.1 222.57,17.15 JUSH1.21
VCI_IN1#: length 6.8
  TOP w0.102: UE1.B5 296.17,75.13 295.73,74.69 295.24,74.69 294.59,74.04 293.96,74.04 v2(293.57,74.44) 292.77,74.44 291.94,75.27 290.77,75.27 RE507.1
VCI_IN2#: length 17.6
  TOP w0.102: RE508.1 286.75,69.18 v1(286.64,69.18) v2(286.22,68.76) ; v1(297.56,73.93) UE1.D4
  BOTTOM w0.102: v1(286.64,69.18) 286.64,71.54 287.91,72.81 292.99,72.81 294.01,71.8 296.17,71.8 297.17,72.8 297.17,73.53 v1(297.56,73.93)
VCT_LAN_R1: length 2.3
  TOP w0.102: RL3.1 282.96,85.42 v2(282.45,85.42) UL1.6
VGA_IDENTIFY: length 22.1
  TOP w0.102: v1(304.87,88.92) 304.87,89.62 304.49,90 302.96,90 302.58,90.38 302.58,91.07 v2(302.14,91.51) 300.86,92.78 RE84.1 RE85.1
  TOP w0.107: v1(303.96,78.73) UE1.L9
  BOTTOM w0.102: v1(303.96,78.73) 303.96,78.93 304.88,79.85 304.88,83.61 306.25,84.98 306.66,84.98 307.15,85.48 307.15,86.63 307.41,86.89 307.41,88.28 307.18,88.51 306.25,88.51 306.24,88.51 305.91,88.51 305.9,88.51 305.27,88.51 v1(304.87,88.92)
VID0_PRIM_CORE: length 11.2
  TOP w0.102: v2(124.49,115.97) PR420.1
  TOP w0.254: v1(126.2,114.4) 125.93,114.14 PR408.2 PR418.2 124.51,114.97 PR420.1 ; PU402.9 131.58,114.01 131.76,114.18 132.29,114.18 v1(132.32,114.16)
  IN1 w0.254: v1(126.2,114.4) 126.2,114.37 126.41,114.15 130.31,114.15 130.51,113.95 132.1,113.95 v1(132.32,114.16)
VID0_VCCIO: length 5.7
  TOP w0.254: PR414.2 144.28,113.73 PR416.1 142.88,113.91 142.5,113.91 142.31,113.72 v2(142.31,112.35) 142.31,112.04 141.98,111.72 PU401.9
VID1_PRIM_CORE: length 15.4
  TOP w0.102: v1(121.99,114.14) v2(121.48,114.14)
  TOP w0.254: v1(121.99,114.14) PR411.2 122.77,114.14 PR417.2 123.67,114.17 PR419.1 ; v1(132.49,113.51) 132.8,113.51 133.05,113.27 133.05,113.02 132.87,112.84 PU402.8
  IN1 w0.254: v1(132.49,113.51) 130.33,113.51 130.1,113.74 122.38,113.74 v1(121.99,114.14)
VID1_VCCIO: length 4
  TOP w0.254: PU401.8 142.81,110.51 143.47,110.51 143.81,110.85 v2(143.81,111.19) 143.81,111.59 143.41,111.98 PR415.1 144.02,112.57 PR413.2
VIDALERT_N: length 79.4
  TOP w0.102: PR625.1 v1(75.44,49.92)
  IN2 w0.122: v1(99.7,76.09) 97.03,78.76 91,78.76 89.79,79.96 82.99,79.96 75.63,72.61 75.63,55.58 76.52,54.7 80.21,54.7 80.33,54.57 80.33,50.04 80.21,49.92 79.82,49.92 79.7,50.04 79.7,53.93 79.57,54.06 79.33,54.06 79.21,53.93 79.21,50.04 79.09,49.92 78.84,49.92 78.72,50.04 78.72,53.93 78.6,54.06 78.35,54.06 78.23,53.93 78.23,50.04 78.11,49.92 v1(75.44,49.92)
  BOTTOM w0.102: RC153.2 99.73,76.07 v1(99.7,76.09) RC152.1 ; PR604.2 v1(75.44,49.92)
VIDALERT_N_B: length 2.5
  TOP w0.102: PR625.2 72.69,49.92 72.22,50.38 PU602.36
VIDSCLK: length 91.9
  TOP w0.102: PR618.1 v1(75.44,50.82)
  IN2 w0.122: v1(75.44,50.82) 76.37,50.82 76.49,50.94 76.49,53.43 76.61,53.55 76.86,53.55 76.98,53.43 76.98,50.94 77.1,50.82 77.61,50.82 77.73,50.94 77.73,53.81 77.34,54.19 75.98,54.19 75.13,55.04 75.13,72.82 82.85,80.54 90.24,80.54 91.38,79.39 92.03,79.39 92.15,79.51 92.15,80.73 92.27,80.85 92.52,80.85 92.64,80.73 92.64,79.51 92.76,79.39 93,79.39 93.13,79.51 93.13,80.8 93.25,80.92 93.49,80.92 93.61,80.8 93.61,79.51 93.74,79.39 93.98,79.39 94.1,79.51 94.1,80.8 94.22,80.92 94.47,80.92 94.59,80.8 94.59,79.51 94.71,79.39 94.96,79.39 95.08,79.51 95.08,80.48 95.2,80.6 95.44,80.6 95.56,80.48 95.56,79.51 95.69,79.39 95.93,79.39 96.05,79.51 96.05,80.12 96.17,80.25 96.42,80.25 96.54,80.12 96.54,79.51 96.66,79.39 96.91,79.39 97.03,79.51 97.03,80.12 97.15,80.25 97.39,80.25 97.52,80.12 97.52,79.51 97.64,79.39 98.05,79.39 99.19,78.25 99.19,77.62 100.21,76.6 100.21,74.9 v1(100.04,74.73)
  BOTTOM w0.076: UC1.A63 101.57,69.85 101.57,70.13 101.35,70.35 101.35,70.55 101.49,70.69 101.69,70.69 101.83,70.84 101.83,71.24 100.72,72.36 100.72,72.65 100.47,72.9
  BOTTOM w0.102: CC321.1 100.54,75.46 100.04,74.96 v1(100.04,74.73) 100.04,74.4 100.21,74.23 100.43,74.23 100.55,74.35 100.55,74.91 100.62,74.98 100.85,74.98 100.95,74.88 100.95,74.21 100.52,73.77 100.17,73.77 v2(99.51,74.43) 99.51,74.9 99.4,75.01 98.92,75.01 98.83,74.91 98.83,74.54 100.47,72.9 ; v1(75.44,50.82) 75.4,50.78 PR601.2
VIDSCLK_B: length 2.5
  TOP w0.102: PU602.37 72.33,50.78 72.37,50.82 PR618.2
VIDSOUT: length 91.9
  TOP w0.102: PR626.1 v1(75.44,49.04)
  IN2 w0.122: v1(98.42,76.09) 96.32,78.19 90.68,78.19 89.54,79.33 83.06,79.33 76.14,72.41 76.14,55.83 76.78,55.2 80.65,55.2 80.84,55.01 80.84,49.8 80.47,49.43 80.47,47.42 80.35,47.3 80.1,47.3 79.98,47.42 79.98,49.29 79.86,49.41 79.62,49.41 79.49,49.29 79.49,47.42 79.37,47.3 79.13,47.3 79.01,47.42 79.01,49.29 78.88,49.41 78.64,49.41 78.52,49.29 78.52,47.42 78.4,47.3 78.16,47.3 78.04,47.42 78.04,49.29 77.92,49.41 77.66,49.41 77.54,49.29 77.54,47.42 77.42,47.3 77.18,47.3 77.05,47.42 77.05,48.6 76.93,48.72 76.69,48.72 76.57,48.6 76.57,47.67 76.45,47.55 75.66,47.55 75.44,47.76 v1(75.44,49.04)
  BOTTOM w0.076: UC1.D64 101.16,68.33 101.46,68.62 101.46,68.86 101.24,69.08 101.24,69.99 101.02,70.21 101.02,71.5 100.96,71.56 100.83,71.56 100.63,71.36 100.5,71.36 100.41,71.45 100.41,71.57 100.62,71.78 100.62,71.9 100.53,71.99 100.4,71.99 100.28,71.87 100.16,71.87 100.07,71.96 100.07,72.09 100.19,72.21 100.19,72.33 100.02,72.5 100.02,72.72 99.75,72.99
  BOTTOM w0.102: v1(75.44,49.04) 75.43,49.03 PR605.2 ; 99.75,72.99 99.45,73.3 97.64,73.3 97.1,73.83 97.1,74.17 98.31,75.38 98.31,75.98 v1(98.42,76.09) 98.42,76.15 98.68,76.41 RC157.1
VIDSOUT_B: length 2.5
  TOP w0.102: PU602.35 72.1,49.98 v2(72.37,49.71) 73.04,49.04 PR626.2
VRALERT#: length 35.3
  TOP w0.102: RC73.1 152.02,33.93 v1(152.02,34.56) 151.82,34.77 v2(151.39,34.77)
  IN2 w0.122: v1(152.02,34.56) 150.22,36.37 150.22,38.63 143.31,45.54 143.31,46.96 141.2,49.07 141.2,50.34 140.58,50.97 140.58,51.29 140.25,51.62 137.6,51.62 136.1,53.12 135.08,53.12 134.15,54.06 131.69,54.06 v1(130.66,53.03)
  BOTTOM w0.076: v1(130.66,53.03) 131.09,53.45 UC1.AM11
VSA_SEN+: length 125.2
  TOP w0.254: v1(122.18,79.65) 122.43,79.9 RC168.2
  IN1 w0.254: v1(126.12,65.31) 125.64,64.83 124.77,64.83 124.62,64.98 122.9,64.98 122.23,65.65 122.23,67.49 122.85,68.11 122.85,69.09 121.35,70.59 121.35,71.1 v1(121.79,71.54)
  IN3 w0.203: v1(122.18,79.65) 122.53,80 123.55,80 124.05,80.5 124.05,83.26 123.04,84.27 119.84,84.27 119.05,85.06 117.73,85.06 117.12,84.45 113.01,84.45 112.5,83.94 110.24,83.94 108.49,85.69 105.06,85.69 104.65,85.29 104.65,84.5 103.97,83.81 101.12,83.81 100.97,83.97 98.39,83.97 97.81,83.38 93.38,83.38 93.05,83.71 87.87,83.71 v1(87.75,83.59)
  IN4 w0.203: v1(87.75,83.59) 87.57,83.76 87.38,83.76 87.1,83.48 87.1,79.72 91.37,75.46 91.37,71.21 88.4,68.24 88.4,66.85 87.13,65.58 85.93,65.58 84.23,63.87 84.23,60.98 81.72,58.46 81.72,56.08 78.52,52.88 75.46,52.88 74.74,52.16 74.74,48.57 71.56,45.38 69.02,45.38 68.92,45.48 v1(68.46,45.48)
  BOTTOM w0.203: PC650.1 68.82,43.86 PC652.1 PC640.2 ; PC650.1 68.02,44.71 PR649.2 ; PC650.1 68.82,45.12 v1(68.46,45.48)
  BOTTOM w0.254: v1(122.18,79.65) 122.56,79.27 v2(122.56,77.45) 122.56,76.09 121.01,74.54 121.01,72.05 121.51,71.54 v1(121.79,71.54) ; UC1.H20 126.39,65.04 v1(126.12,65.31)
VSA_SEN-: length 125.2
  TOP w0.203: PU602.26 68.96,46.11 v1(68.84,45.99)
  TOP w0.254: RC166.1 121.67,79.89 121.67,79.39 v1(122.05,79.01)
  IN1 w0.254: v1(121.81,70.82) 121.84,70.82 123.35,69.3 123.35,67.9 122.74,67.28 122.74,65.9 123.16,65.49 125.01,65.49 v1(125.2,65.29)
  IN3 w0.203: v1(87.75,84.18) 87.91,84.02 93.17,84.02 93.5,83.69 97.68,83.69 98.28,84.28 101.1,84.28 101.26,84.12 103.84,84.12 104.35,84.63 104.35,85.41 104.93,86 108.62,86 110.37,84.24 112.38,84.24 112.91,84.78 117.02,84.78 117.61,85.36 119.18,85.36 119.97,84.57 123.17,84.57 124.35,83.39 124.35,80.02 123.35,79.01 v1(122.05,79.01)
  IN4 w0.203: v1(68.84,45.99) 69.14,45.69 71.43,45.69 74.43,48.68 74.43,52.28 75.33,53.18 78.39,53.18 81.41,56.2 81.41,58.59 83.93,61.1 83.93,64 85.81,65.88 87,65.88 88.09,66.97 88.09,68.37 91.06,71.34 91.06,75.33 86.8,79.6 86.8,83.61 87.27,84.08 87.65,84.08 v1(87.75,84.18)
  BOTTOM w0.203: v1(68.84,45.99) 69.73,45.1 PC650.2 69.73,43.83 PC649.1
  BOTTOM w0.254: v1(122.05,79.01) 122.05,76.22 v2(121.25,75.42) 120.53,74.7 120.53,72.02 121.74,70.82 v1(121.81,70.82) ; v1(125.2,65.29) 125.46,65.04 UC1.H21
VSET_5105: length 8.2
  TOP w0.102: RE77.1 293.91,82.57 v2(294.23,82.89)
  TOP w0.112: RE77.1 CE38.1 294.24,81.68 v1(294.85,81.07) ; v1(296.76,78.73) UE1.C9
  IN2 w0.122: v1(294.85,81.07) 294.85,79.27 295.39,78.73 v1(296.76,78.73)
VSYNC_CONN: length 5.2
  TOP w0.102: RV121.1 RV651.2 CV132.1 319.17,76.36 v2(319.22,76.31) JCRT1.14
VSYNC_CRT: length 71.7
  TOP w0.102: RV651.1 316.62,75.08 v1(316.36,74.82) ; UV6.18 280.6,54.07 v1(280.67,54)
  IN2 w0.122: v1(280.67,54) 280.73,54 283.27,56.53 283.27,57.42 283.95,58.1 283.95,65 282.94,66.01 282.03,66.01 280.61,67.44 280.61,68.94 283.71,72.04 283.71,72.63 284.4,73.32 285.15,73.32 287.66,75.83 287.66,78.28 288.57,79.19 290.33,79.19 292.35,81.21 292.35,82.5 293.97,84.12 297.67,84.12 298.43,84.88 300.75,84.88 301.12,84.5 311.38,84.5 312.73,83.15 312.73,82.1 313.68,81.15 313.68,77.51 v1(316.36,74.82)
WIGIG_32KHZ: length 11.6
  TOP w0.102: RZ56.1 198.23,13.38 v2(200.08,13.38) 200.08,13.18 200.89,12.37 204.72,12.37 205.29,12.94 v1(206.01,12.94)
  BOTTOM w0.102: JNGFF1.50 207.44,12.5 207.44,12.5 207,12.94 v1(206.01,12.94)
WLAN_COEX1: length 114
  TOP w0.102: RZ130.2 303.08,45.97 303.08,45.68 v1(303.17,45.59) 303.19,45.56 303.36,45.56 303.69,45.23 v2(304.6,45.23)
  IN1 w0.089: v1(303.17,45.59) 303.17,45.65 302.77,46.04 301.97,46.04 301.16,45.23 300.77,45.23 299.59,44.06 299.59,43.02 298.59,42.01 296.8,42.01 294.16,39.37 294.16,38.69 291.01,35.54 290.21,35.54 287.77,33.1 287.77,31.06 285.25,28.54 259.43,28.54 255.96,25.07 254.11,25.07 251.85,22.82 246.11,22.82 244.77,21.48 233.41,21.48 231.9,19.97 231.9,19.97 227.96,16.02 222.69,16.02 222.61,16.1 218.59,16.1 218.35,15.86 211.45,15.86 v1(211.26,15.66)
  BOTTOM w0.102: v1(211.26,15.66) 211.62,15.3 211.62,14.67 209.95,13 JNGFF1.48
WLAN_COEX2: length 111.9
  TOP w0.102: RZ129.2 302.59,45.82 v1(302.59,45.5) 303.01,45.08 v2(303.2,45.08)
  IN1 w0.089: v1(210.65,14.83) 211.08,14.39 211.51,14.39 212.59,15.48 218.51,15.48 218.75,15.72 222.45,15.72 222.54,15.64 228.11,15.64 233.42,20.94 244.77,20.94 246.27,22.44 252.08,22.44 254.32,24.68 256.99,24.68 260.44,28.14 285.4,28.14 288.16,30.9 288.16,32.95 290.37,35.16 291.17,35.16 294.61,38.6 294.95,38.6 295.21,38.85 295.21,39.88 296.96,41.63 298.77,41.63 299.98,42.84 299.98,43.88 300.92,44.82 301.3,44.82 301.65,45.17 302.32,45.17 302.59,45.44 v1(302.59,45.5)
  BOTTOM w0.102: v1(210.65,14.83) 210.65,14.29 209.85,13.5 JNGFF1.46
WLAN_COEX3: length 110.7
  TOP w0.102: RZ128.2 302,45.71 v1(302,45.54) 301.78,45.33 v2(301.78,45.03)
  IN1 w0.089: v1(210.65,15.67) 211.03,15.28 212.1,15.28 212.48,15.67 218.43,15.67 218.67,15.91 222.53,15.91 222.62,15.83 228.04,15.83 232.09,19.89 233.49,21.29 244.85,21.29 246.19,22.63 251.97,22.63 254.21,24.87 256.03,24.87 259.5,28.34 285.32,28.34 287.96,30.98 287.96,33.02 290.29,35.35 291.09,35.35 294.35,38.61 294.35,39.29 296.88,41.82 298.68,41.82 299.78,42.93 299.78,43.97 300.84,45.03 301.24,45.03 301.75,45.54 v1(302,45.54)
  BOTTOM w0.102: JNGFF1.44 209.77,14 210.22,14.45 210.22,15.23 v1(210.65,15.67)
WLAN_PWR_EN: length 13.1
  TOP w0.203: UZ4.5 190.23,16.13 190.15,16.05 189.29,16.05 RZ38.2
  TOP w0.254: RZ70.2 RZ71.2 181.41,14.06 v2(181.82,13.66) 183.22,13.66 183.35,13.52 DZ9.1 184,13.86 185.24,15.09 185.24,15.73 185.53,16.02 188.24,16.02 RZ38.2
WLAN_WIGIG60GHZ_DIS#: length 160.5
  TOP w0.102: RE8.1 304.81,83.36 303.87,82.42 303.87,81.83 UE1.L13 303.38,81.7 v1(303.38,82.42) ; DZ1.1 216.58,9.38 217.52,8.44 v2(217.52,6.16) 217.52,5.84 218.68,4.67 223.43,4.67 228.45,9.7 228.45,17.72 224.58,21.6 224.58,24.44 224.73,24.59 224.73,26.75 224.58,26.9 224.58,29.14 224.86,29.42 v1(225.56,29.42)
  IN3 w0.122: v1(225.56,29.42) 226,28.97 227.37,28.97 227.78,29.39 236.36,29.39 240.87,33.9 246.33,33.9 247.74,35.31 256.43,35.31 258.18,37.06 267.07,37.06 269.45,39.44 272.67,39.44 274.3,41.06 274.3,43.42 275.09,44.21 276.49,44.21 279.88,47.61 279.88,49.04 283.84,52.99 283.84,53.87 285.72,55.76 285.72,58.54 285.4,58.87 285.4,59.94 286.03,60.57 286.03,61.9 285.17,62.76 285.17,65.41 285.95,66.19 285.95,67.63 287.13,68.8 287.13,69.54 286.87,69.79 286.87,74.36 287.96,75.46 287.96,77.53 288.36,77.93 288.99,77.93 289.67,78.61 290.87,78.61 295.82,83.56 297.95,83.56 298.66,84.27 301.53,84.27 v1(303.38,82.42)
WLAN_WIGIG60GHZ_DIS#_R: length 6.7
  TOP w0.102: v1(212.37,10.46) 213.26,9.57 v2(213.8,9.57) 214.68,9.57 DZ1.2
  BOTTOM w0.102: JNGFF1.56 208.83,11 210.38,11 210.93,10.46 v1(212.37,10.46)
WWAN_COEX1: length 4
  TOP w0.102: v2(303.08,47.91) 302.86,47.91 302.55,47.6 v1(302.55,47.33) 302.84,47.04 RZ130.1
  BOTTOM w0.102: JNGFF2.64 302.55,48.86 302.93,48.48 302.93,47.7 v1(302.55,47.33)
WWAN_COEX2: length 3.2
  TOP w0.102: v2(301.78,48.2) 302.05,47.93 v1(302.05,47.77) 302.05,46.94 RZ129.1
  BOTTOM w0.102: JNGFF2.62 v1(302.05,47.77)
WWAN_COEX3: length 3.8
  TOP w0.102: RZ128.1 v1(301.57,47.33) 301.25,47.64 300.65,47.64 v2(300.62,47.67)
  BOTTOM w0.102: JNGFF2.60 301.55,47.34 v1(301.57,47.33)
WWAN_PWR_EN: length 4.5
  TOP w0.102: CZ198.1 RZ43.1 290.35,50.51 290.05,50.21 v2(289.45,50.21) 288.57,50.21 v1(288.27,50.5)
  BOTTOM w0.102: v1(288.27,50.5) 288.05,50.28 JNGFF2.6
WWAN_RADIO_DIS#: length 60.6
  TOP w0.102: DZ5.1 292.83,48.14 v1(292.66,47.97)
  TOP w0.107: RE10.1 299.93,83.2 v1(299.96,83.2) 299.96,81.13 UE1.F12
  IN2 w0.122: v1(300.33,48.3) 300.33,48.71 300.66,49.05 302.1,49.05 303.03,49.97 304.85,49.97 308.43,53.55 308.43,58.06 310.37,60 310.37,64.41 308.89,65.9 308.89,67.18 307.07,69 307.07,71.74 306.74,72.08 306.15,72.08 305.74,72.48 305.74,73.6 305.46,73.89 305.46,74.52 305.25,74.73 305.25,75.01 304.34,75.93 302.87,75.93 302.76,76.04 302.76,77.06 302.28,77.54 301.4,77.54 301.11,77.82 301.11,79.86 301.2,79.95 301.2,81.93 299.96,83.17 v1(299.96,83.2)
  BOTTOM w0.102: v1(300.33,48.3) 300.33,47.93 299.57,47.16 298.25,47.16 297.82,47.59 293.05,47.59 v1(292.66,47.97)
WWAN_RADIO_DIS#_R: length 8.4
  TOP w0.102: DZ5.2 292.22,50.87 v1(292.08,50.73)
  BOTTOM w0.102: v2(293.68,51.72) 293.68,51.41 292.99,50.73 v1(292.08,50.73) 291.43,50.73 289.11,48.41 288.73,48.41 288.55,48.58 JNGFF2.8
WWAN_WAKE#: length 102.2
  TOP w0.102: v1(285.55,40.82) 285.55,41.08 286.03,41.56 291.05,41.56 291.84,40.77 v1(292.77,40.77) ; UE1.M13 304.36,82 v1(305.71,83.34) 305.71,84.13 RE38.1
  IN4 w0.089: v1(285.55,40.82) 287.2,40.82 289.26,42.88 289.26,43.33 290.09,44.17 293.69,44.17 294.03,43.83 298.99,43.83 300.06,42.75 303.15,42.75 303.85,43.45 306.43,43.45 308.14,45.16 308.14,52.63 308.17,52.66 308.17,56.96 312,60.79 314.08,60.79 315.85,62.57 316.64,62.57 319.77,65.69 319.77,81.35 314.69,86.43 v1(314.69,87.01)
  BOTTOM w0.102: JNGFF2.23 292.3,41.02 292.56,40.77 v1(292.77,40.77) ; v1(314.69,87.01) 313.16,88.54 v2(312.65,88.54) 309.5,88.54 309.15,88.18 309.15,85.55 306.94,83.34 v1(305.71,83.34)
XCLK_BIASREF: length 20.3
  TOP w0.102: RC324.1 112.97,67.24 112.48,67.72 112.2,67.72 111.7,68.22 v2(110.43,68.22)
  TOP w0.254: RC324.1 114.21,67.24 v1(114.22,67.23) ; RC52.1 123.92,61.47 v1(123.9,61.5)
  IN1 w0.254: v1(123.9,61.5) 123.9,62.08 123.45,62.53 119.44,62.53 119.28,62.68 117.76,62.68 117.56,62.88 117.56,63.21 116.51,64.25 116.51,64.92 116.03,65.4 113.97,65.4 113.67,65.7 113.67,66.92 113.98,67.23 v1(114.22,67.23)
  BOTTOM w0.254: UC1.E42 114.01,67.23 v1(114.22,67.23)
XDP_DBRESET#: length 203.6
  TOP w0.102: v1(55.47,27.59) v2(59.28,27.59) RC137.1 CC32.1 63.95,27.66 JXDP1.48
  IN2 w0.122: v1(149.92,87.8) 148.87,88.84 145.78,88.84 145.04,89.58 142.93,89.58 142.47,89.12 138.77,89.12 138.16,88.52 133.06,88.52 132.57,88.03 130.41,88.03 130.35,88.08 126.03,88.08 125.83,88.28 119.95,88.28 119.56,88.66 109.65,88.66 109.41,88.42 104.69,88.42 104.19,88.93 102.81,88.93 102.42,89.32 99.4,89.32 98.67,88.6 91.76,88.6 90.43,89.93 88.09,89.93 86.95,91.08 68.27,91.08 67.72,90.53 65.28,90.53 62.69,87.95 61.32,87.95 58.69,85.31 58.02,85.31 54.85,82.14 54.49,82.14 48.82,76.47 46.66,76.47 34.85,64.66 34.85,62.72 29.77,57.65 29.77,53.76 27.64,51.63 27.64,50.12 28.33,49.44 28.33,48.16 29.41,47.08 29.41,41.86 32.26,39.01 37.03,39.01 46.55,29.48 50.23,29.48 50.93,28.78 54.27,28.78 v1(55.47,27.59)
  BOTTOM w0.102: v1(149.92,87.8) 150.2,88.08 RC290.1 150.2,88.58 149.66,89.12 149.12,89.12 148.87,89.38 148.87,90.45 149.32,90.9 UC12.1
XDP_JTAGX: length 10.7
  BOTTOM w0.076: UC1.A59 104.05,69.87 104.05,71.66 103.45,72.26 103.45,73.76 103.13,74.08 103.13,74.1 103.11,74.12
  BOTTOM w0.102: 103.11,74.12 v2(103.11,74.19) 103.11,74.57 102.75,74.93 CC305.1 103.26,75.95 103.26,77.23 RC328.2 102.49,78.23 RC87.1
XDP_OBS0: length 3.9
  TOP w0.102: v2(72.19,38.26) 72.09,38.36 RC239.2 71.05,38.36 70.45,37.76 JXDP1.21
XDP_OBS0_R: length 75.1
  TOP w0.102: RC239.1 70.64,39.88 70.64,41.14 69.91,41.87 66.76,41.87 63.96,44.67 62.06,44.67 v1(62.04,44.66)
  IN1 w0.089: v1(62.04,44.66) 62.04,45.87 64.9,48.72 66.44,48.72 67.25,47.91 72.09,47.91 74.16,49.98 74.16,51.82 75.48,53.14 78.69,53.14 84.37,58.83 84.37,60.86 86.34,62.83 88.4,62.83 89.39,63.82 89.39,66.67 92.4,69.68 95.13,69.68 95.38,69.93 98.43,69.93 98.95,69.41 104.85,69.41 v1(106.21,70.77)
  BOTTOM w0.076: v1(106.21,70.77) 105.95,70.51 105.95,70.07 106.01,70.01 106.01,68.85 UC1.C55
XDP_OBS1: length 4.7
  TOP w0.102: v2(69.7,40.23) 69.7,38.89 RC240.2 69.95,38.07 JXDP1.23
XDP_OBS1_R: length 73.9
  TOP w0.102: RC240.1 70.24,40.28 69.13,41.39 66.67,41.39 64.04,44.02 v2(62.87,44.02) v1(62.04,44.02)
  IN1 w0.089: v1(62.04,44.02) 62.49,44.47 62.49,45.74 65.03,48.28 66.32,48.28 67.09,47.52 72.25,47.52 74.55,49.82 74.55,51.64 75.66,52.75 78.96,52.75 84.4,58.18 85.1,58.18 85.41,58.5 85.41,60.66 86.45,61.7 87.98,61.7 89.84,63.57 89.84,66.49 92.59,69.23 94.87,69.23 95.26,68.85 96.72,68.85 96.82,68.95 105.03,68.95 106.3,70.22 v1(106.32,70.22)
  BOTTOM w0.076: v1(106.32,70.22) 106.38,70.16 106.38,68.9 106.41,68.86 106.41,68.62 106.12,68.33 UC1.D55
XDP_OBS2_R: length 8.6
  BOTTOM w0.076: T10.1 107.32,75.89 107.32,74.44 105.92,73.04 105.92,71.37 105.98,71.31 106.5,71.31 106.91,70.9 106.91,70.12 106.97,70.06 106.97,69.35 UC1.B54
XDP_OBS3_R: length 7.5
  BOTTOM w0.076: UC1.C56 105.56,68.59 105.83,68.86 105.83,69.94 105.78,69.99 105.78,70.85 105.58,71.05 105.58,72.75 105.26,73.07
  BOTTOM w0.102: 105.26,73.07 105.16,73.17 105.16,73.71 105.47,74.03 106.02,74.03 T11.1
XDP_PRSNT_PIN1: length 4.7
  TOP w0.102: JXDP1.1 75.45,37.73 RC122.1 RC121.1 v2(78.05,38.36)
XDP_TMS: length 16.6
  TOP w0.102: v1(59.33,31.62) 59.81,32.1 61.35,32.1 61.45,32 JXDP1.58 ; v1(51.62,30.54) 51.62,29.84 52.15,29.3 RC228.1 v2(52.2,30.17) 52.2,30.22 52.22,30.23 UC8.9
  BOTTOM w0.102: v1(51.62,30.54) 51.62,31.13 52.07,31.58 55.68,31.58 56.03,31.24 57.86,31.24 58.24,31.62 v1(59.33,31.62)
XTAL24_IN_U22: length 1.8
  BOTTOM w0.102: RC294.1 RC46.2 RC419.2
XTAL24_IN_U22_CPU: length 11.6
  BOTTOM w0.102: RC419.1 116.69,77.53 v2(116.69,74.85) 116.69,73.7 116.16,73.17 116.16,71.45 115.8,71.09 115.75,71.04 115.75,68.9 115.73,68.89 115.73,68.87 115.73,68.87 115.73,68.61 115.73,68.6 115.73,68.58 115.91,68.41 116.15,68.41 116.34,68.22 116.34,67.94 116.29,67.89 116.29,67.22 UC1.E37
XTAL24_IN_U22_R: length 4.7
  BOTTOM w0.102: YC1.3 116.83,82.65 116.83,80.49 CC21.1 RC294.2
XTAL24_IN_U42: length 2.3
  BOTTOM w0.102: RC550.1 145.42,74.74 144.66,73.98 RC421.2 143.79,73.83 RC417.2
XTAL24_IN_U42_CPU: length 14.8
  BOTTOM w0.102: RC417.1 142.55,73.86 141.9,73.21 141.9,73.06 142.2,72.76 142.2,72.62 142.06,72.48 141.92,72.48 141.62,72.78 141.47,72.78 141.32,72.63 141.32,72.45 141.6,72.16 v2(141.6,72.15) 141.6,72.02 141.46,71.88 141.31,71.88 141.01,72.18 140.87,72.18 140.73,72.03 140.73,71.89 141.03,71.59 141.03,71.44 140.88,71.3 140.74,71.3 140.44,71.6 140.29,71.6 140.15,71.46 140.15,71.31 140.45,71.01 140.45,70.87 140.31,70.73 140.16,70.73 139.86,71.03 139.72,71.03 139.58,70.88 139.58,70.74 139.88,70.44 139.88,70.29 139.73,70.15 139.59,70.15 139.29,70.45 139.14,70.45 137.99,69.3 137.55,69.3 137.15,68.9 137.15,68.22 136.37,67.44 UC1.E3
XTAL24_IN_U42_R: length 3.2
  BOTTOM w0.102: RC550.2 145.55,72.78 CC334.1 146.3,73.49 146.55,73.49 YC3.3
XTAL24_OUT_U22: length 1.8
  BOTTOM w0.102: RC46.1 RC420.2 RC295.1
XTAL24_OUT_U22_CPU: length 14.8
  BOTTOM w0.102: RC420.1 118.38,78.2 v2(117.64,77.46) 117.3,77.12 117.3,73.2 117.2,73.09 116.5,73.09 116.4,72.99 116.4,72.73 116.5,72.62 117.01,72.62 117.11,72.52 117.11,72.32 117.01,72.22 116.5,72.22 116.4,72.12 116.4,71.32 115.99,70.91 115.99,69.8 116.32,69.48 116.32,68.9 116.48,68.74 116.74,68.74 116.9,68.57 116.9,67.52 UC1.E35
XTAL24_OUT_U22_R: length 3.2
  BOTTOM w0.102: RC295.2 118.38,79.46 117.57,80.27 CC22.1 117.47,81.3 YC1.1
XTAL24_OUT_U42: length 1.7
  BOTTOM w0.102: RC422.1 RC421.1 RC418.2
XTAL24_OUT_U42_CPU: length 12.1
  BOTTOM w0.102: UC1.C7 134.75,68.41 135.04,68.71 135.32,68.71 135.33,68.7 135.36,68.7 135.69,68.37 136.12,68.37 136.66,68.9 136.66,69.36 136.97,69.68 137.79,69.68 v2(141.75,73.64) RC418.1
XTAL24_OUT_U42_R: length 5.3
  BOTTOM w0.102: RC422.2 144.71,76.5 145.55,75.66 CC335.1 145.85,75.28 147.99,75.28 148.87,76.16 YC3.1
XTALI: length 10.8
  TOP w0.102: YL1.1 289.12,89.67 287.11,89.67 286.49,90.29 v2(286.33,90.29) 285.4,90.29 RL11.2 284.46,89.35 CL14.1 283.93,88.92 283.68,88.92 281.78,87.02 UL1.10
XTALO: length 5.4
  TOP w0.102: RL11.1 284.41,88.38 RL34.2 283.67,88.16 v2(283.48,87.97) 283.22,87.97 281.87,86.62 UL1.9
XTALO_R: length 3.3
  TOP w0.102: YL1.3 287.44,89.17 286.59,89.17 CL13.1 285.32,88.31 RL34.1
Z2805: length 3.8
  TOP w0.508: RL18.1 v2(302.39,102.25) 302.39,102.63 302.07,102.95 v1(302.07,102.96)
  BOTTOM w0.508: v1(302.07,102.96) 302.07,102.95 301.71,102.58 TL1.24
Z2806: length 3.9
  TOP w0.508: v1(295.65,103.13) 295.65,102.87 295.53,102.76 v2(295.53,102.28) RL16.1
  BOTTOM w0.508: TL1.18 295.71,103.07 v1(295.65,103.13)
Z2807: length 3.9
  TOP w0.508: RL17.1 v2(298.84,102.28) 298.84,102.82 298.71,102.96 v1(298.71,103.12)
  BOTTOM w0.508: TL1.21 v1(298.71,103.12)
Z2808: length 3.9
  TOP w0.508: RL15.1 v2(292.99,102.25) 292.99,102.66 292.73,102.92 v1(292.73,103.09)
  BOTTOM w0.508: TL1.15 292.71,103.07 v1(292.73,103.09)
N04748: length 4.9
  TOP w0.203: PU901.3 20.96,16.36 21.03,16.29 21.55,16.29 22.05,15.79 v1(22.31,15.79)
  BOTTOM w0.254: v1(22.31,15.79) 22.71,16.19 PC939.1 PR929.1
N43975: length 3.5
  TOP w0.102: v2(277.73,40.1) 277.73,39.31 277.75,39.29 RN2.2 277.9,38.81 278.94,38.81 QN1.5 QN1.6
N16399089:
  vias: v3(9.15,21.74)
N16400770: length 15.7
  TOP w0.127: v1(5.94,16.53) 5.91,16.55 v2(5.91,17.4)
  TOP w0.254: PR910.1 13.37,22.65 v1(13.37,22.52)
  IN1 w0.254: v1(5.94,16.53) 5.76,16.35 5.76,16.17 5.91,16.02 6.8,16.02 8.73,17.95 8.73,21.19 9.93,22.39 13.25,22.39 v1(13.37,22.52)
  BOTTOM w0.254: v1(5.94,16.53) 5.48,16.07 PR901.3
N16775301: length 5.4
  BOTTOM w0.102: v2(43.95,43.58) 43.95,45.12 PR206.1
  BOTTOM w0.203: PU200.16 46.19,45.58 PR204.2
  BOTTOM w0.254: PR206.1 PC208.2 PR204.2
N16775385: length 3.7
  BOTTOM w0.102: v2(45.17,53.23) 45.16,53.22 45.16,51.6 45.61,51.15 PC218.1
  BOTTOM w0.203: PU200.3 45.74,50.74 45.61,50.87 PC218.1
N16775433: length 1.1
  TOP w0.102: 48.48,49.93 47.8,49.93 v2(47.53,50.2)
N16775513: length 2.1
  TOP w0.102: v2(51.77,46.17) 51.39,46.17 50.26,47.29 PC205.1
N16775517: length 1.3
  TOP w0.102: v2(46.74,47.66) 47.67,47.66 PR203.1
  vias: v1(48.43,46.51)
N16776853: length 1.4
  BOTTOM w0.203: PU200.14 47.09,45.87 PC207.1
N16783095: length 2
  TOP w0.102: v2(149.67,112.39) 149.93,112.65 PR108.1
  TOP w0.254: PC113.2 150.8,112.46 PR108.1
N16783126: length 0.9
  TOP w0.102: v2(154.87,106.85) 154.87,107.76
N16783134: length 2.2
  BOTTOM w0.102: v2(173.69,113.61) 172.97,114.33 PR117.1
  BOTTOM w0.254: PR117.1 PC127.2
N16784595: length 2.6
  TOP w0.102: v2(159.77,108.84) PC102.1
  TOP w0.508: PC102.1 PR100.2
N16784799: length 1.2
  BOTTOM w0.102: v2(161.1,112) PC114.1
N17023599: length 6.1
  TOP w0.102: PR950.1 33.29,28.86 33.79,29.36 33.79,30.18 34.12,30.51 PD905.3 35.54,30.51 PR939.2 35.93,29.44 v2(36.4,28.97)
N17023623: length 2.8
  TOP w0.102: PR961.1 31.7,29.86 PD905.1 32.9,30.75 32.66,30.99 PU903.1
N17023625: length 4.2
  TOP w0.102: v2(29.49,29.89) 29.49,30.96 30.49,31.95 PU903.4 30.22,32.29 30.03,32.48 PR946.1
N17023649: length 1.1
  TOP w0.102: PR942.2 PU903.2
N17023661: length 2.2
  TOP w0.102: v2(34.82,27.06) PR941.2 34.8,28.1 PD905.2
N17185089: length 3.3
  TOP w0.102: PR1218.1 16.55,31.78 v2(17.47,30.87)
  TOP w0.254: PR1218.1 16.13,31.78 15.88,32.04 15.88,32.52 15.59,32.81 PQ1204.5
N17185092: length 4.9
  TOP w0.102: PR1214.2 17.82,32.26 18.51,32.26 v2(18.93,32.68)
  TOP w0.254: PQ1204.6 15.44,33.46 16.2,32.7 PR1218.2 16.88,32.7 17.39,32.19 PR1214.2
N17185371: length 4.7
  TOP w0.102: PR1223.1 13.44,30.8 13.57,30.68 v2(15.42,30.68)
  TOP w0.254: PR1223.1 13.44,31.48 13.98,32.01 13.98,32.53 13.7,32.81 PQ1204.2
N17188383: length 5.5
  TOP w0.102: v2(17.63,32.76) 17.25,33.14 16.44,33.14 16.24,33.34 PR1216.2
  TOP w0.254: 15.6,34.12 PQ1201.2 ; 15.6,34.12 14.28,34.12 PR1262.1 ; 15.6,34.12 15.75,34.12 PR1216.2
N17275961: length 4.3
  TOP w0.203: v1(72.13,51.68) 72.04,51.58 PU602.39
  BOTTOM w0.254: PR614.2 PR612.2 73.6,52.74 72.63,52.74 v2(72.39,52.5) 72.13,52.24 v1(72.13,51.68)
N17275988: length 3.1
  TOP w0.203: PU602.40 71.7,51.98 71.9,52.19 71.9,52.54 v2(72.38,53.01) 72.78,53.41 73.45,53.41 PR616.2
N17370862: length 29.8
  TOP w0.102: PC4.2 v2(49.27,80.85)
  TOP w0.508: PQ5.1 60.69,102.18 PR16.1 59.3,101.31 v1(59.23,101.38)
  IN1 w0.508: v1(48.04,81.98) 48.04,89.02 52.52,93.51 52.52,94.67 v1(59.23,101.38)
N17370885: length 4.2
  TOP w0.102: PR15.1 55.69,104.73 v2(55.5,104.54)
  TOP w0.508: PQ5.2 58.24,103.87 PR10.2 56.52,103.88 PR15.1
N17370921: length 3.1
  TOP w0.102: v2(55.5,105.94) 55.8,105.64 PR15.2
  TOP w0.254: PQ1.6 57,106.12 PR15.2
N17370927: length 3.3
  TOP w0.381: PQ7.1 64.58,102.29 v2(63.61,101.31) PR16.2
N17370961: length 12.3
  TOP w0.254: PR3.1 63.51,92.35 PQ2.1 63.51,88.29 62.53,87.31 v2(61.35,87.31) 59.96,88.7 59.96,90.32 PL3.1 59.59,90.67 PR6.2
N17370983: length 6.5
  TOP w0.102: PQ2.3 64.48,87.86 v2(63.82,87.2)
  TOP w0.254: PR3.2 64.91,91.86 PR5.1 64.94,89.51 PQ2.3
N17370995: length 4.7
  TOP w0.102: PQ3.2 59.61,88.97 v2(59.61,87.32)
  TOP w0.254: PQ3.2 57.98,89.65 PR8.2 57.81,89.81 PR6.1
N17370999: length 7
  TOP w0.102: v2(62.9,93.72) 62.67,93.49 62.67,93.29 62.53,93.15 62.53,92.36 PR7.2
  TOP w0.254: PR7.2 62.03,90.52 62.55,90 PQ2.2 62.5,89 PQ3.1
N17371029: length 7.6
  TOP w0.508: PR18.1 54.97,93.13 v1(53.43,91.59)
  IN4 w0.508: v1(53.43,91.59) v1(48.11,91.59)
  vias: v2(47.55,91.94)
N17371043: length 2.6
  TOP w0.102: PR18.2 55.88,93.5 v2(56.56,94.18)
  TOP w0.254: PR18.2 56.34,92.8 PQ6.1
N17371125: length 2.5
  TOP w0.102: v2(64.57,104.93) 64.43,104.79 PR20.1
  TOP w0.381: PR20.1 63.56,104.59 PQ7.2
N17371182: length 3.1
  TOP w0.254: PR30.1 PR23.2 v2(60.1,92.52) 60.1,92.42 59.83,92.15 PQ6.2
N17371184: length 5.1
  TOP w0.102: v1(62.94,94.23) 64.35,94.23 v2(64.88,94.76)
  TOP w0.254: v1(62.94,94.23) 62.08,94.23 61.38,93.54 PR23.1
  BOTTOM w0.254: v1(62.94,94.23) 63.35,94.65 PU1.4
N17371196: length 4.5
  BOTTOM w0.102: v2(65.09,97.13) 65.25,96.97 PU1.1
  BOTTOM w0.254: PU1.1 64.63,96.09 63.8,95.26 PR21.2
N17371202: length 2.2
  BOTTOM w0.102: v2(66.43,94.34) PR22.2
  BOTTOM w0.254: PR22.2 65.96,95.24 65.76,95.44 PU1.2
N17372063: length 3
  TOP w0.102: v2(62.16,108.54) PR17.2
  TOP w0.381: PQ1.3 60.61,107.42 60.75,107.56 PR19.2 62.13,107.56 PR17.2
N17372074: length 2.2
  TOP w0.102: v2(57.08,107.92) PR25.1
  TOP w0.254: PQ1.5 57.26,106.77 PR25.1
N17372283: length 2
  TOP w0.102: v2(61.22,105.73) PR19.1
  TOP w0.381: PR19.1 60.31,106.65 PQ1.2
N17400451: length 4.1
  TOP w0.102: PR516.1 v2(191.91,1.48)
  TOP w0.381: PR515.2 192.29,3.29 192.51,3.51 PU503.3 ; PR515.2 191.91,3.29 PR516.1 ; PR515.2 191.91,4.16 PC515.2
N17494434: length 111.5
  TOP w0.254: v1(70.21,105.96) PQ1212.1 69.84,106.8 PC1211.1 68.46,105.63 PR1238.1 ; v1(17.66,52.34) 17.66,50.82 v2(16.52,49.68) PR1255.2
  IN1 w0.254: v1(67.06,93.85) 67.06,100.26 69.05,102.25 69.05,105.45 69.57,105.96 v1(70.21,105.96)
  IN2 w0.254: v1(67.06,93.85) 66.6,93.39 64.54,93.39 63.78,92.62 55.32,92.62 53.15,90.45 43.31,90.45 42.85,90.91 31.42,90.91 29.66,89.15 28.63,89.15 26.85,87.37 26.85,86.71 27.12,86.44 27.12,77.74 28.12,76.74 28.12,64.08 18.36,54.31 18.36,53.04 v1(17.66,52.34)
  BOTTOM w0.254: PR1239.2 71.84,105.67 PR1246.1 71.45,107.02 PD1205.1 70.52,106.28 v1(70.21,105.96) 69.63,105.38 PU1201.5
N18490882: length 2.6
  TOP w0.102: UI3.16 311.02,60.97 311.08,61.03 RI14.2 312.32,61.03 312.57,60.78 v2(312.72,60.78)
N18762046: length 0.9
  TOP w0.102: RA17.2 CA33.1
N18762152: length 2.4
  TOP w0.203: CZ127.1 274.71,72 v2(274.58,72.13) 274.56,72.14 UZ5.10
N18762172: length 2.6
  TOP w0.203: CZ126.1 275.72,71.72 275.85,71.85 v2(275.85,72.13) 275.85,72.15 275.36,72.64 UZ5.12
N18762349:
  vias: v2(304.61,33.9)
N18762353: length 2.8
  TOP w0.102: CA53.1 294.65,36.02 294.96,35.71 v2(295.25,35.71) 295.84,35.12 UA1.7
N18762355: length 4.6
  TOP w0.203: 301.41,39.29 301,38.88 UA1.39
  TOP w0.254: 301.41,39.29 301.89,39.77 302.24,39.77 302.62,40.15 v2(302.84,40.15) 303.6,40.91 303.98,40.91 CA52.1
N18762401: length 5.5
  TOP w0.203: UA1.20 300.2,31.73 300.68,31.25 300.68,31.21
  TOP w0.254: RA53.1 RA54.1 302.58,29.43 302.58,29.92 302.01,30.5 301.39,30.5 300.68,31.21
N18762411: length 2.4
  TOP w0.203: 303.55,37.73 303.55,37.65 303.02,37.12 UA1.35
  TOP w0.254: 303.55,37.73 304.17,38.35 CA29.1
N18762416: length 3.2
  TOP w0.203: 303.28,39.26 302.79,38.76 v1(302.33,38.76) 301.91,38.76 301.8,38.65 UA1.37
  TOP w0.254: 303.28,39.26 304.11,40.09 CA29.2
N18762426:
  vias: v2(305.86,34.41)
N18762428: length 3.7
  TOP w0.203: 304.52,38.13 v2(303.93,37.54) 303.13,36.73 303,36.73 302.99,36.72 UA1.34
  TOP w0.254: 304.52,38.13 304.98,38.13 305.44,38.59 CA49.1
N18762438: length 3.2
  TOP w0.203: UA1.19 299.8,31.52 v2(300.19,31.13) 300.55,30.77 CA25.1
N20151644: length 16
  TOP w0.127: v2(5.21,15.66) 5.21,16.5 v1(5.24,16.53)
  TOP w0.254: PR909.1 13.86,21.88 v1(13.37,21.88)
  IN1 w0.254: v1(13.37,21.88) 13.25,22.01 10.06,22.01 9.09,21.04 9.09,17.8 6.93,15.64 5.72,15.64 5.38,15.98 5.38,16.39 v1(5.24,16.53)
  BOTTOM w0.254: v1(5.24,16.53) 5.48,16.77 PR901.2
N27077001: length 9.1
  TOP w0.254: PR917.2 29.74,9.86 29.55,9.67 27.64,9.67 27.03,10.28 v2(27.03,12.15) 27.03,12.43 26.45,13.01 26.45,13.56 25.86,14.14 25.25,14.14 PR937.2
N28424999: length 6.1
  BOTTOM w0.076: UC1.AW71 96.75,48.76 95.79,48.76 95.48,48.46 95.48,48.05 95.2,47.77 95.2,47.15 93.41,45.36 T113.1
N28425002: length 9.2
  BOTTOM w0.076: UC1.AW70 97.3,48.53 96.3,48.53 96.25,48.58 95.88,48.58 95.69,48.39 95.69,47.9 95.46,47.67 95.46,47.08 92.27,43.9 T114.1
N28489601: length 7.2
  BOTTOM w0.102: RC222.1 279.79,91.59 278.9,90.7 v3(275.85,90.7) 275.09,90.7 274.79,90.39 SW1.2
N28769860: length 4
  TOP w0.102: PR421.2 144.13,107.74 v2(143.79,107.41)
  TOP w0.254: PR421.2 144.71,108.63 PR422.1 143.87,108.63 143.51,108.99 PU401.5
N28771761: length 2.5
  TOP w0.254: PU401.14 138.96,109.99 v1(138.87,110.08) 138.8,110.08 PR425.2 138.32,108.68 PR404.2
N28771835: length 2.4
  TOP w0.254: PU402.14 128.33,112.34 PR426.2 127.95,111.06 PR410.2
N28810563: length 1.9
  BOTTOM w0.203: CZ110.1 278.6,50.69 v2(277.86,50.69) 277.75,50.69 277.65,50.58 UZ2.10
N28811129: length 1.9
  TOP w0.203: UZ3.10 204.2,7.21 204.55,6.85 204.55,6.57 CZ114.1
N28856399: length 6.9
  BOTTOM w0.076: 93.16,44.47 95.69,46.99 95.69,47.57 95.89,47.77 96.19,47.77 96.3,47.87 97.31,47.87 UC1.BA70
  BOTTOM w0.102: T16.1 92.97,44.27 93.16,44.47
N28856402: length 8.4
  BOTTOM w0.076: UC1.BA68 98.12,47.47 98.28,47.31 98.28,46.77 97.86,46.35 96.34,46.35 96.19,46.2
  BOTTOM w0.102: 96.19,46.2 94.59,44.6 94.59,42.22 T17.1
N28857231: length 5.3
  BOTTOM w0.076: 96.91,46.16 97.96,46.16 98.6,46.8 UC1.BB68
  BOTTOM w0.102: T12.1 95.13,44.53 96.75,46.16 96.91,46.16
N28857234: length 6.6
  BOTTOM w0.076: 95.94,46.37 96.12,46.55 97.69,46.55 97.95,46.81 UC1.BB69
  BOTTOM w0.102: 95.94,46.37 94.05,44.48 T13.1
N28857237: length 1.8
  TOP w0.102: T14.1 128.64,55.02 129.22,55.02 v1(129.6,54.64)
  BOTTOM w0.102: v1(129.6,54.64) 129.85,54.39 UC1.AK13
N28857240: length 1.1
  TOP w0.102: T15.1 130.93,54.84 v1(130.54,54.84)
  BOTTOM w0.102: UC1.AK12 130.83,54.55 v1(130.54,54.84)
N28861827: length 14.2
  BOTTOM w0.076: UC1.C64 101.16,68.92 101.07,69.01 101.07,69.91 100.86,70.13 100.86,70.71 99.81,71.76 99.81,72.41 99.16,73.05 97.53,73.05 97.27,73.31
  BOTTOM w0.102: RC120.1 98.54,79 97.8,78.25 v2(97.8,78.06) 97.8,77.81 98.19,77.41 98.19,76.73 98.01,76.54 98.01,75.39 96.8,74.19 96.8,73.78 97.27,73.31
N28938912: length 1.1
  BOTTOM w0.102: RC29.2 151.59,63.49 CC8.1
N28938914: length 1.8
  BOTTOM w0.102: v2(149.47,53.8) 149.5,53.83 CC7.1 RC28.2
N29708559: length 8.9
  BOTTOM w0.076: 137.38,47.17 137.16,47.39 137.15,47.39 137.14,47.4 137.12,47.4 136.08,47.4 135.87,47.61 135.87,47.92 UC1.AY4
  BOTTOM w0.102: T126.1 139.88,45.46 138.17,47.17 137.38,47.17
N29708561: length 8.4
  BOTTOM w0.102: T127.1 140.68,44.32 138.26,46.74 136.7,46.74 UC1.BB3
N29708599: length 9.9
  BOTTOM w0.076: T128.1 142.31,51.77 141.79,52.29 138.4,52.29 137.97,51.87 137.97,51.61 137.61,51.25 135.39,51.25 135.22,51.08 135.22,50.62 UC1.AU5
N29708601: length 8.9
  BOTTOM w0.076: UC1.AT5 134.8,51.04 135.1,51.34 135.1,51.66 135.39,51.95 137.71,51.95 138.33,52.57 142.34,52.57 T129.1
N29708639: length 9.6
  BOTTOM w0.102: UC1.BB5 135.2,47.09 135.53,46.75 135.75,46.75 136.25,46.25 137.64,46.25 138.42,45.47 138.7,45.47 140.59,43.58 142.58,43.58 T130.1
N30342894: length 4.6
  TOP w0.102: RV18.2 110.4,101.15 v2(111.32,102.06) 111.78,102.52 QV4.2
N32590572: length 2.2
  TOP w0.203: CZ117.1 194.76,17.21 v2(194,17.21) 193.86,17.21 193.57,16.93 UZ4.12
N32592963: length 3.5
  TOP w0.102: v2(195.27,14.75) 194.94,15.08 CZ118.1
  TOP w0.203: UZ4.10 193.57,16.13 193.68,16.02 CZ118.1
N32594166: length 4.1
  BOTTOM w0.102: v2(280.57,49.55) 280.47,49.45 279.19,49.45 CZ109.1
  BOTTOM w0.203: UZ2.12 277.47,49.78 277.58,49.68 278.47,49.68 CZ109.1
N32817808: length 4.1
  TOP w0.203: UZ3.12 204.72,8.01 205.26,7.46 205.41,7.46 206.02,6.85 206.08,6.85 v2(206.1,6.83) 206.17,6.76 CZ113.1
N32818355: length 1.3
  TOP w0.102: RZ65.2 200.39,8.98 v2(200.39,9.82)
N32819772: length 3.1
  TOP w0.102: CZ121.1 269.91,48.83 v2(269.25,48.83)
  TOP w0.254: CZ121.1 270.65,48.36 UZ8.6
N32875032: length 4
  BOTTOM w0.102: CZ130.1 281.72,41.9 283.01,41.9 283.34,41.57 v2(283.34,41.37)
  BOTTOM w0.254: UZ23.6 281.07,41.73 CZ130.1
N33199744: length 2.4
  TOP w0.102: T51.1 82.43,14.57 v1(82.5,14.5)
  BOTTOM w0.102: JDIMM1.165 82.28,14.24 82.54,14.51 82.48,14.51 82.48,14.5 v1(82.5,14.5)
N33298471: length 2
  TOP w0.102: v1(163.1,14.29) 163.24,14.43 T55.1
  BOTTOM w0.102: v1(163.1,14.29) 163.28,14.11 JDIMM2.165
N35551558:
  vias: v2(16.02,51.12)
N35551572: length 92.2
  TOP w0.102: v1(66.31,93.84) v2(66.31,94.61)
  TOP w0.254: PC1214.1 16.88,54.06 PQ1209.5 v1(17.61,54.07) ; PR1243.2 v1(66.61,102.12)
  IN1 w0.254: v1(66.31,93.84) 66.31,101.82 v1(66.61,102.12)
  IN2 w0.254: v1(66.31,93.84) 64.43,93.84 63.58,93 53.79,93 51.72,90.92 44.53,90.92 44.02,91.43 31.35,91.43 29.47,89.55 28.53,89.55 26.5,87.52 26.5,86.56 26.77,86.29 26.77,77.59 26.97,77.38 27.12,77.24 27.12,63.58 v1(17.61,54.07)
N35551576:
  vias: v2(19.69,55.9)
N35551581: length 2.2
  TOP w0.102: v2(17.05,52.33) 16.89,52.49 PQ1209.6
  TOP w0.254: PQ1209.6 16.14,53.42 PR1229.2
N35551584: length 4.3
  TOP w0.508: 67.42,104.61 69.54,104.61 v1(69.7,104.77)
  BOTTOM w0.254: v1(67.73,106.55) 67.57,106.38 PU1201.7 ; v1(66.37,104.53) 66.58,104.33 PC1213.1
  vias: v2(66.3,105.56)
N35551592: length 5.4
  BOTTOM w0.102: PR1237.2 69.24,103.94 69.67,103.51 v2(69.67,101.94)
  BOTTOM w0.254: PR1237.2 69.23,103.95 PR1247.1 ; PC1212.1 68.35,103.94 PR1247.1 ; PU1201.6 68.22,104.09 PR1247.1
N35551616: length 4.6
  TOP w0.102: v2(70.89,112.44) 70.23,112.44 PR1249.1
  TOP w0.254: PR1249.1 69.98,111.26 PR1250.1 69.94,110.28 PR1248.1 69.92,110.01 PQ1212.2
N35551696:
  vias: v2(6.77,50.73)
N35551713: length 22.2
  TOP w0.254: v1(14.22,40.82) v2(14.22,38.62) 14.23,38.62 14.49,38.36 14.49,37.35 14.95,36.89 PQ1201.6 ; PR1212.2 2.72,48.67 v1(2.74,48.66)
  IN4 w0.254: v1(14.22,40.82) 14.22,44.68 10.24,48.66 v1(2.74,48.66)
N35551783: length 1
  TOP w0.102: PC1203.2 v2(11.31,42.61)
N35551785: length 4.4
  TOP w0.102: PR1209.1 v2(3.22,41.29)
  TOP w0.508: PR1209.1 3.25,40.14 PR1202.2 5.24,41.18 PQ1203.2
N35551806: length 14.9
  TOP w0.254: PQ1204.3 12.84,32.16 v2(12.3,31.62) v1(11.94,31.26) ; v1(2.66,38.64) PR1209.2
  IN1 w0.254: v1(2.66,38.64) 4.56,38.64 v1(11.94,31.26)
N35551822: length 9.4
  TOP w0.254: PR1213.2 12.6,39.74 v2(12.88,39.47) 13.53,38.82 13.53,38.56 14.1,37.99 14.1,36.34 14.48,35.96 15.37,35.96 16.25,35.09 PQ1201.3
N36255106: length 3.5
  TOP w0.102: PR1220.2 14.8,38.11 14.8,39.63 v2(14.88,39.71)
  TOP w0.254: PR1220.2 15.3,37.18 15.6,36.88 PQ1201.5
N36626863: length 1.2
  BOTTOM w0.102: RT111.2 37.94,101.35 v2(37.51,101.35)
N36827741:
  vias: v2(128.06,30.36)
N38798736: length 24.2
  TOP w0.076: 33.03,76.6 33.03,77.76 32.89,77.9 32.89,78.29 UT5.F10
  TOP w0.102: 33.03,76.6 33.03,76.11 RT98.1 RT99.1 33.48,75.54 33.44,75.54 33.22,75.32 33.22,74.19 33.72,73.68 35.44,73.68 36.01,74.25 37.72,74.25 40.07,76.6 40.07,84.49 v2(39.76,84.8) 39.07,85.49 RT97.2
