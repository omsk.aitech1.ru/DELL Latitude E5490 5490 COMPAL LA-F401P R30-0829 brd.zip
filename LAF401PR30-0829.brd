# Allegro board LAF401PR30-0829.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCC_CORE on BOTTOM (solid shape): outline of 335 points within 114.13,52.78 119.46,55.71
+VCC_CORE on BOTTOM (solid shape): outline of 603 points within 112.65,63.33 119.92,66.31
+VCC_CORE on IN1 (solid shape): outline of 1013 points within 111.19,52.89 119.38,65.16
+VCC_CORE on IN2 (solid shape): outline of 11851 points within 76.65,52.79 119.84,78.5
+VCC_CORE on IN3 (solid shape): outline of 12829 points within 76.65,54.46 119.94,79.01
+VCC_CORE on IN4 (solid shape): outline of 1737 points within 110.86,52.74 119.95,70.66
+VCC_CORE on VCC: 72.4,62.12 72.4,80.35 80.02,80.35 81.54,81.87 83.51,81.87 86.49,78.89 115.51,78.89 119.77,74.63 119.77,53.61 119.19,53.61 118.56,52.98 115.13,52.98 113.73,54.37 104.46,54.37 101.35,57.49 89.98,57.49 89.54,57.93 88.4,57.93 84.21,62.12
+VCC_GT on TOP (solid shape): outline of 3317 points within 74.55,53.36 108.36,70.82
+VCC_GT on BOTTOM (solid shape): outline of 1521 points within 69.66,55.87 107.43,65.36
+VCC_GT on IN1 (solid shape): outline of 1343 points within 95.7,55.2 108.02,65.11
+VCC_GT on IN4 (solid shape): outline of 1884 points within 96.07,54.36 110.55,65.14
+VCC_GT_+VCC_CORE on TOP (solid shape): 112.65,64.92 112.65,64.34 112.46,64.15 111.7,64.15 111.32,63.77 111.32,62.12 110.88,62.12 110.5,61.74 110.5,58.12 110.75,57.87 111.64,57.87 111.83,57.68 111.83,56.22 112.46,55.58 113.23,55.58 113.53,55.28 113.53,55.07 113.52,55 113.52,54.92 113.52,54.87 113.52,54.82 113.52,54.79 113.52,54.67 113.48,54.63 110.32,54.63 110.16,54.47 110.16,53.02 109.99,52.85 109.16,52.85 109.08,52.89 109.06,52.98 109.04,53.21 108.87,53.36 108.84,53.38 108.84,55.39 109.06,55.61 109.2,55.61 109.2,55.6 109.62,55.92 109.2,56.24 109.2,56.24 109.03,56.24 109.03,56.81 109.2,56.81 109.2,56.81 109.62,57.13 109.2,57.45 109.2,57.45 109.03,57.45 109.03,58.08 109.2,58.08 109.2,58.08 109.62,58.4 109.2,58.72 109.2,58.72 109.03,58.72 109.03,59.35 109.2,59.35 109.2,59.35 109.62,59.67 109.2,59.99 109.2,59.99 109.03,59.99 109.03,60.56 109.2,60.56 109.2,60.56 109.62,60.88 109.2,61.2 109.2,61.19 109.03,61.19 109.03,61.74 108.78,61.99 108.62,61.99 108.54,62.07 108.54,64.86 108.81,65.14 112.43,65.14
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 321 points within 107.76,63.39 112.58,65.36
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 466 points within 108.45,53.38 113.85,55.71
+VCC_GT_+VCC_CORE on IN1 (solid shape): outline of 670 points within 106.3,52.79 113.54,70.5
+VCC_GT_K52 on TOP (solid shape): 106.91,67.63 107.55,67 107.55,66.74 107.54,66.65 107.55,66.56 107.55,66.02 107.55,65.73 108.1,65.18 108.1,64.4 107.98,64.28 107.67,64.28 107.58,64.37 107.58,65.06 107.17,65.47 107.17,65.73 107.25,65.94 107.17,66.16 107.17,66.38 107.29,66.72 107.05,66.99 107.04,67 106.41,67.63 106.41,68.22 106.91,68.22
+VCC_GTX on BOTTOM (solid shape): outline of 141 points within 106.99,52.82 108.36,54.88
+VCC_GTX on BOTTOM (solid shape): outline of 334 points within 103.36,52.85 106.53,54.9
+VCC_GTX on IN1 (solid shape): 108.15,53.61 108.15,52.91 107.96,52.72 107.93,52.73 107.82,52.75 107.71,52.73 107.7,52.72 107.11,52.72 107.1,52.74 107.07,52.81 107.09,52.88 106.8,53.43 106.65,52.83 106.67,52.79 106.65,52.75 106.63,52.72 106.17,52.72 105.95,52.81 105.73,52.72 104.28,52.72 104.27,52.73 104.17,52.74 104.07,52.73 104.07,52.72 103.95,52.72 103.7,52.98 103.7,53.93 103.95,54.18 107.57,54.18
+VCC_SA on TOP (solid shape): 86.75,84.47 86.43,84.16 83.38,84.16 83.13,84.41 83.13,87.71 83.38,87.97 86.75,87.97
+VCC_SA on TOP (solid shape): 124.46,56.63 124.46,55.64 124.43,55.57 124.36,55.53 124.12,55.42 124.04,55.18 124.04,55.12 123.94,55.12 123.76,55.3 122.36,55.3 122.31,55.35 122.31,56.39 122.61,56.69 124.4,56.69
+VCC_SA on TOP (solid shape): 124.46,56.69 124.46,55.64 124.43,55.57 124.36,55.53 124.12,55.42 124.04,55.18 124.04,55.12 123.94,55.12 123.87,55.19 122.48,55.19 122.31,55.35 122.31,56.39 122.64,56.72 124.43,56.72
+VCC_SA on TOP (solid shape): 121.98,64.5 122.02,64.09 122.41,63.99 122.64,63.99 122.82,63.8 122.82,63.26 122.92,63.16 123.47,63.16 123.52,63.12 123.52,60.98 123.77,60.74 123.77,59.19 123.7,59.13 123.22,59.13 123.01,58.92 122.23,58.92 122.1,59.05 122.1,60.11 122,60.22 121.7,60.22 121.59,60.32 121.59,61.41 122.03,61.84 122.03,62.48 121.59,62.91 121.59,63.91 121.25,64.26 121.25,64.43 121.44,64.63 121.85,64.63
+VCC_SA on BOTTOM (solid shape): 86.93,87.86 86.93,84.35 86.55,83.97 80.59,83.97 80.27,84.28 80.27,85.87 81.22,85.87 81.22,86.76 80.27,86.76 80.27,87.78 80.46,87.97 86.82,87.97
+VCC_SA on BOTTOM (solid shape): 123.99,55.56 123.99,54.68 123.98,54.67 123.96,54.55 123.98,54.43 123.99,54.42 123.99,54.29 123.89,54.19 122.71,54.19 122.29,54.62 122.29,55.62 122.42,55.76 123.79,55.76
+VCC_SA on BOTTOM (solid shape): outline of 337 points within 119.97,63.6 124.34,66.21
+VCC_SA on IN1 (solid shape): 123.42,61.82 123.42,59.56 123.02,59.15 123.02,57.04 123.93,56.13 123.93,55.29 123.83,55.19 122.53,55.19 122.26,55.47 122.24,55.49 122.22,55.53 122.19,55.57 122.15,55.6 122.11,55.63 122.08,55.64 121.01,56.71 121.01,59.86 121.39,59.86 121.39,59.81 121.4,59.76 121.42,59.71 121.44,59.66 121.47,59.62 121.51,59.58 121.55,59.55 121.6,59.53 121.64,59.51 121.7,59.5 121.75,59.5 121.8,59.51 121.85,59.53 121.89,59.55 121.94,59.58 121.97,59.62 122,59.66 122.03,59.71 122.04,59.76 122.05,59.81 122.05,59.86 122.04,59.91 122.03,59.96 122,60.01 121.97,60.05 121.94,60.09 121.89,60.12 121.85,60.14 121.8,60.16 121.75,60.17 121.7,60.17 121.64,60.16 121.6,60.14 121.55,60.12 121.51,60.09 121.47,60.05 121.44,60.01 121.42,59.96 121.4,59.91 121.39,59.86 121.01,59.86 121.01,60.7 122.33,62.02 123.22,62.02
+VCC_SA on IN2 (solid shape): outline of 445 points within 120.29,55.14 124.12,70.47
+VCC_SA on IN3 (solid shape): outline of 1022 points within 120.3,54.84 125.35,75.84
+VCC_SA on VCC: 124.21,56.09 123.83,55.71 123.83,53.74 123.7,53.61 120.27,53.61 120.27,74.88 115.77,79.39 86.75,79.39 83.76,82.38 81.67,82.38 81.67,85.62 82.68,86.63 87.25,86.63 89.98,83.9 104.08,83.9 104.91,84.73 108.78,84.73 109.1,84.41 124.21,84.41
+VCC_SFR_OC on TOP (solid shape): 123.77,29.4 124.65,29.4 124.84,29.21 124.84,27.89 124.65,27.7 124.33,27.7 123.86,28.17 121.2,28.17 121.04,28.34 121.04,29.23 121.16,29.36 122.87,29.36 123.07,29.56 123.62,29.56
+VCC_SFR_OC on TOP (solid shape): 124.63,54.76 124.64,54.75 124.71,54.62 124.84,54.54 124.85,54.54 125.01,54.38 125.01,54.34 124.98,54.26 124.91,54.23 124.59,53.91 124.9,53.57 124.97,53.54 125,53.47 125,53.31 124.87,53.05 124.99,52.79 125.01,52.77 125.01,52.69 124.87,52.41 125.01,52.14 125.01,52.05 124.87,51.77 125.01,51.5 125.01,51.41 124.9,51.27 124.88,51.09 124.88,51.07 124.82,51.01 124.57,51.01 124.52,51.06 124.52,51.53 124.62,51.77 124.52,52.02 124.52,52.13 124.64,52.41 124.52,52.68 124.52,52.82 124.61,53.15 124.35,53.38 124.34,53.39 124,53.72 124,54.73 124.11,54.84 124.55,54.84
+VDDA_AVDD1 on TOP (solid shape): 303.21,33.61 305.38,33.61 305.57,33.42 305.57,32.67 305.56,32.62 305.57,32.53 305.58,32.51 305.67,32.37 305.81,32.28 305.82,32.27 306.58,31.51 308.3,31.51 308.49,31.32 308.49,29.61 307.85,28.97 307.85,28.4 307.73,28.28 307.22,28.28 307.15,28.34 307.15,29.23 307.54,29.61 307.54,30.63 307.47,30.69 307.22,30.94 305.75,30.94 305.31,31.38 305.31,32.09 304.88,32.52 304.89,32.55 304.79,32.92 304.4,32.98 304.39,32.97 303.73,32.97 303.28,33.42 302.33,33.42 302.25,33.42 302.2,33.47 302.2,33.58 302.26,33.63 303.19,33.63
+VSS_PLL on TOP (solid shape): 300.54,72 300.54,71.09 300.21,70.76 300.21,70.16 300.47,69.89 300.48,69.88 300.48,69.81 300.47,69.81 300.47,69.2 301.08,69.2 301.08,68.17 300.44,68.17 300.39,68.22 300.39,68.39 300.25,68.52 300.25,68.85 299.93,69.18 299.93,69.91 299.7,70.14 299.7,70.83 300.18,71.32 300.18,72 300.28,72.1 300.44,72.1
GND on TOP (solid shape): 86.75,88.22 86.68,88.16 83.57,88.16 83.44,88.28 83.44,89.36 86.75,89.36
GND on TOP (solid shape): 176.79,30.18 176.79,29.29 174.69,29.29 174.69,30.12 175.07,30.5 176.47,30.5
GND on TOP (solid shape): 70.56,5.99 70.56,5.28 70.51,5.23 69.53,5.23 69.53,6.03 69.78,6.28 70.27,6.28
GND on TOP (solid shape): 5.4,26.05 5.4,20.47 5.28,20.34 3.94,20.34 3.69,20.59 3.69,26.05 3.82,26.18 5.28,26.18
GND on TOP (solid shape): 9.47,94.82 9.97,94.82 9.97,93.93 9.78,93.74 9.21,93.74 8.13,94.82 8.13,95.2 9.09,95.2
GND on TOP (solid shape): 20.89,48.12 20.89,47.18 20.87,47.15 20.23,47.15 19.86,47.53 19.86,47.98 20.04,48.16 20.86,48.16
GND on TOP (solid shape): 46.83,90.57 46.83,89.59 46.45,89.21 41.15,89.21 41.03,89.34 41.03,90.78 41.15,90.91 46.49,90.91
GND on TOP (solid shape): 48.29,12.45 48.29,11.64 48.13,11.48 47.38,11.48 47.19,11.67 47.19,12.43 47.24,12.47 48.26,12.47
GND on TOP (solid shape): 63.16,5.8 63.16,5.34 63.14,5.32 62.2,5.32 62.16,5.35 62.16,6.13 62.35,6.32 62.65,6.32
GND on TOP (solid shape): 70.62,12.46 70.62,12.09 69.99,11.46 69.63,11.46 69.49,11.6 69.49,12.43 69.56,12.49 70.59,12.49
GND on TOP (solid shape): 71.81,12.44 71.81,11.75 71.45,11.39 71.1,11.39 70.8,11.7 70.8,12.46 70.83,12.49 71.76,12.49
GND on TOP (solid shape): 87.34,20.77 87.34,17.46 86.84,16.96 84.3,16.96 84.04,17.21 84.04,20.77 84.17,20.89 87.22,20.89
GND on TOP (solid shape): 127.01,5.98 127.01,5.38 126.95,5.33 125.95,5.33 125.91,5.36 125.91,5.83 126.43,6.35 126.65,6.35
GND on TOP (solid shape): 145.09,74.74 145.09,74.46 145.03,74.4 143.94,74.4 143.61,74.73 143.61,75.57 143.77,75.73 144.1,75.73
GND on TOP (solid shape): 173.76,105.28 173.76,100.42 173.47,100.13 172.45,100.13 172.04,100.54 172.04,105.2 172.37,105.54 173.5,105.54
GND on TOP (solid shape): 177.34,5.66 177.34,5.29 177.31,5.26 176.32,5.26 176.26,5.31 176.26,6.21 176.33,6.27 176.73,6.27
GND on TOP (solid shape): 189.44,5.49 189.44,4.44 189.16,4.16 188.71,4.16 188.44,4.44 188.44,5.49 188.48,5.52 189.41,5.52
GND on TOP (solid shape): 117.9,54.19 117.9,52.99 118.12,52.77 118.12,52.26 118.03,52.17 117.75,52.17 117.46,52.45 117.46,54.23 117.86,54.23
GND on TOP (solid shape): 309.25,74.82 309.25,74.44 309.06,74.25 308.11,74.25 308.04,74.31 308.04,75.33 308.17,75.46 308.62,75.46
GND on TOP (solid shape): 24.72,45.55 25.29,45.55 25.53,45.31 25.53,44.39 25.43,44.29 21.87,44.29 21.75,44.42 21.75,45.48 21.82,45.56 24.72,45.56
GND on TOP (solid shape): 28.41,14.64 28.41,13.11 28.34,13.03 27.01,13.03 26.92,13.12 26.92,14.59 27.03,14.7 28.35,14.7
GND on TOP (solid shape): 36.97,12.82 36.97,5.92 36.66,5.61 32.87,5.61 32.77,5.71 32.77,12.98 33.13,13.35 36.45,13.35
GND on TOP (solid shape): 55.42,70.22 55.42,68.21 55.28,68.07 54.19,68.07 54.06,68.19 54.06,70.23 54.19,70.36 55.29,70.36
GND on TOP (solid shape): 102.03,9.77 102.03,8.81 102.25,8.59 102.25,8.33 102.15,8.24 101.76,8.24 101.47,8.53 101.47,9.73 101.52,9.78 102.02,9.78
GND on TOP (solid shape): 108.62,9.11 108.62,5.44 108.54,5.36 108.1,5.36 108.08,5.38 108.08,7.02 107.91,7.19 107.91,9.18 107.99,9.26 108.47,9.26
GND on TOP (solid shape): 125.26,59.06 125.26,58.68 125.14,58.57 125.14,57.49 125.08,57.43 124.62,57.43 124.59,57.46 124.59,59.07 124.72,59.2 125.12,59.2
GND on TOP (solid shape): 139.69,84.98 139.69,84.68 139.33,84.33 138.72,84.33 138.49,84.11 138.09,84.11 138.05,84.14 138.05,85.08 138.11,85.14 139.53,85.14
GND on TOP (solid shape): 149.4,68.94 149.4,67.59 149.3,67.49 148.99,67.49 148.89,67.59 148.89,67.98 148.26,68.62 148.26,69.6 148.32,69.66 148.68,69.66
GND on TOP (solid shape): 158.25,67.96 158.25,65.04 157.87,64.66 156.85,64.66 156.6,64.92 156.6,68.19 156.71,68.31 157.9,68.31
GND on TOP (solid shape): 167.07,8.28 167.07,7.34 167.03,7.31 166.68,7.31 166.44,7.54 166.17,7.54 166.03,7.68 166.03,7.87 166.46,8.31 167.05,8.31
GND on TOP (solid shape): 171.85,14.34 171.85,14.23 171.97,14.12 171.97,13.51 171.93,13.47 170.95,13.47 170.9,13.51 170.9,14.31 171.25,14.66 171.53,14.66
GND on TOP (solid shape): 186.23,83.71 186.23,80.47 186.04,80.28 184.55,80.28 184.36,80.47 184.36,83.41 184.92,83.97 185.98,83.97
GND on TOP (solid shape): 289.79,77.36 289.79,76.77 290,76.56 290,75.57 289.96,75.53 289.23,75.53 289.01,75.75 289.01,77.16 289.27,77.41 289.74,77.41
GND on TOP (solid shape): 304.87,50.63 304.87,50.37 305.19,50.06 305.19,49.55 302.84,49.55 302.84,50.12 303.47,50.12 304.11,50.75 304.74,50.75
GND on TOP (solid shape): 313.63,73.36 315.16,73.36 315.16,72.85 313.7,72.85 313.44,72.6 313.12,72.6 313,72.73 313,73.55 313.12,73.68 313.31,73.68
GND on TOP (solid shape): 79.06,57.42 84.97,57.42 84.97,55.71 84.71,55.45 77.03,55.45 76.84,55.64 76.84,57.74 77.03,57.93 78.55,57.93
GND on TOP (solid shape): 135.35,107.69 135.35,106.63 135.34,106.62 135.3,106.62 134.05,106.62 133.94,106.74 133.94,107.72 134.07,107.85 135.19,107.85
GND on TOP (solid shape): 145.61,106.25 145.61,105.3 145.48,105.17 144.4,105.17 144.34,105.24 144.34,106.25 144.47,106.38 145.48,106.38
GND on TOP (solid shape): 174.43,20.05 174.43,16.58 174.1,16.25 171.19,16.25 171.18,16.26 170.79,16.26 170.4,16.64 170.4,20.36 170.77,20.72 173.76,20.72
GND on TOP (solid shape): 188.29,5.48 188.29,4.59 187.95,4.25 187.9,4.22 187.61,4.22 187.27,4.56 187.27,5.49 187.31,5.53 188.25,5.53
GND on TOP (solid shape): 285.67,72.46 285.67,71.92 285.53,71.79 285.53,71.41 285.4,71.27 284.42,71.27 284.26,71.43 284.26,72.34 284.41,72.49 284.44,72.5 285.62,72.5
GND on TOP (solid shape): 57.5,14.42 57.5,13.98 57.63,13.85 58.63,13.85 58.68,13.8 58.68,13.41 58.64,13.37 57.3,13.37 56.95,13.71 56.95,14.31 57.16,14.52 57.41,14.52
GND on TOP (solid shape): 58.72,44.63 58.72,41.63 58.54,41.45 57.66,41.45 57.33,41.77 57.33,44.62 57.34,44.62 57.34,44.88 57.41,44.95 58.4,44.95
GND on TOP (solid shape): 130.02,14.42 130.02,14.2 129.09,13.27 127.44,13.27 127.34,13.36 126.87,13.36 126.84,13.39 126.84,14.04 126.87,14.07 129.06,14.07 129.55,14.56 129.88,14.56
GND on TOP (solid shape): 139.43,12.14 139.43,11.71 139.52,11.62 139.52,11.36 139.41,11.25 139.16,11.25 138.71,11.71 138.33,11.71 138.3,11.75 138.3,12.21 138.36,12.28 139.3,12.28
GND on TOP (solid shape): 169.11,35.13 169.11,34.31 169.68,33.74 169.68,32.72 169.23,32.28 168.47,32.28 168.47,33.74 168.72,33.99 168.72,35.26 168.79,35.32 168.92,35.32
GND on TOP (solid shape): 307.75,90.95 307.9,90.95 307.94,90.91 308.78,90.91 309,90.7 309,89.93 308.74,89.68 306.84,89.68 306.68,89.68 306.39,89.97 306.39,90.78 306.56,90.95
GND on TOP (solid shape): 181.97,12.15 181.97,11.61 181.86,11.5 181.57,11.5 181.46,11.6 181.46,11.94 181.35,12.05 180.4,12.05 180.38,12.08 180.38,12.52 180.39,12.54 181.58,12.54
GND on TOP (solid shape): 108.52,5.13 108.52,4.03 108.42,3.78 108.34,3.53 107.76,2.95 107.48,2.95 107.26,3.18 107.26,3.3 108.07,4.11 108.07,5.12 108.11,5.17 108.48,5.17
GND on TOP (solid shape): 109.52,12.13 109.52,11.51 109.51,11.49 107.34,11.49 107.1,11.73 105.52,11.73 105.25,12.01 104.67,12.01 104.1,11.44 103.67,11.44 103.54,11.57 103.54,11.77 104.18,12.41 109.23,12.41
GND on TOP (solid shape): 191.03,10.04 191.03,8.82 190.03,7.81 189.64,7.81 189.46,7.99 189.46,8.49 190.01,9.03 190.01,9.67 189.83,9.85 188.94,9.85 188.83,9.96 188.83,10.34 188.91,10.42 190.65,10.42
GND on TOP (solid shape): 128.27,58.46 128.27,57.58 128.62,57.23 128.62,57.02 128.57,56.97 128.57,55.89 128.53,55.84 128.11,55.84 128.08,55.87 128.08,57.28 127.76,57.6 127.76,58.44 127.82,58.5 128.23,58.5
GND on TOP (solid shape): 182.89,98.63 182.89,91.97 182.33,91.41 181.41,91.41 180.14,92.68 180.14,95.67 180.55,96.08 180.55,96.92 180.32,97.15 179.79,97.15 179.79,98.72 180.04,98.98 182.54,98.98
GND on TOP (solid shape): 21.66,75.27 21.66,74.95 21.53,74.82 20.9,74.82 20.71,74.63 20.71,73.3 20.45,73.04 18.17,73.04 17.91,73.3 17.91,74.82 18.29,75.2 19.37,75.2 19.56,75.39 21.53,75.39
GND on TOP (solid shape): 45.23,49.46 47.07,49.46 47.15,49.38 47.15,48.59 46.86,48.29 42.37,48.29 42.27,48.39 41.19,48.39 40.98,48.61 40.98,49.75 41.59,50.37 44.32,50.37
GND on TOP (solid shape): 114.64,110 114.64,109.26 114.53,109.16 112.83,109.16 112.37,108.7 112.37,108.57 111.7,108.57 111.52,108.76 111.52,109.26 111.52,109.27 111.52,109.72 112.03,110.23 114.41,110.23
GND on TOP (solid shape): 126.55,57.6 126.55,56.51 126.07,56.03 126.07,55.39 125.89,55.21 125.66,55.21 125.13,55.73 125.13,56.68 125.16,56.71 125.86,56.71 126.1,56.95 126.1,57.62 126.12,57.63 126.51,57.63
GND on TOP (solid shape): 127.78,26.75 127.78,25.52 128.42,24.88 129.21,24.88 129.58,25.25 129.58,26.46 129.67,26.55 130.1,26.55 130.21,26.44 130.21,24.94 129.51,24.23 128.19,24.23 127.15,25.27 127.15,26.84 127.18,26.86 127.66,26.86
GND on TOP (solid shape): 21.13,53.07 21.13,52.42 21.23,52.32 21.73,52.32 21.79,52.26 21.79,51.94 21.73,51.87 20.47,51.87 20.19,51.6 19.83,51.6 19.75,51.68 19.75,51.92 20.36,52.53 20.36,53.04 20.43,53.1 21.1,53.1
GND on TOP (solid shape): 124.85,30.5 124.85,29.74 124.72,29.61 123.75,29.61 123.75,29.68 123.63,29.68 123.58,29.74 122.94,29.74 122.69,29.48 121.11,29.48 120.91,29.48 120.66,29.74 120.66,31.26 121.01,31.62 123.73,31.62
GND on TOP (solid shape): 131.86,104.99 131.86,104.32 131.75,104.21 129.09,104.21 128.85,104.45 128.85,105.29 129.17,105.62 131.23,105.62
GND on TOP (solid shape): 163.33,115.97 163.33,112.41 163.01,112.1 160.6,112.1 160.34,112.35 160.03,112.35 159.9,112.48 159.9,112.73 160.09,112.92 161.1,112.92 161.36,112.67 162.12,112.67 162.37,112.92 162.37,116.16 163.14,116.16
GND on TOP (solid shape): 287.42,86.07 287.42,83.09 287.04,82.71 284.72,82.71 284.62,82.82 284.62,84.02 284.04,84.59 284.04,85.32 284.08,85.35 285.49,85.35 285.49,85.35 285.69,85.54 285.69,85.65 285.73,85.69 285.73,86.13 285.79,86.19 287.3,86.19
GND on TOP (solid shape): 305.38,28.72 305.38,28.28 305.5,28.15 305.5,27.51 305.44,27.45 304.93,27.45 304.87,27.51 304.87,27.89 304.86,27.91 304.86,27.92 304.84,27.92 304.81,27.96 304.36,27.96 304.3,28.02 304.3,28.66 304.42,28.78 305.31,28.78
GND on TOP (solid shape): 47.83,101.45 47.83,100.56 47.06,99.79 45.93,99.79 45.49,99.35 45.49,98.15 45.96,97.68 45.96,96.86 46,96.83 46,94.82 45.74,94.57 44.13,94.57 43.9,94.79 43.9,97.72 44.22,98.03 44.22,101.47 44.51,101.77 47.5,101.77
GND on TOP (solid shape): 132.78,117.56 132.78,116.67 132.69,116.58 130.62,116.58 130.62,116.8 130.48,116.95 129.64,116.95 129.44,116.74 129.44,115.3 129.4,115.26 128.86,115.26 128.79,115.32 128.79,117.1 129.65,117.96 132.38,117.96
GND on TOP (solid shape): 69.65,81.91 69.65,80.15 70.04,79.76 70.04,78.33 69.86,78.15 69.09,78.15 68.84,77.89 68.84,74.84 68.66,74.66 66.83,74.66 66.77,74.73 66.77,75.29 66.53,75.53 66.53,82.71 66.65,82.83 68.73,82.83
GND on TOP (solid shape): 83.63,68.03 84.59,68.03 85.03,67.58 85.73,67.58 86.3,67.01 88.52,67.01 89.03,66.5 89.03,63.77 88.78,63.52 74.43,63.52 74.05,63.9 74.05,67.96 74.36,68.28 83.38,68.28
GND on TOP (solid shape): 120.02,106.96 120.02,105.38 120.02,105.37 120.32,105.07 121.41,105.07 121.49,104.98 121.4,103.75 119.26,103.75 118.82,104.19 118.82,106.79 119.08,107.04 119.94,107.04
GND on TOP (solid shape): 125.94,107.69 125.94,107.19 125.44,106.69 125.44,106.18 125.37,106.11 124.86,106.11 124.44,106.53 123.57,106.53 123.41,106.36 123.41,105.6 123.19,105.38 122.88,105.38 122.65,105.6 122.65,107.66 122.81,107.81 125.82,107.81
GND on TOP (solid shape): 128.95,85.13 128.95,83.25 128.91,83.22 128.88,83.2 127.74,82.05 127.74,81.05 127.61,80.93 126.25,80.93 126.07,81.12 126.07,82.95 126.83,83.71 126.83,85.21 127.06,85.44 127.06,85.44 128.63,85.44
GND on TOP (solid shape): 168.88,118.5 168.88,117.43 168.24,116.79 167.15,116.79 166.73,117.22 165.97,117.22 165.87,117.11 165.87,116.5 165.84,116.46 165.81,116.43 165.21,116.43 165.16,116.48 165.16,118.74 165.16,118.76 165.28,118.89 168.48,118.89
GND on TOP (solid shape): 216.23,8.27 216.23,7.74 216.46,7.51 216.62,7.51 216.79,7.33 216.79,6.18 216.6,5.99 215.91,5.99 215.8,6.09 215.8,6.66 215.27,7.19 215.27,8.34 215.4,8.46 216.03,8.46
GND on TOP (solid shape): 299.9,86.3 299.9,85.76 300.29,85.37 300.29,84.05 300.24,84 299.85,84 299.73,84.12 299.73,85.25 299.46,85.51 299.39,85.61 299.29,85.69 299.21,85.76 299.21,86.42 299.28,86.48 299.72,86.48
GND on TOP (solid shape): 29.77,55.75 29.77,54.48 29.7,54.4 28.55,54.4 28.5,54.35 28.45,54.35 28.43,54.32 28.4,54.32 28.4,54.3 28.3,54.2 28.3,54.14 28.25,54.09 27.87,54.09 27.87,54.45 27.87,54.45 28.17,54.45 28.45,54.73 28.45,55.8 28.63,55.97 29.55,55.97
GND on TOP (solid shape): 71.57,85.44 71.57,84.35 71.7,84.22 72.46,84.22 72.59,84.35 72.59,85.49 73.47,85.49 73.47,84.92 73.6,84.79 74.62,84.79 74.81,84.6 74.81,83.46 74.62,83.27 70.62,83.27 70.17,83.71 70.17,85.41 70.31,85.55 71.46,85.55
GND on TOP (solid shape): 110.21,93.88 110.21,91.78 110.15,91.72 110.12,91.75 109.89,91.81 109.7,91.69 108.34,91.69 108.22,91.8 108.22,93.92 108.56,94.25 109.84,94.25
GND on TOP (solid shape): 313.19,63 313.19,61.28 312.97,61.05 312.51,61.05 312.2,61.37 312.2,61.41 312.15,61.41 312.05,61.52 311.61,61.52 311.45,61.68 311.45,62.27 311.57,62.39 311.57,63.66 311.58,63.67 311.68,63.72 311.75,63.79 312.4,63.79
GND on TOP (solid shape): 264.86,42.31 264.86,41.86 264.29,41.86 263.97,41.55 263.97,40.34 264.64,39.68 265.11,39.68 265.24,39.55 265.24,38.5 265.38,38.36 265.38,37.69 265.24,37.55 263.78,37.55 263.34,38 263.34,39.2 262.13,40.4 262.13,41.42 262.39,41.67 262.39,42.31 262.45,42.37 264.8,42.37
GND on TOP (solid shape): 11.18,99.79 11.18,99.21 11.07,99.1 10.81,99.1 10.8,99.09 9.6,99.09 9.18,98.68 8.75,98.68 8.46,98.39 7.49,98.39 7.43,98.44 7.43,98.82 7.47,98.86 7.59,98.86 7.69,98.96 7.83,98.96 8.84,99.97 11,99.97
GND on TOP (solid shape): 196.06,7.24 196.06,5.82 195.55,5.31 195.55,2.71 195.47,2.63 192.86,2.63 192.76,2.73 192.76,3.02 192.83,3.09 193.65,3.09 193.9,3.35 193.9,5.23 193.69,5.44 193.23,5.44 192.75,5.92 192.75,7.09 193.03,7.37 195.92,7.37
GND on TOP (solid shape): 303.67,69.02 303.67,67.85 303.4,67.59 303.4,66.05 303.3,65.94 303.27,65.94 303.23,65.91 303.09,65.86 302.95,65.91 302.47,66.39 302.47,68.15 302.5,68.18 302.99,68.18 303.17,68.36 303.17,69.02 303.2,69.05 303.64,69.05
GND on TOP (solid shape): 14.48,29.96 14.48,28.08 14.66,27.9 15.69,27.9 15.82,27.78 15.82,26.95 15.71,26.84 14.83,26.84 14.67,26.69 14.67,24.89 14.38,24.59 11.75,24.59 11.69,24.66 11.69,24.72 11.64,24.72 11.64,25.5 11.68,25.5 11.68,27.1 11.64,27.1 11.64,28.87 11.64,28.88 11.64,29.98 11.85,30.18 14.26,30.18
GND on TOP (solid shape): 105.29,96.94 105.29,92.47 105.26,92.44 105.17,92.44 105.08,92.53 105.08,93.85 104.98,93.95 102.34,93.95 102.11,93.72 102.11,92.5 102.07,92.45 101.92,92.45 101.88,92.48 101.88,93.74 101.68,93.95 98.28,93.95 98.28,96.77 96.83,96.77 96.78,96.82 96.78,96.92 96.83,96.97 105.26,96.97
GND on TOP (solid shape): 101.73,65.87 102.18,65.87 102.18,65.55 101.67,65.55 101.54,65.42 101.54,64.53 102.11,63.96 102.49,63.96 102.49,63.58 102.45,63.54 100.57,63.54 100.34,63.77 99.7,63.77 99.57,63.9 99.57,64.09 99.7,64.22 100.21,64.22 100.78,64.79 100.78,65.17 101.1,65.49 101.1,66.06 101.22,66.19 101.41,66.19
GND on TOP (solid shape): 132.79,53.93 132.79,53.59 132.78,53.58 132.48,53.58 132.46,53.56 132.29,53.47 132.2,53.3 131.72,52.82 131.52,52.82 131.39,52.94 131.39,53.14 131.53,53.28 131.68,53.28 131.76,53.36 131.76,53.69 131.8,53.73 132.14,53.73 132.36,53.94 132.77,53.94
GND on TOP (solid shape): 36.02,80.4 36.18,80.26 36.38,80.21 36.48,80.21 36.94,79.75 36.94,79.42 36.85,79.34 36.28,79.34 36.26,79.36 35.45,79.36 35.38,79.43 34.84,79.43 34.77,79.36 34.59,79.36 34.51,79.44 34.51,79.68 34.51,79.72 34.51,79.76 34.51,80.15 34.61,80.26 35.39,80.26 35.53,80.4
GND on TOP (solid shape): 139.44,116.1 139.7,115.89 139.98,115.7 140.47,115.21 141.24,115.21 141.91,115.14 142.58,115.19 142.82,114.95 142.82,114.25 142.25,114.25 141.99,114 140.53,114 140.02,114.51 138.24,114.51 137.99,114.76 137.99,115.84 138.24,116.1
GND on TOP (solid shape): 142.08,110.58 142.08,109.94 142.09,109.94 142.39,109.63 143.17,109.63 143.24,109.57 143.24,109.41 143.18,109.35 142.16,109.35 142.08,109.27 142.08,108.91 142.04,108.86 140.41,108.86 138.88,107.32 138.06,107.32 138.01,107.38 138.01,108.08 138.13,108.2 138.78,108.2 138.92,108.34 138.92,109.5 139.04,109.62 140.06,109.62 140.38,109.94 140.38,110.58 140.4,110.6 142.07,110.6
GND on TOP (solid shape): 152.05,108.37 153.32,108.37 153.45,108.25 153.45,107.48 154.72,106.21 154.72,105.43 154.59,105.3 153.95,105.3 153.74,105.52 152.29,105.52 150.53,105.52 150.44,105.62 150.44,107.14 149.99,107.59 147.76,107.59 147.6,107.74 147.6,109.16 147.81,109.37 151.06,109.37
GND on TOP (solid shape): 287.97,76.49 287.97,75.9 287.66,75.58 287.16,75.58 286.91,75.33 286.91,74.51 286.8,74.41 286.25,74.41 285.94,74.71 285.94,75.69 285.95,75.74 286,75.79 286,75.91 286.02,75.93 286.11,76 286.16,76.11 286.39,76.34 286.45,76.39 286.5,76.45 287.33,76.45 287.48,76.6 287.86,76.6
GND on TOP (solid shape): 120.08,68.34 120.08,68.15 119.96,68.03 119.26,68.03 119,67.77 119,66.95 118.04,66.95 117.99,67 117.99,67.93 117.9,68.03 117.36,68.03 117.2,67.87 117.19,67.83 117.19,67.79 117.19,67.51 117.18,67.51 115.72,67.51 115.71,67.52 115.7,67.52 115.7,67.84 115.58,67.96 114.88,67.96 114.75,68.09 114.75,68.34 114.88,68.47 119.96,68.47
GND on TOP (solid shape): 157.08,118.86 157.08,118.26 156.66,117.84 156.66,116.62 156.6,116.55 156.6,114.8 156.04,114.24 156.04,113.32 156.37,112.99 156.37,111.37 156.37,111.27 156.28,111.19 155.67,111.19 155.58,111.09 155.58,110.23 155.49,110.14 155.39,110.14 155.3,110.23 155.3,111.27 154.92,111.65 154.92,112.72 155.3,113.1 155.3,114.32 154.44,115.18 154.44,116.35 153.99,116.79 153.99,118.32 154.69,119.02 156.93,119.02
GND on TOP (solid shape): 131.71,112.94 131.71,112.23 131.83,112.11 131.83,112.1 131.91,112.02 132.77,112.02 132.85,111.93 132.85,111.72 132.8,111.67 131.73,111.67 131.71,111.64 131.71,111.23 131.69,111.22 129.96,111.22 129.96,111.22 129.29,110.55 129.29,110.18 128.91,109.79 127.67,109.79 127.57,109.89 127.57,110.37 127.79,110.58 128.32,110.58 128.73,110.99 128.73,111.84 128.87,111.98 129.74,111.98 129.96,112.2 129.96,112.94 130.01,112.99 131.65,112.99
GND on TOP (solid shape): 147.24,67.39 147.24,66.76 147.46,66.53 147.91,66.53 148.02,66.42 148.02,65.87 147.96,65.8 147.58,65.8 147.07,65.3 147.07,64.79 146.88,64.6 146.08,64.6 145.61,64.13 145.06,64.13 144.99,64.2 144.99,64.47 145.06,64.47 145.06,64.56 145.09,64.58 145.09,66.06 145.06,66.08 145.06,66.12 145.03,66.12 144.83,66.32 144.83,66.47 144.82,66.47 144.82,66.55 144.81,66.57 144.81,66.95 145.04,67.18 146.28,67.18 146.64,67.53 147.1,67.53
GND on TOP (solid shape): 101.81,88.69 101.99,88.5 101.99,88.42 102.48,87.94 102.48,87.36 102.46,87.32 102.43,87.31 102.3,87.28 102.18,87.21 102.12,87.18 102.05,87.21 101.93,87.28 101.8,87.31 101.77,87.32 101.75,87.36 101.75,87.63 100.83,88.56 100.83,89.01 101.81,89.01
GND on TOP (solid shape): 305.26,46.45 305.53,46.23 305.85,46.12 305.86,46.11 305.92,46.06 306.65,46.06 308.23,44.47 308.62,44.47 308.68,44.4 308.68,43.39 308.62,43.33 307.15,43.33 307.09,43.26 304.68,43.26 304.11,43.83 304.11,44.28 304.23,44.4 305.25,44.4 305.44,44.6 305.44,45.36 305.12,45.67 303.53,45.67 303.5,45.71 303.5,45.72 303.43,45.82 303.34,45.9 303.34,46.39 303.4,46.45
GND on TOP (solid shape): 88.14,7.8 88.16,7.76 88.21,7.71 88.24,7.66 88.27,7.55 88.24,7.45 88.22,7.41 88.15,7.34 88.12,7.29 88.07,7.26 88.05,7.27 87.68,7.12 87.68,6.72 87.7,6.68 87.57,6.54 87.12,6.54 87.11,6.56 87.11,7.53 87.37,7.79 87.56,7.79 87.59,7.79 87.63,7.8
GND on TOP (solid shape): 108.36,54.25 108.36,52.34 108.23,52.22 107.35,52.22 107.22,52.34 107.22,53.09 107.5,53.09 107.5,53.03 107.51,52.98 107.52,52.93 107.55,52.89 107.58,52.84 107.61,52.81 107.66,52.78 107.7,52.75 107.75,52.74 107.8,52.73 107.86,52.73 107.91,52.74 107.96,52.75 108,52.78 108.04,52.81 108.08,52.84 108.11,52.89 108.14,52.93 108.15,52.98 108.16,53.03 108.16,53.09 108.15,53.14 108.14,53.19 108.11,53.23 108.08,53.27 108.04,53.31 108,53.34 107.96,53.37 107.91,53.38 107.86,53.39 107.8,53.39 107.75,53.38 107.7,53.37 107.66,53.34 107.61,53.31 107.58,53.27 107.55,53.23 107.52,53.19 107.51,53.14 107.5,53.09 107.22,53.09 107.22,54.25 107.4,54.42 108.18,54.42
GND on TOP (solid shape): 103.08,88.62 103.68,88.02 103.68,87.36 103.67,87.32 103.63,87.31 103.5,87.28 103.39,87.21 103.32,87.18 103.25,87.21 103.14,87.28 103.01,87.31 102.98,87.32 102.96,87.36 102.96,88.22 102.85,88.33 102.82,88.39 102.8,88.42 102.51,88.71 102.47,88.74 102.42,88.76 102.4,88.78 102.37,88.89 102.47,88.96 103.08,88.96
GND on TOP (solid shape): 61.17,75.24 61.17,74.4 61.66,73.91 61.66,71.97 62.03,71.6 62.03,58.89 61.61,58.47 59.19,58.47 59.13,58.53 59.13,59.08 59.37,59.32 59.37,62.02 59.43,62.09 59.96,62.09 60.08,62.21 60.08,62.88 59.9,63.06 59.45,63.06 59.37,63.14 59.37,63.91 59.05,64.23 59.05,67.01 59.34,67.31 59.34,71.23 59.35,71.23 59.35,71.32 59.66,71.63 59.9,71.63 60.03,71.77 60.03,72.4 59.95,72.48 59.72,72.48 59.69,72.48 59.62,72.48 59.34,72.76 59.34,73.62 59.25,73.7 58.72,73.7 58.64,73.78 58.64,75.15 58.89,75.4 61.01,75.4
GND on TOP (solid shape): 113.43,54.13 113.43,53.72 113.86,53.29 113.86,52.53 113.48,52.15 112.97,52.15 112.78,52.34 112.78,53.06 112.99,53.06 112.99,53.03 112.99,52.98 113.01,52.93 113.03,52.89 113.06,52.84 113.1,52.81 113.14,52.78 113.19,52.75 113.24,52.74 113.29,52.73 113.34,52.73 113.39,52.74 113.44,52.75 113.49,52.78 113.53,52.81 113.57,52.84 113.6,52.89 113.62,52.93 113.64,52.98 113.65,53.03 113.65,53.09 113.64,53.14 113.62,53.19 113.6,53.23 113.57,53.27 113.53,53.31 113.49,53.34 113.44,53.37 113.39,53.38 113.34,53.39 113.29,53.39 113.24,53.38 113.19,53.37 113.14,53.34 113.1,53.31 113.06,53.27 113.03,53.23 113.01,53.19 112.99,53.14 112.99,53.09 112.99,53.06 112.78,53.06 112.78,54.04 112.9,54.16 113.41,54.16
GND on TOP (solid shape): 182.5,120 182.5,119.96 182.53,119.73 182.59,119.51 182.66,119.38 182.74,119.26 182.8,119.18 182.84,119.14 182.94,119.04 183.02,118.98 183.1,118.93 183.27,118.84 183.45,118.78 183.59,118.76 183.73,118.75 183.75,118.75 187.4,118.75 187.4,118.5 183.75,118.5 182.7,118.92 182.25,119.96 182.25,120.55 182.5,120.55
GND on TOP (solid shape): 54.49,87.78 54.49,87.39 54.74,87.14 55.76,87.14 55.86,87.04 55.86,85.47 54.74,84.35 52.79,84.35 52.69,84.45 52.69,84.99 53.23,85.52 54.49,85.52 54.49,85.47 54.49,85.42 54.51,85.37 54.53,85.32 54.56,85.27 54.6,85.24 54.64,85.2 54.69,85.18 54.74,85.16 54.79,85.14 54.84,85.14 54.9,85.14 54.95,85.16 55,85.18 55.04,85.2 55.09,85.24 55.12,85.27 55.15,85.32 55.17,85.37 55.19,85.42 55.2,85.47 55.2,85.52 55.19,85.58 55.17,85.63 55.15,85.67 55.12,85.72 55.09,85.76 55.04,85.79 55,85.82 54.95,85.84 54.9,85.85 54.84,85.85 54.79,85.85 54.74,85.84 54.69,85.82 54.64,85.79 54.6,85.76 54.56,85.72 54.53,85.67 54.51,85.63 54.49,85.58 54.49,85.52 53.23,85.52 53.23,86.8 53,87.02 51.62,87.02 51.5,87.14 51.5,87.9 51.57,87.97 54.3,87.97
GND on TOP (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.36,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.4 325.19,40.4 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on TOP (solid shape): 120.97,65.99 120.78,65.8 120.78,64.63 120.97,64.44 120.97,64.28 121.35,63.9 121.35,62.95 121.86,62.44 121.86,61.95 121.42,61.51 121.42,60.15 121.54,60.03 121.86,60.03 121.93,59.96 121.93,59.52 121.8,59.39 120.59,59.39 120.34,59.14 120.34,56.98 120.57,56.75 122.01,56.75 122.06,56.7 122.06,55.54 122.17,55.42 122.17,55.23 122.04,55.1 121.87,55.1 121.14,55.83 120.58,55.83 120.43,55.98 120.43,56.11 120.34,56.2 119.18,56.2 119.11,56.13 119.11,55.77 119.05,55.71 118.7,55.71 118.69,55.72 118.69,56.75 118.78,56.84 118.93,56.84 119.07,56.97 119.07,57.23 119.19,57.36 119.51,57.36 119.64,57.49 119.64,62.57 119.13,63.07 119.13,64 119.16,64.03 119.77,64.03 120.21,64.46 120.21,65.93 120.59,66.31 120.59,66.76 120.97,66.76
GND on TOP (solid shape): 2.85,8.4 4.45,10 6.05,8.4 6.05,6.67 7.78,5.21 8.45,3.05 8.45,3.05 8.45,0.25 2.1,0.25 1.57,0.47 1.35,1 1.35,3.05 1.36,3.05 1.36,5.53 2.04,6.19 2.85,6.67
GND on TOP (solid shape): 109.15,1.99 113.1,6.1 117.15,2.1 117.15,2.04 117.15,0 116.55,0 113.15,-1.9 109.75,0 109.15,0
GND on TOP (solid shape): 237,1.46 240.98,5.5 245,1.5 245,1.43 245,0 244.71,0 241,-2.5 237.29,0 237,0
GND on TOP (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 320.4,56.9 320.36,56.93 320.36,56.94 320.14,57.13 319.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
GND on TOP (solid shape): outline of 132 points within 28.08,17.91 34.74,22.37
GND on TOP (solid shape): 17.48,68.49 17.48,65.79 15.72,64.03 4.51,64.03 4.09,63.74 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.87,34.96 3.26,34.11 2.75,34.11 2.51,34.6 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 16.74,69.23
GND on TOP (solid shape): 247.31,15.46 247.3,15.2 247.3,14.8 246.15,14.8 245.93,14.8 245.71,14.77 242.9,11.74 245.33,8.4 245.74,8.32 246.15,8.3 247.3,8.3 247.3,7.55 246.15,7.55 242.15,11.55 246.15,15.55 247.07,15.55 247.07,15.55 247.32,15.55
GND on TOP (solid shape): 108.4,109.35 108.4,109.15 108.37,109.12 108.37,108.41 108.4,108.38 108.4,107.73 108.38,107.68 108.38,107.64 108.38,107.23 108.38,107.19 108.4,107.14 108.4,106.85 107.75,106.85 107.75,105.94 107.98,105.94 107.98,105.74 107.62,105.74 107.62,104.37 107.57,104.28 107.47,104.29 106.96,104.17 107.12,103.67 107.12,103.53 106.11,103.53 106.04,103.6 106.04,103.8 106.4,103.8 106.4,103.96 106.76,103.96 106.76,105.74 106.4,105.74 106.4,105.94 106.69,105.94 106.69,106.85 106.04,106.85 106.04,107.22 105.97,107.29 105.97,107.33 105.47,107.83 105.42,107.83 104.99,108.27 104.97,108.31 104.94,108.34 104.65,108.64 104.62,108.66 104.57,108.69 104.3,108.96 103.88,108.96 103.79,109.05 103.79,109.13 103.79,109.14 103.79,109.23 103.83,109.31 103.92,109.33 104.22,109.34 104.47,109.53 104.55,109.57 104.63,109.53 105.04,109.31 105.45,109.51 105.54,109.55 105.62,109.51 106.05,109.29 106.48,109.51 106.56,109.55 106.65,109.51 107.43,109.48 107.31,110.26 107.29,110.27 107.29,110.35 107.4,110.35
GND on TOP (solid shape): 268.15,108.55 270.18,107.27 269.9,104.89 270.75,98.08 267.36,104.05 265.65,104.05 265.65,105.05 268.15,105.05 269.4,106.3 268.15,107.55 266.65,107.55 266.65,108.55
GND on TOP (solid shape): 306.7,115.19 307.12,114.77 307.18,114.69 307.2,114.59 307.2,113.55 307.86,111.96 309.45,111.3 309.95,111.3 311.89,110.49 312.7,108.55 312.7,101.95 313.06,101.06 313.95,100.7 323.8,100.7 325.74,99.89 326.55,97.95 326.55,90.1 325.15,90.1 324.62,89.88 324.4,89.35 324.4,87.35 323,87.35 322.26,86.73 322.75,85.89 322.75,85.36 322.24,85.36 322.24,85.59 321.8,87 323,87.86 323.89,87.86 323.89,89.35 324.26,90.24 325.15,90.61 326.04,90.61 326.04,97.95 325.38,99.53 323.8,100.19 317.38,100.19 312.97,95.78 308.62,95.78 306.58,97.81 306.58,109.42 305.11,110.89 305.1,110.89 305.1,118.58 306.7,118.58
GND on TOP (solid shape): outline of 92 points within 0.25,79.65 75.39,119.65
GND on TOP (solid shape): outline of 98 points within 30.82,78.69 33.91,82.39
GND on TOP (solid shape): outline of 113 points within 1.35,0.25 327.8,32.72
GND on TOP (solid shape): outline of 3496 points within 82.65,38.34 288,120.8
GND on BOTTOM (solid shape): 5.47,29.16 5.47,20.47 5.4,20.4 4.2,20.4 3.69,20.91 3.69,29.16 3.82,29.29 5.34,29.29
GND on BOTTOM (solid shape): 35.13,9.23 35.13,7.74 34.91,7.51 32.85,7.51 32.77,7.59 32.77,9.17 32.99,9.39 34.97,9.39
GND on BOTTOM (solid shape): 46.66,90.62 46.66,89.25 46.5,89.08 45.01,89.08 44.86,89.24 44.86,90.71 44.98,90.82 46.46,90.82
GND on BOTTOM (solid shape): 152.26,57.61 152.26,57.29 152.06,57.09 150.94,57.09 150.92,57.11 150.92,58.04 150.94,58.07 151.81,58.07
GND on BOTTOM (solid shape): 159.03,47.46 159.03,45.51 158.76,45.23 157.99,45.23 157.62,45.6 157.62,47.5 157.77,47.64 158.85,47.64
GND on BOTTOM (solid shape): 188.54,23.2 189.17,23.2 189.17,18.62 185.62,18.62 185.3,18.94 185.3,23.77 185.49,23.96 187.77,23.96
GND on BOTTOM (solid shape): 288.42,95.15 288.42,94.32 287.99,93.89 284.72,93.89 284.55,94.06 284.55,95.2 284.74,95.4 288.17,95.4
GND on BOTTOM (solid shape): 52.38,56.01 52.38,54.51 52.24,54.37 48.07,54.37 47.76,54.69 47.76,56.03 47.82,56.09 52.3,56.09
GND on BOTTOM (solid shape): 53.03,74.63 53.03,71.28 52.63,70.88 44.46,70.88 44.14,71.2 44.14,74.5 44.58,74.95 52.71,74.95
GND on BOTTOM (solid shape): 55.34,70.27 55.34,68.15 55.25,68.06 54.11,68.06 54.04,68.14 54.04,70.24 54.12,70.33 55.28,70.33
GND on BOTTOM (solid shape): 58.77,44.88 58.77,41.5 58.61,41.34 57.73,41.34 57.36,41.7 57.36,44.67 57.69,45 58.65,45
GND on BOTTOM (solid shape): 81.6,67.94 81.6,65.04 81.41,64.85 73.96,64.85 73.79,65.02 73.79,67.93 73.9,68.04 81.5,68.04
GND on BOTTOM (solid shape): 122.74,23 122.74,18.12 122.04,17.42 114.99,17.42 113.99,16.41 103.87,16.41 103.03,17.25 103.03,23.7 103.7,24.36 121.38,24.36
GND on BOTTOM (solid shape): 137.42,86.95 137.42,85.91 137.39,85.89 136.94,85.89 136.83,86 136.83,86.81 136.25,87.4 136.25,87.7 136.4,87.85 136.52,87.85
GND on BOTTOM (solid shape): 145.67,106.32 145.67,105.17 145.55,105.05 144.47,105.05 144.34,105.17 144.34,106.38 144.47,106.51 145.48,106.51
GND on BOTTOM (solid shape): 175.58,93.74 175.58,92.86 175.46,92.73 174.25,92.73 174.12,92.86 174.12,93.68 174.25,93.81 175.52,93.81
GND on BOTTOM (solid shape): 206.44,29.86 206.44,28.28 206.51,28.21 206.51,27.83 206.44,27.77 205.55,27.77 205.11,28.21 205.11,29.42 205.62,29.93 206.38,29.93
GND on BOTTOM (solid shape): 4.75,13.23 4.75,11.47 4.65,11.37 2.85,11.37 2.75,11.47 2.75,13.3 2.85,13.4 4.58,13.4
GND on BOTTOM (solid shape): 28.43,14.6 28.43,13.13 28.33,13.03 27.04,13.03 26.93,13.13 26.93,14.58 27.03,14.68 28.35,14.68
GND on BOTTOM (solid shape): 34.92,7.11 34.92,5.85 34.75,5.69 32.82,5.69 32.76,5.75 32.76,7.13 32.83,7.2 34.82,7.2
GND on BOTTOM (solid shape): 48.28,101.74 48.28,98.47 48.11,98.3 46.38,98.3 45.86,98.82 45.86,99.43 45.52,99.77 44.48,99.77 44.1,100.15 44.1,101.18 44.94,102.03 48,102.03
GND on BOTTOM (solid shape): 49.19,45.07 49.19,44.1 48.96,43.86 46.9,43.86 46.84,43.93 46.84,44.27 46.95,44.38 46.95,45.04 47.11,45.2 49.07,45.2
GND on BOTTOM (solid shape): 156.66,118.7 156.66,116.46 156.49,116.3 156.49,114.78 155.87,114.15 154.6,114.15 154.12,114.64 154.12,118.57 154.37,118.83 156.53,118.83
GND on BOTTOM (solid shape): 174.06,105.17 174.06,100.54 173.87,100.35 173.84,100.35 172.85,99.36 172.19,99.36 172.09,99.46 172.09,100.09 172.41,100.41 172.41,105.24 172.53,105.36 173.87,105.36
GND on BOTTOM (solid shape): 186.23,83.71 186.23,78.45 186.01,78.22 184.36,78.22 184.26,78.33 184.26,83.3 184.92,83.97 185.98,83.97
GND on BOTTOM (solid shape): 31.83,20.42 31.83,19.43 31.92,19.34 32.96,19.34 33.13,19.16 33.13,18.15 32.83,17.86 24.52,17.86 24.41,17.98 24.41,20.24 24.6,20.44 31.81,20.44
GND on BOTTOM (solid shape): 48.95,53.45 48.95,52.35 48.89,52.29 46.56,52.29 46.06,51.78 45.39,51.78 45.34,51.83 45.34,52.85 46.23,53.73 48.66,53.73
GND on BOTTOM (solid shape): 310.84,45.35 310.84,43.9 310.75,43.81 307.24,43.81 307.07,43.64 307.07,41.38 306.96,41.27 305.82,41.27 305.8,41.29 305.8,45.18 306.16,45.54 310.65,45.54
GND on BOTTOM (solid shape): 315.16,73.42 315.54,73.42 315.66,73.3 315.66,72.34 315.54,72.22 313.25,72.22 312.52,72.95 312.52,74.54 312.68,74.69 313.89,74.69
GND on BOTTOM (solid shape): 82.36,57.42 84.97,57.42 85.1,57.3 85.1,55.71 84.84,55.45 73.94,55.45 73.87,55.52 73.87,58.01 74.01,58.15 81.63,58.15
GND on BOTTOM (solid shape): 309.82,34.58 309.82,30.95 309.62,30.75 308.49,30.75 306.9,32.34 304.49,32.34 304.3,32.53 304.3,32.97 307.15,32.97 307.28,33.1 307.28,34.63 307.4,34.74 309.66,34.74
GND on BOTTOM (solid shape): 53.08,91.65 53.07,91.63 53.07,91.55 53.09,91.47 53.09,88.94 53.55,88.49 53.55,87.29 53.29,87.04 50.58,87.04 49.08,88.54 49.08,91.84 49.54,92.3 52.43,92.3
GND on BOTTOM (solid shape): 85.48,103.08 85.51,103.04 86.29,103.04 86.36,102.97 86.36,102.39 86.28,102.3 84.08,102.3 84.02,102.37 84.02,102.82 83.89,102.95 82.75,102.95 82.56,103.14 82.56,104.19 82.85,104.49 84.07,104.49
GND on BOTTOM (solid shape): 9.4,94.21 10.91,94.21 11.18,93.93 11.18,93.62 10.74,93.62 10.36,93.24 9.08,93.24 8.16,94.16 7.24,94.16 7.07,94.33 7.07,94.53 7.14,94.61 8.26,94.61 8.29,94.63 8.98,94.63
GND on BOTTOM (solid shape): 151.52,108.54 152.39,108.54 153.96,106.97 153.96,105.75 153.73,105.52 150.53,105.52 150.44,105.62 150.44,107.14 149.99,107.59 148.72,107.59 148.6,107.71 148.6,109.11 148.85,109.37 150.69,109.37
GND on BOTTOM (solid shape): 56.84,70.8 56.98,70.8 57.08,70.71 59.07,70.71 59.18,70.59 59.18,69.04 59.11,68.97 58.07,68.97 58.02,69.02 58.02,70.29 57.93,70.38 56.65,70.38 56.64,70.38 56.58,70.44 55.61,70.44 55.54,70.51 55.54,71.04 55.63,71.13 56.51,71.13
GND on BOTTOM (solid shape): 44.09,50.34 44.39,50.34 44.48,50.25 44.48,49.4 44.67,49.21 46.33,49.21 46.37,49.17 46.37,48.3 46.32,48.25 43.65,48.25 43.63,48.27 42.41,48.27 42.29,48.39 41.13,48.39 40.9,48.62 40.9,49.52 40.9,49.52 40.9,49.68 41.57,50.34 44.08,50.34
GND on BOTTOM (solid shape): 90.32,67.67 90.32,65.07 89.7,65.07 89.49,64.86 89.49,63.96 89.05,63.52 86.37,63.52 85.92,63.96 83.84,63.96 83.72,64.08 83.72,64.79 83.85,64.92 88.19,64.92 88.55,65.27 88.55,67.66 88.65,67.76 90.23,67.76
GND on BOTTOM (solid shape): 276.74,44.34 276.74,42.59 276.53,42.39 275.8,42.39 275.39,41.98 274.91,41.98 274.81,42.08 274.81,42.52 274.55,42.77 274.55,44.39 275.01,44.85 275.04,44.83 275.23,44.8 275.42,44.85 276.23,44.85
GND on BOTTOM (solid shape): 305.31,44.04 305.31,43.12 304.96,42.77 304.96,41.06 305.01,41.01 305.08,41.01 305.31,40.79 305.31,40.28 305.82,39.77 305.82,37.87 305.57,37.61 303.28,37.61 303.22,37.67 303.22,40.47 303.54,40.79 303.92,40.79 304.14,41.01 304.14,44.04 304.27,44.16 305.18,44.16
GND on BOTTOM (solid shape): 17.28,30.79 17.28,29.42 17.14,29.28 14.68,29.28 14.66,29.26 14.35,29.26 14.14,29.05 14.14,25.74 14.11,25.71 13.1,25.71 13.05,25.66 13.05,24.8 13.05,24.8 13.05,24.56 13.04,24.55 13.04,23.92 12.9,23.79 11.77,23.79 11.63,23.92 11.63,24.61 11.62,24.61 11.62,30.18 11.72,30.28 12.87,30.28 13.52,30.94 17.14,30.94
GND on BOTTOM (solid shape): 280.75,87.65 280.75,84.5 279.91,83.66 279.28,83.66 278.72,83.1 278.72,82.34 278.47,82.09 277.8,82.09 277.55,82.34 277.55,82.59 277.3,82.85 277.27,82.87 276.13,82.87 276.1,82.85 275.21,83.74 275.21,85.84 275.21,86.45 277.2,88.44 278.36,88.44 278.54,88.61 279.79,88.61
GND on BOTTOM (solid shape): 68.67,52.61 68.67,51.93 68.76,51.83 69.45,51.83 69.6,51.98 69.6,52.47 69.76,52.63 71.47,52.63 71.53,52.63 71.63,52.52 71.63,51.45 71.51,51.33 71.51,48.84 71.25,48.58 71.25,47.9 71,47.64 67.7,47.64 66.93,48.41 66.93,49.42 66.88,49.48 66.88,49.49 66.86,49.49 66.68,49.68 66.3,49.68 66.17,49.8 66.17,52.27 66.6,52.69 68.59,52.69
GND on BOTTOM (solid shape): 59.1,61.13 59.1,59.58 59.03,59.52 58.05,59.52 58.04,59.52 57.92,59.52 57.87,59.58 57.87,60.83 57.79,60.9 56.54,60.9 56.54,60.9 56.23,60.85 56.09,60.57 56.09,60.55 55.87,60.33 55.16,60.33 55.07,60.42 55.07,60.94 55.17,61.04 56.1,61.04 56.29,61.23 58.99,61.23
GND on BOTTOM (solid shape): 167.51,118.88 168.29,118.88 168.66,118.51 168.66,117.49 167.77,116.6 167.82,116.55 167.82,115.74 168.18,115.38 168.18,113.81 167.82,113.45 167.82,112.69 168.08,112.44 168.56,112.44 168.74,112.26 168.74,111.93 168.64,111.83 168.1,111.83 167.57,112.36 167.57,113.45 167.38,113.65 166.83,113.65 166.73,113.74 166.73,115.37 167.11,115.75 167.11,116.86 166.76,117.21 165.28,117.21 165.16,117.34 165.16,118.76 165.28,118.89 167.49,118.89
GND on BOTTOM (solid shape): 63.43,78.12 63.43,78.05 63.42,78.04 63.41,77.72 63.66,77.52 63.67,77.52 63.96,77.23 66.29,77.23 66.38,77.15 66.39,77.13 66.39,75.55 66.37,75.53 65.2,75.53 65.17,75.56 65.17,76.86 65.14,76.89 63.9,76.89 63.82,76.91 63.17,77.56 62.74,77.56 62.67,77.63 62.67,78.18 62.71,78.22 63.32,78.22
GND on BOTTOM (solid shape): 9.65,102.51 3.6,102.51 3.6,104.15 3.48,104.43 3.2,104.55 1.46,104.55 1.62,105.24 1.15,105.76 1.15,108.85 2.23,108.85 2.23,108.85 4.19,108.85 6.19,109.35 9.65,109.35
GND on BOTTOM (solid shape): 181.94,13.72 181.94,12.28 181.97,12.14 182.06,12.03 182.06,11.72 181.77,11.43 181.74,11.43 181.66,11.42 181.58,11.39 181.48,11.39 181.43,11.47 181.43,11.98 181.56,12.1 181.61,12.28 181.61,13.72 181.6,13.82 181.95,13.82
GND on BOTTOM (solid shape): 183.01,98.8 183.01,97 182.63,96.61 181.39,96.61 181.23,96.46 181.23,95.55 181.44,95.34 182,95.34 182.07,95.27 182.07,93.49 182,93.41 181.41,93.41 181.23,93.24 181.23,92.22 181.55,91.9 181.74,91.9 181.93,91.71 181.93,91.59 181.74,91.39 181.42,91.39 180.92,91.9 180.92,92.22 180.98,92.28 180.98,93.31 180.88,93.41 180.22,93.41 180.14,93.49 180.14,95.27 180.22,95.34 180.42,95.34 180.52,95.45 180.52,96.87 180.22,97.17 179.77,97.17 179.77,100.77 179.89,100.88 180.93,100.88
GND on BOTTOM (solid shape): 61.16,76.71 61.16,74.44 61.7,73.91 61.7,69.07 61.59,68.96 60.33,68.96 60.33,69.54 59.72,69.54 59.72,68.69 59.7,68.66 59.7,68 59.88,67.83 63.55,67.83 63.68,67.69 63.68,65.52 61.44,63.28 61.44,59.54 60.41,59.54 60.2,59.54 60.2,60.07 59.59,60.07 59.57,60.05 59.57,58.54 59.92,58.18 59.92,56.97 59.85,56.9 59.3,56.9 59.26,56.94 59.26,59.29 59.33,59.36 59.33,67.48 59.34,67.56 59.33,67.63 59.33,74.34 59.3,74.38 59,74.67 56.8,74.67 56.64,74.83 56.64,76.73 56.87,76.96 60.92,76.96
GND on BOTTOM (solid shape): 9.65,84.85 5.79,84.85 4.33,85.22 4.2,85.25 3.93,85.47 3.59,85.55 1.15,85.55 1.15,88.34 1.63,88.86 1.46,89.55 2.7,89.55 3.2,89.55 3.48,89.67 3.6,89.95 3.6,91.59 9.65,91.59
GND on BOTTOM (solid shape): 91.98,82.82 93.12,82.82 93.2,82.75 93.2,81.45 92.59,80.84 90.87,80.84 90.78,80.94 90.78,81.4 90.64,81.54 90.46,81.54 90.39,81.61 90.39,82.3 90.42,82.31 90.37,82.84 90.08,82.39 90.08,81.61 90.01,81.54 89.83,81.54 89.26,80.97 88.02,80.97 87.05,81.93 87.05,82.59 87.2,82.74 88.75,82.74 89.13,83.11 91.69,83.11
GND on BOTTOM (solid shape): 103.38,88.98 103.38,87.78 103.48,87.67 103.48,87.63 103.52,87.63 103.57,87.58 103.57,87.33 103.54,87.29 103.46,87.26 103.4,87.22 103.38,87.2 103.26,87.2 103.25,87.22 103.01,87.31 102.78,87.22 102.76,87.2 102.68,87.2 102.66,87.22 102.43,87.31 102.19,87.22 102.18,87.2 102.05,87.2 102.04,87.22 101.98,87.26 101.91,87.29 101.9,87.29 101.86,87.33 101.86,87.52 102.05,87.71 102.43,87.71 102.68,87.97 102.68,89.17 103.19,89.17
GND on BOTTOM (solid shape): 69.98,87.39 69.98,86.22 70.46,85.74 71.32,85.74 71.57,85.49 71.57,84.47 71.82,84.22 72.71,84.22 72.9,84.41 72.9,85.04 73.03,85.17 74.74,85.17 74.94,84.98 74.94,83.81 74.94,83.81 74.94,81.49 74.33,80.89 70.06,80.89 70.04,80.87 70.03,80.87 68.92,79.76 68.92,75.71 68.76,75.55 67.62,75.55 67.6,75.53 67.54,75.56 67.54,76.07 66.93,76.07 66.92,76.06 66.92,74.58 66.83,74.49 66.7,74.49 66.6,74.59 66.6,75.46 66.52,75.54 66.52,80.24 66.52,82.7 66.59,82.77 68.78,82.77 69.04,82.51 70.2,82.51 70.45,82.76 70.45,83.99 70.17,84.27 70.17,84.79 69.45,85.52 67.76,85.52 67.75,85.54 67.75,86.45 67.76,86.46 68.94,86.46 69.13,86.65 69.13,87.43 69.22,87.52 69.86,87.52
GND on BOTTOM (solid shape): 182.5,120 182.5,119.96 182.53,119.73 182.59,119.51 182.66,119.38 182.74,119.26 182.8,119.18 182.84,119.14 182.94,119.04 183.02,118.98 183.1,118.93 183.27,118.84 183.45,118.78 183.59,118.76 183.73,118.75 183.75,118.75 187.4,118.75 187.4,118.5 183.75,118.5 182.7,118.92 182.25,119.96 182.25,120.55 182.5,120.55
GND on BOTTOM (solid shape): 315.4,42.75 316.02,42.01 316.86,42.5 319.85,42.5 320.14,42.57 320.35,42.76 320.36,42.77 320.4,42.8 325.7,42.8 325.7,40.4 325.19,40.4 325.19,41.13 324.89,41.42 315.98,41.42 315.88,41.52 315.17,41.96 314.89,42.75 314.89,44.59 315.4,44.59
GND on BOTTOM (solid shape): 135.29,68.55 135.62,68.21 135.6,68.16 135.59,68.11 135.59,68.07 135.59,68.02 135.6,67.98 135.62,67.94 135.65,67.9 135.68,67.87 135.72,67.85 135.76,67.83 135.8,67.82 135.85,67.81 135.86,67.79 135.87,67.76 135.87,67.28 135.77,67.18 134.98,67.18 134.96,67.19 134.93,67.21 134.89,67.23 134.85,67.24 134.81,67.25 134.42,67.63 134.42,67.76 134.99,67.76 134.99,67.72 135,67.67 135.02,67.63 135.05,67.6 135.08,67.56 135.12,67.54 135.16,67.52 135.21,67.51 135.25,67.51 135.3,67.51 135.34,67.53 135.38,67.55 135.42,67.58 135.45,67.61 135.47,67.65 135.49,67.7 135.49,67.74 135.49,67.79 135.49,67.83 135.47,67.87 135.45,67.91 135.42,67.95 135.38,67.98 135.34,68 135.3,68.01 135.25,68.02 135.21,68.02 135.16,68.01 135.12,67.99 135.08,67.96 135.05,67.93 135.02,67.89 135,67.85 134.99,67.81 134.99,67.76 134.42,67.76 134.42,67.86 135.11,68.55
GND on BOTTOM (solid shape): 2.85,8.4 4.45,10 6.05,8.4 6.05,6.67 7.78,5.21 8.45,3.05 8.45,3.05 8.45,0.25 2.1,0.25 1.57,0.47 1.35,1 1.35,3.05 1.36,3.05 1.36,5.53 2.04,6.19 2.85,6.67
GND on BOTTOM (solid shape): outline of 106 points within 12.01,7.57 17.4,13.61
GND on BOTTOM (solid shape): 109.16,1.88 113.04,6.1 117.15,2.1 117.15,2 117.15,0 116.55,0 113.15,-1.9 109.75,0 109.16,0
GND on BOTTOM (solid shape): outline of 119 points within 267.35,29.55 290.61,36.43
GND on BOTTOM (solid shape): 6.36,94.23 6.36,94.04 7.02,93.37 7.66,93.37 8.03,92.99 8.03,92.23 10.59,89.67 10.59,85.18 12.12,83.64 15.47,83.64 16.52,82.59 16.52,80.57 15.6,79.65 13.61,79.65 13.61,79.94 14.11,80.77 13.37,81.4 10.62,81.4 4.34,81.4 4.34,84.8 4.12,85.33 3.59,85.55 1.15,85.55 1.15,88.34 1.64,89.18 0.9,89.8 0.25,89.8 0.25,92.1 4.04,92.1 4.88,91.61 5.5,92.35 5.5,94.26 5.57,94.33 6.25,94.33
GND on BOTTOM (solid shape): 17.47,68.53 17.47,65.7 15.8,64.02 4.5,64.02 4.46,63.99 4.06,63.73 3.59,63.64 3.26,63.64 3.26,59.55 2.89,58.66 2,58.29 1.21,58.29 1.21,35.31 2,35.31 2.34,35.27 2.65,35.13 2.65,34.43 2.37,34.7 2,34.8 0.7,34.8 0.7,58.8 2,58.8 2.53,59.02 2.75,59.55 2.75,64.15 3.59,64.15 4.12,64.37 4.34,64.9 4.34,67.4 13.37,67.4 14.11,68.03 13.61,68.86 13.61,69.23 16.77,69.23
GND on BOTTOM (solid shape): 237,1.4 240.95,5.5 245,1.5 245,1.44 245,0 244.71,0 241,-2.5 237.29,0 237,0
GND on BOTTOM (solid shape): 322.75,71.31 322.26,70.47 323,69.85 324.4,69.85 324.4,56.9 320.4,56.9 320.36,56.92 320.35,56.94 320.14,57.13 319.85,57.2 316.86,57.2 316.02,57.69 315.4,56.95 315.4,55.01 314.89,55.01 314.89,56.95 315.28,57.87 316.22,58.21 317.33,59.32 323.48,59.32 323.89,59.73 323.89,69.34 323,69.34 321.8,70.2 322.24,71.61 322.24,73.17 322.75,73.17
