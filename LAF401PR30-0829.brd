# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PRX_DTX_P0: length 227.9
  TOP w0.094: v1(283.85,69.08) 283.64,69.3 283.64,69.59 283.4,69.82 282.13,69.82 282.12,69.83 281.49,69.83 281.48,69.82 278.94,69.82 278.18,69.06 278.18,68.31 278.01,68.14 277.83,68.14 277.69,68.28 CN15.1
  IN2 w0.122: v1(283.85,69.08) 283.77,69.08 283.67,69.18 283.67,69.38 283.79,69.5 284.1,69.5 284.81,68.8 284.81,68.23 285.85,67.18 285.85,66.78 286.81,65.82 288.43,65.82 288.88,65.37 288.88,62.55 288.39,62.06 288.39,60.95 286.92,59.48 286.92,57.58 287.13,57.37 287.13,56.18 283.9,52.95 283.9,52.74 280.74,49.58 279.44,49.58 278.91,49.05 277.72,49.05 277.2,48.53 277.2,48.02 275.6,46.43 274.68,46.43 273.3,45.05 271.66,45.05 270.6,43.99 269.23,43.99 268.33,43.09 268.33,42 267.6,41.27 264.86,41.27 263.79,40.2 260.18,40.2 258.96,38.98 258.46,38.98 257.06,37.58 254.84,37.58 253.9,36.64 245.72,36.64 244.71,35.63 243.82,35.63 243.21,35.02 240.78,35.02 238.84,33.09 226.25,33.09 225.64,32.48 220.65,32.48 218,29.83 214.94,29.83 213.69,31.08 200.54,31.08 189.23,42.39 180.14,42.39 169.77,52.76 169.77,58.67 166.92,61.52 166.92,65.16 160.2,71.88 147.51,71.88 146.96,71.33 142.5,71.33 141.01,72.82 128.35,72.82 127.97,72.43 127.97,70.21 126.39,68.63 126.39,67.23 126.33,67.17 126.16,67.17 v1(126.12,67.21)
  BOTTOM w0.076: UC1.E20 126.5,66.92 126.27,66.92 126.12,67.07 v1(126.12,67.21)
SATA_PRX_RD_DTX_N0: length 54.7
  TOP w0.094: v1(277.46,59.94) 277.23,59.71 276.98,59.71 276.5,60.2 276.5,60.74 276.63,60.88 UN7.12
  IN2 w0.122: v1(258.02,40.79) 258.02,40.97 257.75,41.24 257.75,41.69 259.47,43.4 259.98,43.4 260.82,44.24 263.31,44.24 264.17,45.11 265.11,45.11 265.61,45.61 265.61,46.98 267.21,48.58 268.68,48.58 270.06,49.95 270.06,50.44 268.82,51.67 268.82,52.49 269.26,52.93 271.89,52.93 273.61,54.65 273.61,59.58 274.02,59.99 276.61,59.99 276.82,59.77 277.29,59.77 v1(277.46,59.94)
  BOTTOM w0.094: v1(258.02,40.79) 258.31,40.79 259.74,39.36 271.34,39.36 271.96,38.73 272.84,38.73 273.05,38.52 273.05,38.19 CN6.2
SATA_PRX_RD_DTX_P0: length 54.6
  TOP w0.094: v1(277.46,59.35) 277.28,59.53 276.91,59.53 276.31,60.12 276.31,60.72 276.14,60.89 UN7.11
  IN2 w0.122: v1(258.43,41.2) 258.12,41.2 257.99,41.33 257.99,41.59 259.57,43.17 260.07,43.17 260.91,44.01 263.4,44.01 264.27,44.87 265.2,44.87 265.84,45.52 265.84,46.89 267.31,48.35 268.78,48.35 270.29,49.86 270.29,50.53 269.05,51.77 269.05,52.4 269.36,52.7 271.98,52.7 273.85,54.56 273.85,59.49 274.12,59.76 276.52,59.76 276.73,59.54 277.27,59.54 v1(277.46,59.35)
  BOTTOM w0.094: CN7.2 273.24,38.27 273.24,38.6 272.92,38.92 272.04,38.92 271.41,39.54 259.82,39.54 258.43,40.93 v1(258.43,41.2)
SATA_PTX_C_DRX_N0: length 3.7
  BOTTOM w0.094: CN5.1 271.25,36.49 271.25,36.31 271.38,36.18 271.65,36.18 271.66,36.19 272.17,36.19 272.18,36.18 272.39,36.18 272.74,35.83 272.74,35.45 272.9,35.29 JSATA1.3
SATA_PTX_C_DRX_P0: length 3.7
  BOTTOM w0.094: JSATA1.2 272.4,35.3 272.56,35.46 272.56,35.75 272.31,36 v4(271.91,36) 271.3,36 271.06,36.24 271.06,36.48 CN4.1
SATA_PTX_C_RD_DRX_N0: length 4.2
  TOP w0.094: UN7.2 277.63,65.7 277.79,65.86 277.79,66.02 277.99,66.22 278.28,66.22 278.39,66.34 278.39,66.37 278.8,66.78 278.85,66.78 278.89,66.82 279.9,66.82 279.99,66.91 279.99,67.26 279.87,67.38 CN13.2
SATA_PTX_C_RD_DRX_P0: length 4.1
  TOP w0.094: CN12.2 280.27,67.38 280.18,67.28 280.18,66.84 279.98,66.63 278.97,66.63 v4(278.75,66.42) 278.36,66.03 278.07,66.03 277.98,65.94 277.98,65.83 278.14,65.67 UN7.1
SATA_PTX_DRX_N0: length 220.5
  TOP w0.094: v1(283.16,68.04) 283,68.19 283,68.49 282.31,69.18 280.18,69.18 279.88,68.88 279.88,68.58 CN13.1
  IN2 w0.122: v1(126.12,70.86) 125.98,70.99 125.61,70.99 125.35,71.25 125.35,72 126.96,73.6 141.62,73.6 143.13,72.09 146.73,72.09 147.18,72.54 160.47,72.54 168.16,64.86 168.16,61.35 170.43,59.08 170.43,53.06 180.42,43.06 189.62,43.06 200.87,31.82 213.95,31.82 215.25,30.52 217.75,30.52 220.38,33.14 224.98,33.14 225.61,33.77 238.59,33.77 240.5,35.68 242.81,35.68 243.66,36.53 244.64,36.53 245.42,37.31 253.53,37.31 254.52,38.3 256.83,38.3 258.21,39.68 258.69,39.68 259.93,40.91 263.56,40.91 264.6,41.96 266.51,41.96 267.52,42.97 267.52,43.88 268.56,44.92 268.56,45.51 269.07,46.02 269.5,46.02 270.24,46.76 273.44,46.76 273.87,47.19 274.67,47.19 277.2,49.71 278.41,49.71 278.96,50.27 280.47,50.27 283,52.79 283,53.19 285.7,55.9 285.7,58.08 285.27,58.52 285.27,59.63 286.1,60.46 286.1,61.67 285.31,62.46 285.31,65.37 283.82,66.86 283.82,68.06 283.47,68.42 283.2,68.42 283.04,68.27 283.04,68.16 v1(283.16,68.04)
  BOTTOM w0.076: v1(126.12,70.86) 125.98,70.99 125.68,70.99 125.48,70.8 125.48,70.2 125.7,69.98 125.7,69.64 UC1.B21
SATA_PTX_DRX_P0: length 220.4
  TOP w0.094: CN12.1 280.16,68.29 280.07,68.39 280.07,68.8 280.26,68.99 282.24,68.99 282.82,68.41 282.82,68.28 v1(282.58,68.04)
  IN2 w0.122: v1(282.58,68.04) 282.81,68.27 282.81,68.36 283.1,68.65 283.56,68.65 284.06,68.16 284.06,66.95 285.55,65.46 285.55,62.56 286.33,61.77 286.33,60.36 285.5,59.53 285.5,58.61 285.94,58.18 285.94,55.8 283.23,53.09 283.23,52.69 280.57,50.04 279.06,50.04 278.5,49.48 277.29,49.48 274.77,46.96 273.97,46.96 273.54,46.53 270.34,46.53 269.6,45.79 269.17,45.79 268.79,45.41 268.79,44.83 267.75,43.79 267.75,42.87 266.6,41.73 264.7,41.73 263.65,40.68 260.02,40.68 258.79,39.45 258.31,39.45 256.92,38.06 254.61,38.06 253.62,37.07 245.52,37.07 244.74,36.3 243.75,36.3 242.91,35.45 240.59,35.45 238.69,33.54 225.71,33.54 225.07,32.91 220.47,32.91 217.85,30.28 215.15,30.28 213.85,31.59 200.77,31.59 189.53,42.83 180.33,42.83 170.2,52.97 170.2,58.98 167.92,61.26 167.92,64.76 160.38,72.31 147.27,72.31 146.83,71.86 143.04,71.86 141.52,73.37 127.06,73.37 125.58,71.9 125.58,71.35 125.71,71.22 125.9,71.22 v1(126.12,71.44)
  BOTTOM w0.076: UC1.A21 125.46,69.71 125.53,69.79 125.53,69.92 125.31,70.14 125.31,70.86 125.61,71.16 125.89,71.16 126.12,71.38 v1(126.12,71.44)
SATA_PTX_RD_DRX_N0: length 55.9
  TOP w0.094: UN7.14 277.63,61.07 277.83,60.88 277.83,60.74 278.4,60.17 v1(279.76,60.17)
  IN2 w0.122: v1(257.34,39.64) 257.02,39.64 256.9,39.76 256.9,39.99 257.03,40.12 258.53,40.12 259.77,41.37 263.28,41.37 264.52,42.61 265.31,42.61 267.31,44.62 267.31,46.22 268.56,47.47 273,47.47 273.36,47.82 274.53,47.82 276.69,49.98 276.69,50.72 277.25,51.28 277.25,57.61 278.86,59.23 278.86,59.9 279.36,60.4 279.53,60.4 v1(279.76,60.17)
  BOTTOM w0.094: CN5.2 271.54,37.81 271.21,38.15 271.21,38.49 270.74,38.96 257.7,38.96 257.34,39.32 v1(257.34,39.64)
SATA_PTX_RD_DRX_P0: length 56
  TOP w0.094: v1(279.76,60.75) 279.36,60.35 278.47,60.35 278.01,60.82 278.01,60.95 278.14,61.07 UN7.15
  IN2 w0.122: v1(279.76,60.75) 279.63,60.63 279.26,60.63 278.63,60 278.63,59.33 277.01,57.71 277.01,51.38 276.46,50.82 276.46,50.08 274.43,48.05 273.26,48.05 272.91,47.7 268.46,47.7 267.08,46.32 267.08,44.72 265.21,42.84 264.42,42.84 263.18,41.6 259.68,41.6 258.43,40.36 256.93,40.36 256.67,40.09 256.67,39.67 256.92,39.41 v1(256.92,39.23)
  BOTTOM w0.094: v1(256.92,39.23) 257.16,39.23 257.62,38.77 270.67,38.77 271.02,38.42 271.02,38.19 CN4.2
SATALED#: length 221.1
  TOP w0.102: QZ2.4 v1(268.63,65.93) ; v1(256.89,47.72) 256.89,43.74 256.61,43.45 256.61,40.21 256.04,39.64 256.04,38.5 256.29,38.25 256.73,38.25 261.3,39.58 262.15,39.58 262.82,38.91 263.72,35.56 263.72,34.82 260.26,31.36 254.93,31.36 250.58,27.01 v1(250.58,20.85)
  IN3 w0.122: v1(256.89,47.72) 256.89,49.23 264.32,56.66 264.32,60.75 267.13,63.56 267.13,64.31 268.63,65.8 v1(268.63,65.93)
  IN4 w0.089: v1(163.38,70.61) 163.05,70.28 163.05,61.59 165.23,59.4 165.23,54.69 170.88,49.04 170.88,47.98 172.49,46.37 172.49,45.16 173.44,44.21 174.8,44.21 180.64,38.38 182.81,38.38 188.1,33.09 188.55,33.09 199.53,22.12 207.4,22.12 207.73,22.45 215.22,22.45 215.42,22.24 218.32,22.24 218.7,22.62 221.11,22.62 221.75,21.99 226.32,21.99 226.57,22.24 230.45,22.24 231.53,21.16 250.26,21.16 v1(250.58,20.85)
  BOTTOM w0.076: 140.47,66.88 139.21,65.63 138.54,65.63 138.45,65.54 UC1.H1
  BOTTOM w0.102: 140.47,66.88 142.88,69.3 145.1,69.3 145.74,69.93 RPC4.2 146.37,69.93 146.56,69.74 146.56,69.36 146.82,69.11 149.18,69.11 v2(150.6,70.53) 151.26,71.19 162.8,71.19 v1(163.38,70.61) ; v1(250.58,20.85) 250.58,22.56 251.26,23.25 RN100.2 RN101.2
SBIOS_TX: length 193.3
  IN1 w0.089: v1(162.36,42.89) 158.45,42.89 156.36,44.98 156.36,47.81 151.79,52.37 148.24,52.37 143.83,56.79 141.85,56.79 140.37,58.26 138.21,58.26 v1(138.02,58.07)
  IN3 w0.122: v1(272.06,74.69) 273.06,74.69 274.29,73.46 274.29,72.05 275.17,71.17 275.17,61.04 273.72,59.59 273.72,57.33 273.64,57.25 273.64,56.15 273.33,55.84 273.33,55.22 273.07,54.95 273.07,54.19 271.49,52.62 270.92,52.62 269.77,51.46 268.88,51.46 267.67,50.25 265.51,50.25 263.88,48.62 263.88,48.03 263.55,47.7 261.82,47.7 260.57,46.44 259.9,46.44 259.36,46.99 255.99,46.99 247.97,38.96 240.49,38.96 236.53,34.99 219.89,34.99 219.19,34.29 216.91,34.29 215.97,33.36 205.7,33.36 205.43,33.08 201.38,33.08 181.87,52.59 v1(181.24,52.59)
  BOTTOM w0.076: v1(138.02,58.07) 137.8,57.88 137.63,57.88 137.25,58.02 UC1.AB2
  BOTTOM w0.102: v1(181.24,52.59) v2(180.52,52.59) 179.45,52.59 177.6,50.74 177.6,48.72 170.07,41.19 164.06,41.19 v1(162.36,42.89) ; v1(272.06,74.69) 272.92,74.69 RE306.1
SD/MMCCD#: length 8.5
  TOP w0.102: v1(27.06,46.88) 26.39,47.55 UR1.30 ; v1(31.18,48.18) 30.52,48.18 v3(30.36,48.02)
  IN4 w0.089: v1(27.06,46.88) 27.07,46.88 27.5,47.31 29.08,47.31 29.91,48.15 31.15,48.15 v1(31.18,48.18)
  BOTTOM w0.102: JSD1.18 32,49 v1(31.18,48.18)
SD/MMCCLK: length 2.6
  TOP w0.102: RR5.1 22.2,52.77 v2(22.55,52.42) 23.52,51.46 UR1.17
SD/MMCCLK_R: length 27.8
  TOP w0.102: RR5.2 21.61,53.74 CR21.1 20.07,53.74 v2(19.75,53.42) 19.75,53.05 v1(19.97,52.83)
  IN1 w0.089: v1(30.8,47.6) 25.21,47.6 23.26,49.55 23.26,49.75 24.28,50.77 24.28,50.97 24.14,51.11 23.95,51.11 22.92,50.08 22.73,50.08 22.59,50.22 22.59,50.41 23.66,51.48 23.66,51.69 23.53,51.83 23.34,51.83 22.26,50.74 22.06,50.74 21.93,50.88 21.93,51.08 22.52,51.67 22.52,51.86 22.38,52 22.19,52 21.59,51.41 21.4,51.41 21.26,51.55 21.26,51.74 21.96,52.44 21.96,52.62 21.82,52.76 21.62,52.76 20.93,52.07 20.73,52.07 v1(19.97,52.83)
  BOTTOM w0.102: JSD1.5 v1(30.8,47.6)
SD/MMCCMD: length 2.1
  TOP w0.102: RR6.1 v2(22.65,50.82) 22.83,50.82 22.99,50.66 UR1.19
SD/MMCCMD_R: length 27.6
  TOP w0.102: RR6.2 v1(20.08,50.82)
  IN1 w0.089: v1(20.08,50.82) 21.43,50.82 26.78,45.47 26.97,45.47 27.5,45.99 27.69,45.99 27.83,45.86 27.83,45.66 27.31,45.14 27.31,44.94 27.44,44.81 27.64,44.81 28.16,45.33 28.36,45.33 28.49,45.19 28.49,45 27.97,44.47 27.97,44.28 28.11,44.14 28.3,44.14 29.22,45.06 29.4,45.06 29.53,44.92 29.53,44.71 28.64,43.81 28.64,43.61 28.77,43.48 28.97,43.48 29.78,44.28 29.97,44.28 30.11,44.15 30.11,43.95 29.3,43.14 29.3,42.95 29.44,42.81 29.63,42.81 30.31,43.49 30.51,43.49 30.65,43.35 30.65,43.16 29.97,42.48 29.97,42.28 30.35,41.9 v1(30.51,41.9)
  BOTTOM w0.102: v1(30.51,41.9) JSD1.2
SD/MMCDAT0/RCLK+: length 2.4
  TOP w0.102: UR1.16 24.39,52.51 24.27,52.62 23.53,52.62 23.3,52.85 23.3,53.1 22.99,53.41 RR10.1
SD/MMCDAT0/RCLK+_R: length 28.9
  TOP w0.102: v1(22.35,55.32) 22.85,55.32 23.25,54.92 23.25,54.64 RR10.2
  IN1 w0.089: v1(22.35,55.32) 22.58,55.32 22.75,55.15 24.38,55.15 25.16,55.94 25.16,58.07 25.25,58.16 25.52,58.16 25.61,58.07 25.61,56.11 25.82,55.9 26.27,55.9 26.49,56.11 26.49,58.26 26.57,58.35 26.84,58.35 26.93,58.26 26.93,56.11 27.14,55.9 27.59,55.9 27.81,56.11 27.81,58.26 27.89,58.35 28.16,58.35 28.25,58.26 28.25,56.44 28.47,56.23 29.47,56.23 29.59,56.11 29.59,53.36 30.48,52.47 v1(31.45,52.47)
  BOTTOM w0.102: JSD1.7 31.76,51.8 31.45,52.11 v1(31.45,52.47)
SD/MMCDAT1/RCLK-: length 2.4
  TOP w0.102: RR9.1 23.53,53.12 23.53,52.95 23.62,52.85 24.36,52.85 24.79,52.43 UR1.15
SD/MMCDAT1/RCLK-_R: length 28.9
  TOP w0.102: RR9.2 23.47,54.67 23.47,55.02 v1(22.76,55.73)
  IN1 w0.089: v1(31.09,53) 31.16,52.94 31.16,52.75 31.09,52.68 30.57,52.68 29.81,53.45 29.81,56.19 29.56,56.44 28.56,56.44 28.47,56.53 28.47,58.35 28.25,58.57 27.81,58.57 27.59,58.35 27.59,56.2 27.5,56.11 27.23,56.11 27.15,56.2 27.15,58.35 26.93,58.57 26.48,58.57 26.27,58.35 26.27,56.2 26.18,56.11 25.91,56.11 25.82,56.2 25.82,58.16 25.61,58.37 25.16,58.37 24.95,58.16 24.95,56.03 24.29,55.36 22.84,55.36 22.71,55.5 22.71,55.67 v1(22.76,55.73)
  BOTTOM w0.102: JSD1.8 31.93,53.2 31.6,52.88 31.22,52.88 v1(31.09,53)
SD/MMCDAT2: length 2.6
  TOP w0.102: UR1.21 23.19,49.86 22.76,49.43 v2(22.64,49.43) 22.09,49.43 21.67,49.01 RR8.1
SD/MMCDAT2_R: length 27.7
  TOP w0.102: RR8.2 v1(20.13,48.79) 19.69,48.79 v1(19.31,48.41)
  IN1 w0.089: v1(20.13,48.79) 20.13,48.5 22.84,45.79 24.12,45.79 24.84,45.07 24.84,42.71 25.62,41.93 25.62,41.74 24.9,41.02 24.9,40.86 25.04,40.72 25.27,40.72 25.95,41.41 26.15,41.41 26.29,41.27 26.29,41.07 25.29,40.08 25.29,39.94 25.49,39.74 25.61,39.74 26.62,40.74 26.81,40.74 26.95,40.6 26.95,40.41 26.05,39.51 26.05,39.38 26.26,39.18 26.38,39.18 27.28,40.08 29.8,40.08 29.98,39.9 v1(29.98,39.26)
  BOTTOM w0.102: v1(29.98,39.26) 30.14,39.1 JSD1.9
SD/MMCDAT3: length 2.3
  TOP w0.102: RR7.1 22.03,49.8 22.48,50.26 UR1.20
SD/MMCDAT3_R: length 27.9
  TOP w0.102: v1(19.73,49.8) RR7.2
  IN1 w0.089: v1(19.73,49.8) 20.75,48.78 20.75,48.43 22.96,46.22 25.08,46.22 25.8,45.51 25.8,45.31 25.38,44.9 25.38,44.68 25.52,44.54 25.69,44.54 26.13,44.98 26.32,44.98 26.46,44.84 26.46,44.65 25.88,44.06 25.88,43.87 26.01,43.73 26.21,43.73 26.79,44.32 26.99,44.32 27.13,44.18 27.13,43.98 26.64,43.49 26.64,43.3 26.77,43.16 26.97,43.16 27.46,43.65 27.65,43.65 27.79,43.51 27.79,43.32 27.3,42.83 27.3,42.63 27.44,42.5 27.63,42.5 28.12,42.99 28.32,42.99 28.46,42.85 28.46,42.65 27.97,42.16 27.97,41.97 28.1,41.83 28.3,41.83 28.79,42.32 28.98,42.32 29.12,42.18 29.12,41.99 28.63,41.5 28.63,41.3 28.77,41.17 28.96,41.17 29.45,41.66 29.65,41.66 29.88,41.42 v1(31.12,41.42)
  BOTTOM w0.102: v1(31.12,41.42) 31.12,40.79 31.41,40.5 JSD1.1
SD_GPIO: length 2.5
  TOP w0.102: UR1.28 25.59,47.08 v2(25.83,46.84) 26.52,46.14 RR3.2
SD_RCOMP: length 19.8
  TOP w0.127: RC96.1 150.86,60.19 v2(151.08,60.19)
  TOP w0.381: RC96.1 149.61,58.95 v1(148.71,58.95)
  IN2 w0.381: v1(133.72,59.11) 133.72,59.21 134.24,59.73 135.92,59.73 137.04,58.62 138.45,58.62 138.7,58.36 148.25,58.36 148.66,58.77 148.66,58.9 v1(148.71,58.95)
  BOTTOM w0.254: v1(133.72,59.11) 133.83,59 133.83,58.79 UC1.AB7
SD_UHS2_D0N: length 31.3
  TOP w0.089: UR1.25 24.39,47.65 24.44,47.59 24.44,47.44 24.26,47.26 24.07,47.26 v1(23.87,47.47)
  IN4 w0.076: v1(23.87,47.47) 23.69,47.29 23.61,47.29 23.4,47.5 20.88,47.5 19.63,46.25 17.09,46.25 15.69,44.85 15.69,41.11 14.73,40.15 13.03,40.15 7.66,34.78 7.66,30.36 v1(7.42,30.12)
  BOTTOM w0.089: JSD1.12 7.2,30.92 7.57,30.55 7.57,30.27 v1(7.42,30.12)
SD_UHS2_D0P: length 31.3
  TOP w0.089: UR1.26 24.79,47.63 24.74,47.59 24.74,47.32 24.39,46.96 23.95,46.96 v1(23.87,46.88)
  IN4 w0.076: v1(8,30.12) 7.9,30.22 7.9,34.68 13.13,39.91 14.83,39.91 15.93,41.01 15.93,44.75 17.19,46 19.73,46 20.98,47.25 23.3,47.25 23.51,47.05 23.7,47.05 v1(23.87,46.88)
  BOTTOM w0.089: JSD1.11 8.3,31 7.87,30.57 7.87,30.25 v1(8,30.12)
SD_UHS2_D1N: length 31.3
  TOP w0.089: v1(22.32,48.43) 22.42,48.53 22.7,48.53 23.23,49.07 23.43,49.07 23.44,49.06 UR1.23
  IN4 w0.076: v1(22.32,48.43) 22.26,48.48 21.23,48.48 20.84,48.87 20.84,52.69 13.05,60.48 11.34,60.48 11.17,60.31 11.17,58.93 10.88,58.64 10.34,58.64 10.1,58.88 10.1,60.31 9.93,60.48 7.88,60.48 7.53,60.83 7.53,62.66 v1(7.46,62.73)
  BOTTOM w0.089: JSD1.15 7.2,61.15 7.55,61.5 7.55,62.64 v1(7.46,62.73)
SD_UHS2_D1P: length 31.3
  TOP w0.089: v1(22.32,49.01) 22.5,48.83 22.57,48.83 23.11,49.37 23.34,49.37 23.43,49.46 UR1.22
  IN4 w0.076: v1(8.04,62.73) 8.01,62.73 7.77,62.49 7.77,60.93 7.98,60.72 10.03,60.72 10.34,60.41 10.34,58.98 10.44,58.88 10.78,58.88 10.93,59.03 10.93,60.41 11.24,60.72 13.15,60.72 21.08,52.79 21.08,48.97 21.33,48.72 22.06,48.72 22.32,48.98 v1(22.32,49.01)
  BOTTOM w0.089: v1(8.04,62.73) 8.02,62.73 7.85,62.56 7.85,61.6 8.3,61.15 JSD1.16
SDWP: length 13.2
  TOP w0.102: v1(26.42,46.88) 25.99,47.32 UR1.29 ; v2(34.8,52.66) v1(33.85,52.66) 33.28,52.66 QR1.1
  IN4 w0.089: v1(26.42,46.88) 26.42,47.01 27.23,47.82 28.88,47.82 33.73,52.66 v1(33.85,52.66)
SDWP_Q: length 3.3
  TOP w0.102: QR1.3 32.15,54.72 v1(31.16,54.72) v3(31.16,55.58)
  BOTTOM w0.102: v1(31.16,54.72) 31.27,54.6 JSD1.19
SIM_DET: length 248.1
  TOP w0.102: v1(145.06,92.72) v3(145.66,92.72)
  IN4 w0.089: v1(145.06,92.72) 146.12,92.72 149.28,89.55 150.96,89.55 153.99,86.52 153.99,85.49 160.14,79.34 160.14,75.6 165.56,70.17 165.56,67.71 166.14,67.13 166.14,54.81 180.05,40.9 182.87,40.9 183.9,39.87 185.09,39.87 186.06,38.91 186.06,37.99 187.13,36.92 187.89,36.92 189.06,35.76 189.06,34.45 199.36,24.15 207.46,24.15 207.76,23.84 212.51,23.84 213.01,24.34 216.35,24.34 216.73,23.96 221.81,23.96 222.38,23.39 225.42,23.39 226.09,24.05 230.88,24.05 232.44,22.5 252.96,22.5 253.42,22.04 258.44,22.04 259.85,23.45 261.1,23.45 261.9,24.25 261.9,25.77 268.36,32.23 269.8,32.23 272.9,35.33 272.9,35.93 273.59,36.62 276.7,36.62 277.35,37.27 278.35,37.27 278.59,37.02 279.24,37.02 281.32,39.11 281.32,40.45 282.9,42.03 282.9,44.24 284.04,45.38 286.7,45.38 288.56,47.25 290.29,47.25 290.42,47.38 291.39,47.38 293.44,49.44 302.03,49.44 v1(303.22,50.63)
  BOTTOM w0.102: JNGFF2.66 303.05,50.46 v1(303.22,50.63) ; v1(145.06,92.72) 143.82,92.72 142.75,91.65 137.61,91.65 128.78,100.48 125.16,100.48 124.47,101.17 121.23,101.17 120.8,101.6 JSIM1.9
SIO_EXT_SCI#: length 38.1
  TOP w0.102: v1(155.43,51.07) 154.59,51.91 153.87,51.91 151.74,54.04 151.19,54.04 RC237.1 149.73,54.26 147.6,54.26 147.45,54.41 v2(146.84,54.41) 146.23,53.8 145.48,53.8 144.47,52.79 135.12,52.79 134.93,52.98 133.72,52.98 v1(133.44,53.26) ; RC561.1 v1(159.39,41.34)
  IN4 w0.089: v1(155.43,51.07) 154.64,50.28 154.64,46.09 v1(159.39,41.34)
  BOTTOM w0.076: v1(133.44,53.26) UC1.AN7
SIO_EXT_SMI#: length 23.1
  BOTTOM w0.102: UC1.A6 134.62,69.81 134.72,69.91 134.72,69.91 135,70.2 135,70.2 137.41,72.61 137.41,72.78 v2(141.26,76.62) 142.31,77.68 145.12,77.68 146.49,78.3 150.12,78.3 151.9,76.52 RC346.1
SIO_EXT_WAKE#: length 248.6
  TOP w0.102: v1(148.85,58.18) 150.2,58.18 151.11,59.1 151.99,59.1 152.2,59.31 152.2,59.68 v2(153.68,61.17) 154.41,61.9 155.74,61.9 v1(156.5,62.67) ; UE1.M12 304.56,80.73 305.05,81.22 v1(305.69,81.22)
  IN3 w0.122: v1(305.69,81.22) 307.07,81.22 307.35,81.49 309.69,81.49 310.01,81.17 310.01,75.99 309.43,75.41 309.43,73.3 308.31,72.18 308.31,67.63 308.89,67.05 308.89,65.78 308.46,65.34 308.46,64.15 308.06,63.75 307.37,63.75 306.3,62.68 306.3,61.88 303.63,59.21 303.63,53.64 301.29,51.31 301.29,50.64 300.65,49.99 298.71,49.99 297.38,48.67 296.09,48.67 295.48,48.06 295.48,46.69 292.54,43.76 292.54,42.5 291.72,41.68 291.72,40.24 291.41,39.94 290.78,39.94 290.5,39.66 289.75,39.66 286.16,36.07 286.16,34.54 279.66,28.03 261.12,28.03 258.86,25.77 250.1,25.77 249.13,24.8 245.83,24.8 240.99,19.96 233.24,19.96 229.65,16.37 221.43,16.37 221.28,16.22 217.74,16.22 217.4,15.87 215.55,15.87 214.41,17.01 210.96,17.01 208.32,19.65 207.51,19.65 203.72,23.45 200.1,23.45 191.74,31.82 187.98,31.82 185.23,34.56 184.22,34.56 176.83,41.95 176.83,43.29 172.53,47.58 172.53,48.34 163.63,57.24 160.56,57.24 156.06,61.74 156.06,62.23 v1(156.5,62.67)
  BOTTOM w0.076: UC1.AC1 137.2,57.52 139,57.52
  BOTTOM w0.102: v1(148.85,58.18) 147.52,56.85 146.06,56.85 145.61,56.41 RC283.1 144.76,56.41 143.87,57.3 143.24,57.3 142.28,58.25 141.29,58.25 141.06,58.02 139.49,58.02 139,57.52
SIO_PWRBTN#: length 349.8
  TOP w0.102: v2(132.47,37.32) v1(133.05,37.32) ; UE1.K11 v1(303.16,80.33) ; CC269.1 RC241.1 64.92,38.34 v1(64.92,37.74) 65.44,37.23 65.44,35.85 JXDP1.41
  IN2 w0.122: v1(64.92,37.74) 65.3,37.74 66.11,36.93 73.83,36.93 81.28,29.49 124.47,29.49 132.31,37.32 v1(133.05,37.32) 132.09,36.37 132.09,35.2 132.65,34.64 135.86,34.64 136.39,35.17 137.83,35.17 141.61,31.39 141.61,30.63 142.6,29.64 145.53,29.64 154.16,21 179.3,21 180.23,21.93 182.84,21.93 184.01,20.76 188.32,20.76 192.55,16.53 192.55,15.81 198.18,10.18 198.18,9.86 199.27,8.78 205.09,8.78 206.33,7.54 211.56,7.54 213.64,9.62 217.81,9.62 219.95,7.48 226.19,7.48 227.85,9.14 232.74,9.14 237.9,14.29 237.9,15.85 240.86,18.81 244.08,18.81 247.64,22.37 253.04,22.37 253.45,21.96 256.42,21.96 258.55,24.09 259.21,24.09 260.07,24.95 263.49,24.95 264.98,26.44 281.72,26.44 284.29,29.01 284.29,30.61 286.84,33.16 288.61,33.16 289.34,33.9 292.48,33.9 293.88,35.29 293.88,37.01 294.11,37.25 294.11,38.14 294.42,38.45 295.04,38.45 295.6,39.01 295.6,40.88 296.65,41.93 298.42,41.93 299.51,43.02 299.51,43.87 300.41,44.77 301.83,44.77 302.09,45.03 303.2,45.03 304.21,46.03 307.39,46.03 307.79,46.44 307.79,50.4 309.83,52.45 309.83,57.8 311.55,59.52 311.55,60.1 312.05,60.6 312.73,60.6 313.63,61.5 313.63,65.67 312.5,66.81 312.5,67.05 310.44,69.11 310.44,69.46 309.07,70.83 309.07,71.98 308.58,72.47 308.58,74.37 307.61,75.34 307.61,78.41 306.1,79.93 303.58,79.93 303.19,80.33 v1(303.16,80.33)
  BOTTOM w0.076: 130.61,43.96 130.44,43.96 128.65,45.76 128.65,47.47 UC1.BA15
  BOTTOM w0.102: v1(133.05,37.32) 133.05,39.05 131.73,40.37 131.73,42.84 130.61,43.96
SIO_SLP_A#: length 293.5
  TOP w0.102: UE1.M11 304.74,80.31 305.66,80.31 307.22,81.86 v1(307.22,82.38)
  IN1 w0.089: v1(127.95,52.54) 127.95,52.47 127.53,52.06 127.53,49.64 131.49,45.68 135.22,45.68 138.99,41.91 140.03,41.91 141.1,40.84 141.59,40.84 143.27,39.16 143.27,35.01 145.5,32.78 152.54,32.78 153.75,31.56 157.44,31.56 157.97,31.03 161.02,31.03 163.78,28.26 167.72,28.26 170.59,25.39 177.55,25.39 178.32,24.62 179.12,24.62 179.65,24.08 187.52,24.08 188.4,24.97 193.39,24.97 195.27,23.09 195.27,20.65 198.45,17.46 203.62,17.46 204.23,16.85 210.25,16.85 210.65,16.45 214.74,16.45 214.95,16.67 216.78,16.67 217.4,16.05 218.27,16.05 218.51,16.29 222.69,16.29 222.77,16.21 227.88,16.21 231.71,20.05 233.33,21.67 244.69,21.67 246.03,23.01 251.75,23.01 254,25.27 255.88,25.27 259.35,28.73 285.18,28.73 286.95,30.51 286.95,32.58 290.1,35.73 290.93,35.73 293.97,38.77 293.97,39.44 296.72,42.2 298.5,42.2 299.39,43.1 299.39,44.14 300.68,45.42 301.08,45.42 301.89,46.23 303.2,46.23 303.74,46.77 303.74,48.54 303.83,48.62 304.71,48.62 308.7,52.62 308.7,57.41 310.43,59.14 310.43,62.59 311.13,63.29 311.47,63.29 312.58,64.4 314.17,64.4 315.2,65.43 316.18,65.43 317.45,66.71 317.45,70.19 316.31,71.33 316.31,71.95 313.63,74.63 313.63,80.68 310.6,83.71 308.11,83.71 307.22,82.82 v1(307.22,82.38)
  BOTTOM w0.076: v1(127.95,52.54) 128.02,52.6 128.26,52.8 UC1.AN16
  BOTTOM w0.102: JAPS1.6 316.46,64.75 315.39,65.82 315.39,69.68 311.89,73.18 311.89,74.14 311.48,74.54 v2(311.48,75.46) 311.48,77 311.31,77.17 311.31,80.52 310.09,81.74 307.85,81.74 v1(307.22,82.38)
SIO_SLP_LAN#: length 292.2
  TOP w0.102: v1(273.18,52.04) 273.18,51.58 272.9,51.3 272.9,48.64 273.37,48.18 274.63,48.18 276.85,45.95 276.85,45.68 277.23,45.31 277.65,45.31 279.51,43.45 281.23,43.45 v2(282.18,44.4) 282.93,45.15 285.37,45.15 286.57,43.95 286.57,42.95 287.02,42.49 v1(289.95,42.49) ; RC344.1 RC68.1 134.41,30.76 v1(134.08,31.09)
  TOP w0.107: v1(301.56,78.73) UE1.H9
  IN3 w0.122: v1(301.56,78.73) 301.95,78.34 305.58,78.34 305.78,78.54 307.13,78.54 307.53,78.14 307.53,75.95 307.17,75.59 307.17,69.74 305.69,68.27 304.43,68.27 303.43,67.26 303.43,66.78 304.88,65.32 304.88,62.53 300.99,58.63 300.99,54.35 298.05,51.41 298.05,50.92 296.91,49.79 295.62,49.79 294.36,48.52 294.36,47.16 291.22,44.01 291.22,43.7 290.75,43.23 290.75,42.98 290.26,42.49 v1(289.95,42.49) 289.95,42.39 289.89,42.33 289.89,42.14 285.11,37.36 285.11,36.08 278.85,29.81 260.39,29.81 259.07,28.49 256.44,28.49 255.47,27.52 249.48,27.52 248.53,26.57 245.23,26.57 240.34,21.68 232.43,21.68 230.35,19.6 224.84,19.6 224.05,20.38 220.59,20.38 220.36,20.16 213.16,20.16 212.78,20.54 211.57,20.54 209.47,22.64 208.7,22.64 208.16,23.18 206.67,23.18 202.15,27.7 199.77,27.7 192.46,35.01 187.64,35.01 186.49,36.15 186.49,36.52 185.91,37.11 184.53,37.11 181.5,40.14 v1(180.76,40.14)
  BOTTOM w0.076: UC1.AW15 128.87,48.89 129.03,48.73 129.03,48.74 129.19,48.4 129.19,46.93 129.03,46.77 129.03,45.85 129.75,45.13 130.26,45.13 132.18,43.2
  BOTTOM w0.102: UZ2.5 274.42,50.58 273.18,51.83 v1(273.18,52.04) ; v1(180.76,40.14) 180.76,31.73 173.87,24.83 140.8,24.83 134.63,31.01 134.17,31.01 v1(134.08,31.09) 134.08,39.04 133.29,39.83 133.29,41 132.72,41.57 132.72,42.26 132.57,42.41 132.57,42.82 132.18,43.2
SIO_SLP_S0#: length 443.2
  TOP w0.102: RZ112.1 168.27,32.02 170.63,32.02 172.03,33.42 v1(173.06,33.42) 173.06,34.64 172.78,34.92 RZ362.2 RZ363.1 ; v1(154.89,80.76) 154.89,79.32 155.77,78.44 155.77,77.3 157.87,75.2 157.87,71.54 162.84,66.57 164.39,66.57 174.02,56.93 174.02,49.94 184.14,39.81 188.4,39.81 189.59,38.63 189.59,31.54 189.31,31.26 189.31,24.94 v1(189.79,24.45) ; PR425.1 136.89,109.6 136.43,109.14 v1(136.28,109.14) v2(136.28,108.12) 136.28,103.9 139.83,100.35 v1(140.98,100.35)
  TOP w0.254: PR426.1 126.62,111.96 v1(126.38,112.19)
  IN1 w0.089: v1(318.87,69.25) 318.28,69.25 317.89,68.85 317.89,65.61 316.74,64.47 314.97,64.47 314.03,63.53 312.54,63.53 312.11,63.1 311.21,63.1 310.62,62.51 310.62,59.06 308.96,57.4 308.96,51.57 307.68,50.28 307.68,46.83 306.81,45.97 304.09,45.97 303.1,44.97 301.72,44.97 301.37,44.62 301,44.62 300.17,43.79 300.17,42.75 298.86,41.44 297.04,41.44 296.42,40.82 296.42,40.51 296.58,40.35 296.58,39.88 295.09,38.4 294.68,38.4 291.25,34.97 290.45,34.97 288.36,32.87 288.36,30.82 285.47,27.93 260.51,27.93 257.06,24.49 254.4,24.49 252.16,22.25 246.35,22.25 244.77,20.68 233.42,20.68 228.19,15.45 222.83,15.45 222.3,14.92 221.13,14.92 220.52,15.53 218.83,15.53 218.58,15.28 212.71,15.28 211.62,14.2 208.29,14.2 205.83,16.66 204.15,16.66 203.54,17.27 198.37,17.27 195.08,20.57 195.08,23.01 193.43,24.65 189.99,24.65 v1(189.79,24.45)
  IN2 w0.122: v1(140.98,100.35) 140.98,99.65 143.2,97.42 143.2,97.01 147.28,92.93 151.63,92.93 152.46,92.11 152.46,91.25 154.89,88.82 v1(154.89,80.76)
  IN3 w0.122: v1(173.06,33.42) 172.78,33.42 171.48,32.12 165.28,32.12 162.31,35.09 158.15,35.09 156.39,36.85 156.39,40.42 155.72,41.09 152.07,41.09 149.99,43.17 145.52,43.17 141.94,46.75 139.32,46.75 138.59,47.49 132.71,47.49 131.09,49.11 131.09,50.04 v1(130.62,50.51)
  IN4 w0.089: v1(130.62,50.51) 130.73,50.51 131.09,50.15 131.09,49.61 131.29,49.42 134.26,49.42 135.15,50.3 145.47,50.3 146.39,51.22 151.82,51.22 153.28,52.69 153.28,54.68 150.5,57.46 150.5,64.6 150.37,64.72 150.37,67.98 151.35,68.96 151.35,74.87 154.23,77.75 154.23,79.27 154.89,79.93 v1(154.89,80.76)
  BOTTOM w0.102: UZ35.1 138.86,82.48 142.45,86.07 146.54,86.07 147.43,85.18 153.12,85.18 154.89,83.41 v1(154.89,80.76) ; v1(136.28,109.14) 132.97,112.44 132.72,112.44 131.81,113.35 127.54,113.35 v1(126.38,112.19) ; JAPS1.15 v1(318.87,69.25)
  BOTTOM w0.254: v1(130.62,50.51) 130.73,50.51 131.07,50.85 UC1.AT11
SIO_SLP_S3#: length 324.8
  TOP w0.102: UE3.2 306.71,95.37 306.05,96.03 RE280.1 304.82,95.21 UE5.1 304.82,93.78 v1(305.07,93.52) ; v1(279.28,71.45) 279.52,71.69 280.04,71.69 QE11.2
  TOP w0.107: v1(303.16,78.73) UE1.K9
  IN1 w0.089: v1(303.16,78.73) 302.79,79.1 301.27,79.1 300.8,78.63 300.8,77.5 300.21,76.9 298.23,76.9 297.96,76.64 297.96,74.54 297.99,74.51 297.99,71.67 297.87,71.56 297.87,69.92 299.14,68.65 299.14,64.58 300.2,63.52 300.2,60.7 299.08,59.58 299.08,56.13 300.14,55.07 301.01,54.19 301.01,50.95 300.35,50.29 298.84,50.29 297.18,48.62 297.18,47.95 296.77,47.54 296.24,47.54 292.21,43.51 292.21,42.64 290.58,41.01 289.7,41.01 288.87,40.18 288.87,39.31 287.97,38.42 287.97,37.81 282.23,32.06 258.08,32.06 257.35,31.34 254.48,31.34 250.04,26.9 240.42,26.9 238.56,25.04 236.93,25.04 236.2,25.77 232.83,25.77 227.65,20.59 220.97,20.59 220.06,19.68 218.81,19.68 218.45,20.04 214.79,20.04 214.65,19.9 212.85,19.9 212.31,20.44 208.49,20.44 207.51,21.42 200.67,21.42 194.07,28.02 186.99,28.02 186.3,27.33 185.72,27.33 185.17,27.88 180.73,27.88 179.71,28.9 171.53,28.9 168.83,31.6 164.79,31.6 161.9,34.49 160.52,34.49 159.53,35.48 155.07,35.48 153.6,36.96 148.88,36.96 148.17,37.66 148.17,39.96 146.81,41.32 145.54,41.32 141.91,44.95 138.22,44.95 136.19,46.98 133.24,46.98 131.17,49.05 131.17,51.12 130.75,51.54 130.05,51.54 v1(129.77,51.26)
  IN4 w0.089: v1(305.07,93.52) 305.57,93.03 305.57,93.01 306.05,92.52 306.05,90.28 306.52,89.82 306.52,87.36 305.43,86.27 305.43,83.76 303.56,81.9 303.56,79.13 v1(303.16,78.73) 302.76,79.13 301.21,79.13 300.4,78.32 298.92,78.32 298.74,78.5 298.74,78.98 298.59,79.13 296.29,79.13 296.08,79.34 288.05,79.34 287.36,78.64 284.28,78.64 284.07,78.43 280.12,78.43 280.04,78.52 278.71,78.52 278.19,78 277.71,78 276.73,77.02 276.73,75.58 276.63,75.48 276.63,74.33 277.14,73.81 277.91,73.81 278.41,73.31 278.41,72.32 v1(279.28,71.45)
  BOTTOM w0.076: UC1.AP15 129.77,51.7 v1(129.77,51.26)
  BOTTOM w0.102: v1(303.16,78.73) 303.59,78.3 304.12,78.3 304.38,78.56 304.38,79 304.55,79.17 304.97,79.17 305.21,78.93 305.21,77.57 306.02,76.75 306.35,76.75 306.46,76.65 306.46,75.76 308.59,73.63 308.59,73.5 308.83,73.26 308.96,73.26 310.24,71.98 310.24,71.62 311.05,70.81 311.41,70.81 313.95,68.27 313.95,64.91 316.11,62.75 JAPS1.2
SIO_SLP_S4#: length 578.7
  TOP w0.102: UE1.N12 305.8,80.73 306.58,81.51 v1(306.58,82.38) ; v1(183.47,28.98) 185.43,28.98 188.7,32.25 188.7,37.53 188.61,37.62 188.61,38.34 187.68,39.27 182.95,39.27 173.61,48.61 173.61,56.76 164.27,66.11 162.72,66.11 157.36,71.47 157.36,75.01 154.34,78.03 154.34,78.56 153.4,79.51 148.38,79.51 145.72,77.46 141.6,77.46 139.84,79.22 137.33,79.22 136.91,79.65 v1(133.72,79.65) ; v1(132.55,28.09) v2(132.04,28.09) 131.86,28.09 131.8,28.15 UZ34.2 ; PR513.1 v1(199.27,3.98)
  IN1 w0.089: v1(306.58,82.38) 306.27,82.7 303.92,82.7 302.96,83.65 295.72,83.65 294.14,82.06 294.14,75.52 293.63,75.01 293.63,73.3 293.44,73.11 293.44,72.22 293.92,71.73 293.92,69.68 296.52,67.08 296.52,64.84 296.65,64.71 296.65,60.37 297.08,59.94 297.08,53.36 295.58,51.86 295.58,51.43 293.71,49.56 293.71,47.46 290.74,44.48 290.21,44.48 289.05,43.32 289.05,42.81 285.76,39.52 285.76,38.04 281.51,33.79 257.24,33.79 256.51,33.06 252.64,33.06 248.21,28.63 238.95,28.63 237.81,27.5 231.4,27.5 227.55,23.64 226.07,23.64 224.93,22.5 221.56,22.5 221.2,22.87 218.99,22.87 218.34,22.21 216.05,22.21 215.69,22.57 211.79,22.57 211.42,22.2 204.01,22.2 203.79,21.99 200.91,21.99 193.54,29.36 183.84,29.36 v1(183.47,28.98)
  IN2 w0.122: v1(199.27,3.98) 196.95,3.98 193.82,7.1 193.62,7.1 187.87,12.85 187.87,16.96 186.57,18.25 182.95,18.25 182.8,18.1 181.47,18.1 181.08,18.49 143.2,18.49 133.61,28.09 v1(132.55,28.09) 132.47,28.09 130.72,29.83 127.24,29.83 124.85,27.45 79.38,27.45 77.93,26 65.97,26 65.18,26.79 58.45,26.79 55.46,29.78 51.4,29.78 50.68,30.5 48.56,30.5 38.7,40.36 v1(38.7,41.27)
  BOTTOM w0.076: UC1.BA16 128.32,48.03 128.32,45.59 130.15,43.76 130.15,43.07
  BOTTOM w0.102: 130.15,43.07 130.15,42.36 131.07,41.45 131.07,40.02 132.18,38.91 132.18,28.45 v1(132.55,28.09) 133.39,28.09 137.81,23.67 174.69,23.67 177.68,26.65 180.44,26.65 182.69,28.91 183.39,28.91 v1(183.47,28.98) ; JAPS1.5 316.65,64.25 315.19,65.71 315.19,69.6 311.69,73.1 311.69,73.98 311.03,74.64 311.03,80.29 309.83,81.49 307.47,81.49 v1(306.58,82.38) ; UZ21.4 128.62,81.78 131.39,79.01 133.09,79.01 v1(133.72,79.65) ; PR208.1 38.68,52.1 38.28,51.71 38.28,41.68 v1(38.7,41.27)
SIO_SLP_S5#: length 278
  TOP w0.102: v1(307.09,77.11) 306.65,77.55 305.18,77.55 UE1.N8
  IN1 w0.089: v1(182.35,26.03) 186.72,26.03 188.11,27.42 193.87,27.42 200.56,20.72 202.53,20.72 204.63,18.63 214.27,18.63 215.11,19.47 218.21,19.47 218.57,19.11 221.51,19.11 221.61,19.01 222.16,19.01 222.92,19.77 228.79,19.77 233.15,24.13 238.46,24.13 240.63,26.31 250.26,26.31 251.71,27.76 254.08,27.76 257.09,30.76 258.11,30.76 258.83,31.49 283.4,31.49 286.02,34.1 286.02,34.77 289.72,38.47 289.72,39.36 290.43,40.07 291.3,40.07 291.93,40.7 291.93,41.3 292.95,42.33 293.48,42.33 294.39,43.23 294.39,43.83 294.59,44.03 295.63,44.03 295.87,44.27 297.01,44.27 297.45,44.71 297.45,46.88 298.13,47.56 298.13,48.23 299.18,49.28 301.08,49.28 302.67,50.87 302.67,51.53 303.92,52.78 303.92,58.01 303.09,58.84 303.09,60.13 303.96,61.01 303.96,61.64 304.76,62.43 304.76,63.61 305.81,64.65 305.97,64.65 307.46,66.14 308.52,66.14 310.62,68.24 310.62,70.17 309.69,71.1 309.69,73.81 309.34,74.16 308.46,74.16 308.17,73.87 308.17,72.98 307.73,72.54 305.69,72.54 305.25,72.98 305.25,74.76 306.08,75.58 306.9,75.58 307.35,76.03 307.35,76.85 v1(307.09,77.11)
  BOTTOM w0.076: UC1.AY16 128.29,48.52 127.99,48.22 127.99,47.79 128.16,47.63 128.16,45.5 129.88,43.78 129.88,42.7
  BOTTOM w0.102: v1(182.35,26.03) 182.17,26.21 177.52,26.21 174.78,23.46 136.58,23.46 131.96,28.09 131.96,38.62 130.77,39.81 130.77,41.31 129.88,42.2 129.88,42.7 ; JAPS1.4 316.83,63.75 314.76,65.82 314.76,67.75 311.4,71.11 311.05,71.11 310.51,71.65 310.51,72 310.09,72.42 310.09,74.92 307.9,77.11 v1(307.09,77.11)
SIO_SLP_SUS#: length 258.4
  TOP w0.102: v1(176.85,23.97) 177.08,24.2 178.68,24.2 182.67,28.18 182.67,29.2 183.65,30.18 183.65,30.82 183.89,31.06 RC441.1 ; RE349.1 311.66,70.2 311.98,70.2 312.74,69.44 v2(312.74,67.98) 312.74,66.31 311.41,64.98 309.19,64.98 308.06,63.84 v1(305.96,63.84)
  IN2 w0.122: v1(128.8,52.47) 129.12,52.47 129.31,52.28 129.31,49.71 132.68,46.34 135.67,46.34 139.82,42.2 141.12,42.2 142.18,41.14 142.18,38.57 143.08,37.67 143.08,35.38 144.53,33.93 145.88,33.93 151.08,28.73 151.08,28.02 155.12,23.97 v1(176.85,23.97) 176.98,24.11 179.97,24.11 180.46,23.61 183.8,23.61 184.37,24.19 187.75,24.19 189.8,22.14 193.27,22.14 193.83,21.58 193.83,19.36 197.63,15.56 200.97,15.56 202.04,14.49 206.44,14.49 206.56,14.37 211.38,14.37 212.11,15.1 214.15,15.1 214.56,14.69 220.84,14.69 220.99,14.84 226.18,14.84 232.67,21.33 242.27,21.33 245.98,25.04 256.57,25.04 257.64,26.1 258.45,26.1 259.73,27.38 261.94,27.38 263.73,29.18 278.39,29.18 285.17,35.96 287.36,35.96 289.85,38.46 289.85,39.69 290.38,40.22 290.38,41.09 291.87,42.57 291.87,43.95 294.72,46.8 296.7,46.8 297.27,47.37 297.27,49.58 298.98,51.29 298.98,54.72 299.29,55.03 299.29,57.41 299.61,57.73 299.89,57.73 301.78,59.62 303.45,59.62 305.96,62.13 v1(305.96,63.84)
  BOTTOM w0.254: UC1.AN15 128.93,52.47 v1(128.8,52.47)
SIO_SLP_SUS#_R: length 3.6
  TOP w0.102: RE561.1 RE349.2 306.72,74.23 v2(306.54,74.23) 306.2,74.57 305.54,74.57 305.3,74.33 UE1.N4
SIO_SLP_WLAN#: length 256.5
  TOP w0.102: v1(211.28,27.48) 211.2,27.4 211.2,24.2 210.06,23.05 210.06,14.54 211.13,13.47 v1(211.13,12.92) ; v1(179.43,21.99) 179.43,19.72 v2(179.51,19.64) 178.43,18.56 QZ15.1
  TOP w0.112: v1(297.56,78.73) UE1.D9
  IN1 w0.089: v1(179.43,21.99) 179.86,21.56 182.68,21.56 183.49,20.75 188.87,20.75 196.48,13.15 200.4,13.15 201.61,14.36 205.99,14.36 207.84,12.51 210.72,12.51 v1(211.13,12.92)
  IN3 w0.122: v1(297.56,78.73) 297.17,78.33 295.76,78.33 293.55,76.13 293.55,74.62 292.58,73.64 292.58,72.09 291.32,70.83 291.32,66.99 292.69,65.61 292.69,64.03 292.07,63.4 292.07,59.73 291.85,59.52 291.85,58.46 290.56,57.17 290.56,55.83 290.12,55.39 288.77,55.39 288.56,55.19 288.56,54.41 287.14,52.98 287.14,51.82 286.51,51.2 286.51,50.67 283.82,47.98 283.21,47.98 279.96,44.73 279.96,41.75 279.29,41.08 279.29,39.42 278.24,38.37 277.95,38.37 276.63,37.05 271.8,37.05 270.56,35.81 268.67,35.81 268,35.14 258.85,35.14 257.06,33.35 248.6,33.35 247.15,31.9 242.57,31.9 238.28,27.6 228.65,27.6 227.83,26.77 221.83,26.77 220.9,27.71 211.52,27.71 v1(211.28,27.48)
  BOTTOM w0.076: UC1.BB17 127.83,46.98 127.83,45.27 129.36,43.74 129.36,42.98
  BOTTOM w0.102: v1(179.43,21.99) 179.43,22.42 179.02,22.83 178.15,22.83 177.82,22.5 136.07,22.5 130.99,27.58 130.99,38.9 129.98,39.91 129.98,40.65 129.78,40.86 129.51,40.86 129.36,41.01 129.36,42.98
SLEEVE: length 9.7
  IN1 w1.27: 308.87,34.63 308.87,33.93 305.88,30.94 303.34,30.94 303.09,30.69 301.19,30.69
  vias: v1(299.22,30.56) v1(299.47,31.13) v1(299.85,30.63) v1(308.69,36.87) v1(308.62,36.29) v1(308.62,35.64) v2(308.22,36.64)
SLEEVE_R: length 0.9
  TOP w0.102: v1(312.87,39.07) 312.88,39.06 v3(313.77,39.06)
  vias: v1(311.54,39.07) v1(312.23,39.07)
SLOT2_SATA_LED#: length 49.6
  TOP w0.102: v1(258.31,26.6) v2(258.31,25.86)
  IN4 w0.089: v1(258.31,26.6) 258.31,27.13 270.92,39.74 270.92,40.77 272.56,42.41 274.04,42.41 275.3,43.68 275.91,43.68 279.9,47.67 281.32,47.67 282.03,48.37 282.03,49.1 283.71,50.78 286.9,50.78 287.14,51.02 288.56,51.02 v1(288.79,50.79)
  BOTTOM w0.102: v1(258.31,26.6) 256.56,24.85 254.63,24.85 RN101.1 ; JNGFF2.10 289.05,50.53 v1(288.79,50.79)
SLP_WLAN#_GATE: length 5.2
  TOP w0.102: RE552.1 RZ518.2 180.33,13.59 QZ15.2 178.97,15.53 v2(178.97,16.81)
SLP_WLAN#_M: length 5.4
  TOP w0.127: v2(180.33,16.81) QZ15.3
  TOP w0.254: QZ15.3 180.33,15.47 RZ71.1 181.41,15.87 181.67,16.12 183.11,16.12 183.35,15.88 DZ9.3
SM_RCOMP0: length 10.5
  TOP w0.254: v1(127.07,51.16) 127.51,50.72 127.51,48.78 127.89,48.41
  TOP w0.381: 127.89,48.41 128.66,47.64 128.66,46.5 v2(130.12,45.03) 130.94,44.21 RC5.1
  BOTTOM w0.254: v1(127.07,51.16) 127.11,51.21 127.46,51.48 127.47,51.48 UC1.AR18
SM_RCOMP1: length 10.2
  TOP w0.381: RC6.1 128.91,43.22 v2(127.91,44.22) 126.62,45.5 126.62,46.25 126.5,46.37 126.5,47.39 125.74,48.15 125.74,49.36 126.83,50.45 v1(127.03,50.45)
  BOTTOM w0.254: v1(127.03,50.45) 127.03,50.46 127.49,50.8 UC1.AT18
SM_RCOMP2: length 9.3
  TOP w0.381: v1(127.03,49.87) 127.03,49.55 126.47,48.98 126.47,48.31 127.77,47.01 127.77,45.88 129.93,43.72 RC7.1
  BOTTOM w0.254: v1(127.03,49.87) 127.47,50.19 UC1.AU18
SML0_SMBCLK: length 221.7
  TOP w0.102: v1(274.26,86.83) 274.34,86.74 275.16,86.74 UL1.28
  IN4 w0.089: v1(175.69,60.98) 175.69,60.97 175.55,61.11 175.38,61.11 175.27,61.01 175.27,59.68 180.18,54.78 183.23,54.78 183.9,54.11 190.16,54.11 202.67,41.6 206.39,41.6 213.62,34.37 216.48,34.37 217.68,35.58 236.54,35.58 240.68,31.44 246.11,31.44 254.65,39.99 255.47,39.99 256.27,40.79 256.27,41.14 259.59,44.47 259.59,44.82 261.61,46.84 261.61,47.35 261.93,47.67 262.41,47.67 262.74,48 262.74,50.34 263.99,51.58 265.63,51.58 266.22,52.18 266.22,53.71 266.98,54.48 268.67,54.48 271.58,57.38 271.58,61.31 267.34,65.55 267.34,66.83 268.09,67.59 268.09,69.48 267.34,70.22 267.34,82.7 270.62,85.98 273.05,85.98 273.9,86.83 v1(274.26,86.83)
  BOTTOM w0.076: UC1.R9 132.78,61.73 133.79,60.72 133.79,60.55 134,60.34 134.56,60.34 135.13,59.76 135.13,59.51 135.38,59.26 137.12,59.26 arc(137.15,59.23) 137.19,59.2 arc(137.32,59.16) 137.45,59.14 138.59,59.14 138.77,59.32 139.25,59.32 139.34,59.23 139.71,59.23 139.74,59.2 139.76,59.2
  BOTTOM w0.102: v1(175.69,60.98) 175.69,61.06 175.59,61.16 174.34,61.16 168.46,67.04 164.74,67.04 163.96,67.82 159.44,67.82 158.04,69.22 152.31,69.22 151.39,68.29 151.39,67.46 150.7,66.77 150.7,66.56 149.67,65.53 149.67,63.9 151.83,61.74 151.83,60.97 151.61,60.75 150.5,60.75 150.12,60.37 RC347.1 ; RC347.1 CC318.1 148.72,60.72 147.78,60.72 147.6,60.55 143.43,60.55 142.56,59.67 141.13,59.67 140.89,59.43 140.46,59.43 140.23,59.2 139.76,59.2 ; RC347.1 RC19.1
SML0_SMBDATA: length 216.2
  TOP w0.102: UL1.31 274.76,85.42 274.45,85.11 v1(273.82,85.11)
  IN4 w0.089: v1(175.69,61.56) 175.46,61.33 175.29,61.33 175.06,61.1 175.06,59.6 180.09,54.56 183.14,54.56 183.81,53.89 190.07,53.89 202.58,41.38 206.3,41.38 213.53,34.16 216.57,34.16 217.77,35.36 236.45,35.36 240.59,31.22 246.19,31.22 254.74,39.77 255.55,39.77 256.48,40.7 256.48,41.05 259.81,44.38 259.81,44.73 261.83,46.75 261.83,47.26 262.02,47.45 262.5,47.45 262.96,47.91 262.96,50.25 264.08,51.36 265.71,51.36 266.44,52.09 266.44,53.62 267.07,54.26 268.76,54.26 271.8,57.29 271.8,61.4 267.56,65.64 267.56,66.74 268.31,67.5 268.31,69.57 267.56,70.31 267.56,82.61 270.71,85.76 273.16,85.76 v1(273.82,85.11)
  BOTTOM w0.076: UC1.W2 136.96,59.43 137.19,59.43 137.27,59.35 arc(137.36,59.32) 137.45,59.31 138.52,59.31 138.7,59.48 139.32,59.48 139.41,59.39 139.7,59.39 139.74,59.43 139.76,59.43
  BOTTOM w0.102: v1(175.69,61.56) 175.69,61.56 175.52,61.39 174.44,61.39 168.56,67.27 164.83,67.27 164.05,68.05 159.53,68.05 158.14,69.44 152.22,69.44 151.16,68.39 151.16,67.55 150.47,66.86 150.47,66.66 149.44,65.62 149.44,63.81 151.6,61.65 151.6,61.07 151.52,60.98 150.5,60.98 150.12,61.36 RC348.1 RC20.1 148.7,60.95 147.68,60.95 147.5,60.77 143.34,60.77 142.46,59.9 141.04,59.9 140.8,59.66 140.37,59.66 140.14,59.43 139.76,59.43
SML1_SMBCLK: length 222.4
  TOP w0.102: v1(297.56,77.88) 297.6,77.88 UE1.D8
  IN2 w0.122: v1(297.56,77.88) 297.56,77.63 296.93,77 296.42,77 294.88,75.46 294.88,74.14 294.44,73.7 294.44,71.49 293.78,70.83 293.78,67.46 292.26,65.94 292.26,60.08 291.47,59.29 291.47,58.61 290.97,58.11 289.11,58.11 288.22,57.22 288.22,55.01 286.36,53.15 286.36,52.37 285.64,51.65 284.05,51.65 281.23,48.83 280.68,48.83 278.42,46.56 276.84,46.56 275.53,45.26 274.76,45.26 273.67,44.16 271.83,44.16 267.06,39.38 260.4,39.38 259.21,38.19 258.73,38.19 257.38,36.85 255.17,36.85 254.23,35.9 247.42,35.9 245.8,34.28 241.07,34.28 239.12,32.33 227.54,32.33 226.85,31.64 220.85,31.64 218.29,29.07 214.66,29.07 213.39,30.34 200.21,30.34 188.91,41.64 179.76,41.64 169.03,52.37 169.03,58.06 166.01,61.09 166.01,64.45 161.42,69.03 161.42,69.38 v1(161.53,69.49)
  BOTTOM w0.076: 141.27,61.04 141.25,61.04 141.22,61.07 140.86,61.07 140.38,60.58 139.95,60.58 139.31,59.94 138.17,59.94 138.07,59.84 137.4,59.84 arc(137.34,59.83) 137.28,59.8 arc(137.21,59.79) 137.14,59.78 137.09,59.78 arc(137.06,59.78) 137.03,59.79 136.99,59.8 arc(136.96,59.81) 136.92,59.83 136.92,59.83 arc(136.91,59.84) 136.9,59.85 arc(136.89,59.85) 136.87,59.85 136.76,59.85 arc(136.7,59.85) 136.65,59.82 136.65,59.82 arc(136.58,59.79) 136.51,59.78 136.37,59.78 UC1.W3
  BOTTOM w0.102: 141.27,61.04 142,61.04 143.08,62.12 143.08,62.76 143.64,63.31 146.06,63.31 CC319.1 RC15.1 147.43,63.11 147.48,63.16 147.83,63.16 148.94,64.27 148.94,66.39 150.67,68.13 150.67,68.67 151.95,69.95 158.66,69.95 159.86,68.75 161.14,68.75 161.4,69 161.4,69.35 v1(161.53,69.49)
SML1_SMBDATA: length 226.5
  TOP w0.102: UE1.E11 v1(298.36,80.33)
  IN2 w0.122: v1(160.95,69.49) 161.17,69.26 161.17,68.93 165.76,64.34 165.76,60.98 168.79,57.95 168.79,52.27 179.66,41.39 188.81,41.39 200.11,30.09 213.29,30.09 214.56,28.82 218.39,28.82 220.95,31.39 226.95,31.39 227.64,32.08 239.23,32.08 241.18,34.03 245.9,34.03 247.52,35.65 254.33,35.65 255.28,36.6 257.49,36.6 258.83,37.95 259.32,37.95 260.5,39.13 267.16,39.13 271.94,43.91 273.77,43.91 274.86,45.01 275.63,45.01 276.94,46.31 278.52,46.31 280.79,48.58 281.33,48.58 284.15,51.4 285.74,51.4 286.61,52.27 286.61,53.05 288.47,54.91 288.47,57.12 289.21,57.86 291.07,57.86 291.72,58.51 291.72,59.19 292.51,59.98 292.51,65.83 294.03,67.36 294.03,70.73 294.69,71.39 294.69,73.6 295.13,74.03 295.13,75.35 296.52,76.75 297.82,76.75 298.78,77.7 298.78,78.52 298.74,78.55 298.74,79.94 v1(298.36,80.33)
  BOTTOM w0.076: UC1.V3 136.13,59.94 136.51,59.94 arc(136.53,59.95) 136.55,59.96 136.56,59.96 arc(136.65,60) 136.76,60.02 136.87,60.02 arc(136.93,60.01) 136.98,59.99 137.01,59.97 arc(137.02,59.96) 137.04,59.96 137.07,59.95 arc(137.08,59.95) 137.09,59.95 137.14,59.95 arc(137.18,59.95) 137.22,59.96 arc(137.31,59.99) 137.4,60 138,60 138.1,60.11 139.24,60.11 139.89,60.75 140.31,60.75 140.79,61.23 141.22,61.23 141.25,61.26 141.27,61.26
  BOTTOM w0.102: 141.27,61.26 141.9,61.26 142.85,62.22 142.85,62.85 143.55,63.54 145.9,63.54 RC17.1 146.72,63.39 147.74,63.39 148.71,64.36 148.71,66.49 150.44,68.22 150.44,68.76 151.86,70.18 158.76,70.18 159.96,68.98 161.04,68.98 161.17,69.1 161.17,69.27 v1(160.95,69.49)
SNB_+1VALWP: length 1.3
  BOTTOM w0.102: PC302.1 v2(173.26,91.78)
SNUB_1.8VALW: length 1.4
  TOP w0.102: PR502.2 126.76,105.48 v2(127.07,105.17)
SNUB_1V_PRIM: length 3
  TOP w0.102: PR409.2 126.5,108.35 126.5,107.14 v2(127.01,106.63)
SNUB_1VS_VCCIO: length 1.4
  TOP w0.102: v2(136.75,106.73) PR405.2
SNUB_CHG1: length 2.1
  TOP w0.102: PR923.2 18.45,28.64 v3(19,28.09)
SNUB_CHG2: length 1.7
  TOP w0.102: PC941.1 v3(34.12,23.2)
SPKR: length 198.5
  TOP w0.102: v1(149.01,37.36) 148.65,37.36 148.34,37.05 RC183.1 ; RA12.2 301.39,27.5 v1(301.44,27.45) 301.45,27.45 301.78,27.12 v2(301.78,26.89)
  IN1 w0.089: v1(149.01,37.36) 151.35,37.36 151.48,37.23 153.6,37.23 155.15,35.67 159.74,35.67 160.73,34.68 161.98,34.68 164.87,31.79 169.08,31.79 171.78,29.09 180.03,29.09 180.88,28.24 185.4,28.24 v1(185.93,27.7)
  IN2 w0.122: v1(149.01,37.36) 147.71,37.36 147.58,37.48 146.98,38.08 146.98,39.17 138.72,47.44 137.89,47.44 135.85,49.47 135.85,49.47 135.6,49.72 135.4,49.72 v1(135.35,49.77)
  IN3 w0.122: v1(185.93,27.7) 186.25,27.39 186.25,26.89 187.16,25.98 191.98,25.98 194.86,23.1 194.86,20.53 196.29,19.1 198.09,19.1 199.3,20.31 202.98,20.31 207.19,16.1 207.19,15.89 209.77,13.32 211.34,13.32 214.23,10.43 218.37,10.43 219.41,9.39 221.29,9.39 222.61,10.71 224.26,10.71 225.28,9.7 235.17,9.7 240.59,15.12 240.59,15.94 241.1,16.45 241.46,16.45 247.25,22.24 250.47,22.24 251.29,23.06 256.09,23.06 256.93,23.89 261.25,23.89 262.47,25.11 293.29,25.11 294.55,26.37 300.8,26.37 301.44,27.01 v1(301.44,27.45)
  BOTTOM w0.102: UC1.AW5 135.07,49.49 v1(135.35,49.77)
SPKR_R: length 3.4
  TOP w0.254: CA72.1 299.09,28.67 RA51.1 ; CA72.1 299.6,29.88 CA27.1 ; CA72.1 299.89,28.67 RA12.1
SRTCRST#: length 19
  TOP w0.102: v2(133.48,40.81) 133.74,40.81 v1(134.07,40.48) 134.45,40.1 CC79.1 CC78.1 RC56.1
  IN2 w0.122: v1(134.07,40.48) 134.07,42.55 133.63,42.98 133.62,42.98 131.52,45.08 131.52,45.09 127.44,49.18 127.04,49.18 126.59,49.63 126.59,52.07 127.03,52.51 v1(127.03,52.52)
  BOTTOM w0.076: v1(127.03,52.52) 127.36,52.8 UC1.AN18
SS_1V_PRIM: length 3.3
  TOP w0.102: PR428.1 v2(133.77,114.04)
  TOP w0.254: PR428.1 PC420.1 133.36,112.18 133.2,112.34 PU402.7
SS_1VS_VCCIO: length 5.2
  TOP w0.102: v2(146.69,110.03) 145.22,110.03 PR427.1
  TOP w0.254: PU401.7 144.14,109.99 PR427.1 PC410.1
SUSACK#: length 235.4
  TOP w0.102: v1(144.21,36.09) 144.34,36.21 RC443.1
  TOP w0.107: v1(303.18,81.15) UE1.K12
  IN1 w0.089: v1(303.18,81.15) 303.71,81.68 306.65,81.68 306.9,81.93 307.41,81.93 307.6,82.12 307.6,82.89 308.23,83.52 310.47,83.52 313.38,80.61 313.38,74.19 313.87,73.69 313.87,67.34 312.49,65.95 311.84,65.95 311.16,65.26 310.29,65.26 309.68,64.65 308.88,64.65 307.96,63.73 307.96,61.45 307.14,60.62 307.14,58.24 305.79,56.9 305.79,55.86 305.33,55.4 305.33,50.67 304.22,49.56 303.36,49.56 302.9,49.1 302.58,49.1 301.88,48.4 301.88,48.21 301.12,47.45 299.87,47.45 298.26,45.85 298.26,44.4 297.34,43.48 296.55,43.48 293.03,39.95 293.03,39.16 291.15,37.28 289.8,37.28 288.4,35.88 288.4,35.41 283.01,30.02 281.47,30.02 281.12,29.68 258.96,29.68 255.49,26.2 253.61,26.2 251.36,23.95 243.58,23.95 242.24,22.61 232.94,22.61 227.49,17.15 223.16,17.15 222.78,17.54 219.96,17.54 219.72,17.29 217.51,17.29 216.72,18.08 204.33,18.08 203.72,18.69 201.52,18.69 200.69,19.51 200.17,19.51 193.78,25.9 187.96,25.9 187.11,25.06 180.44,25.06 179.18,26.33 170.98,26.33 168,29.3 164.07,29.3 161.02,32.36 157.97,32.36 157.83,32.5 154.14,32.5 152.93,33.72 146.77,33.72 146.13,34.36 146.13,34.74 144.79,36.09 v1(144.21,36.09)
  BOTTOM w0.102: v2(303.18,81.7) v1(303.18,81.15)
SUSACK#_R: length 29.7
  TOP w0.102: RC551.1 131.07,53.41 131.07,52.86 v1(130.65,52.44) ; v1(144.21,38.25) 144.34,38.12 RC443.2 143.46,36.75 v2(143.46,35.93)
  IN1 w0.089: v1(130.65,52.44) 130.21,52 129.7,52 129.3,51.6 129.3,49.55 132.46,46.39 135.86,46.39 137.99,44.26 137.99,43.83 138.93,42.89 141.27,42.89 144.59,39.56 144.59,38.63 v1(144.21,38.25)
  BOTTOM w0.076: UC1.AP11 130.94,52.15 v1(130.65,52.44)
SUSCLK: length 206.4
  TOP w0.102: RC48.1 133.74,39.84 133.27,40.3 132.06,40.3 131.57,40.79 v2(131.3,40.79) 130.4,40.79 v1(130.31,40.89) ; v1(198.99,13.81) 198.89,13.91 197.49,13.91 197.29,13.71 RZ56.2 ; RN99.2 v1(293.13,27.07)
  IN1 w0.089: v1(293.13,27.07) 292.07,26 268.2,26 267.8,26.41 265.08,26.41 264.75,26.08 264.03,26.08 264.02,26.1 263.4,25.48 262.86,25.48 262.29,26.05 259.83,26.05 257.42,23.64 255.4,23.64 253.16,21.4 246.7,21.4 244.91,19.61 233.56,19.61 229.56,15.61 229.56,14.37 228.01,12.83 223.54,12.83 222.64,13.73 219.65,13.73 218.94,14.43 214.35,14.43 213.26,13.35 207.94,13.35 205.49,15.8 200.99,15.8 199.71,14.52 199.7,14.52 v1(198.99,13.81) 198.06,13.81 194.25,17.62 193.15,17.62 188.33,22.44 v1(180.11,22.44)
  BOTTOM w0.076: UC1.BA17 127.72,47.53 127.99,47.27 127.99,45.34 129.65,43.69
  BOTTOM w0.102: 129.65,43.69 129.65,42.06 130.31,41.4 v1(130.31,40.89) 130.31,39.86 131.47,38.69 131.47,27.89 136.38,22.98 177.62,22.98 177.95,23.31 179.23,23.31 v1(180.11,22.44)
SUSCLK_R: length 2.6
  TOP w0.102: RN99.1 292.22,27.4 v1(291.89,27.07) v2(292.27,26.68)
  BOTTOM w0.102: JNGFF3.68 291.2,26.86 291.41,27.07 v1(291.89,27.07)
SW2_DP1_AUXN: length 112.1
  TOP w0.094: CT81.1 28.61,87.66 28.61,88.04 v1(28.41,88.24) ; RV70.1 109.85,95.95 109.39,95.95 v1(109.29,96.06) 109.07,95.83 108.15,95.83 108.03,95.95 106.89,95.95 106.78,96.06 UV7.27
  IN1 w0.089: v1(109.29,96.06) 109.25,96.02 95.77,96.02 93.99,97.81 86.87,97.81 85.79,98.89 77.86,98.89 67.18,88.21 64.89,88.21 54.87,78.19 46.14,78.19 39.4,84.93 37.39,84.93 34.74,87.58 34.74,88.92 33.92,89.73 30.16,89.73 29.77,89.35 28.76,89.35 28.41,89.01 v1(28.41,88.24) 28.59,88.07 28.59,87.91 28.45,87.78 25.02,87.78 23.88,88.92 22.17,88.92 21.91,88.66 21.91,88.32 v1(21.7,88.11)
  BOTTOM w0.094: CT116.1 21.54,88.84 21.87,88.51 21.87,88.28 v1(21.7,88.11)
SW2_DP1_AUXN_C: length 3.5
  TOP w0.094: RT131.1 21.62,89.91 21.62,90.15 21.26,90.51 v1(21.21,90.51)
  BOTTOM w0.094: RT131.1 21.68,89.97 21.68,90.09 21.26,90.51 v1(21.21,90.51) 21.37,90.67 21.37,90.91 21.15,91.14 21.15,91.24 21.01,91.38 UT9.25
SW2_DP1_AUXP: length 112.1
  TOP w0.094: UV7.26 106.77,95.66 106.88,95.77 107.96,95.77 108.07,95.65 109.1,95.65 v1(109.29,95.46) 109.6,95.77 109.92,95.77 109.94,95.75 109.95,95.75 RV76.1 ; CT80.1 28.8,87.66 28.8,88.04 v1(29,88.24)
  IN1 w0.089: v1(22.28,88.11) 22.09,88.3 22.09,88.59 22.24,88.74 23.8,88.74 24.95,87.6 28.53,87.6 28.77,87.84 28.77,88.02 v1(29,88.24) 28.6,88.65 28.6,88.93 28.83,89.17 29.85,89.17 30.23,89.55 33.85,89.55 34.56,88.84 34.56,87.51 37.32,84.75 39.33,84.75 46.07,78.01 54.94,78.01 64.96,88.03 67.25,88.03 77.93,98.71 85.72,98.71 86.8,97.63 93.91,97.63 95.7,95.84 108.91,95.84 v1(109.29,95.46)
  BOTTOM w0.094: CT115.1 22.06,88.54 22.06,88.33 v1(22.28,88.11)
SW2_DP1_AUXP_C: length 3.4
  TOP w0.094: v1(21.83,90.51) 21.83,90.28 RT130.1
  BOTTOM w0.094: RT130.1 22.28,89.76 21.83,90.2 v1(21.83,90.51) 21.56,90.78 21.56,90.99 21.34,91.21 21.34,91.35 21.41,91.42 UT9.24
