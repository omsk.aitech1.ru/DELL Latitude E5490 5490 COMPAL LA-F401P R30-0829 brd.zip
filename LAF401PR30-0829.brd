# Allegro board LAF401PR30-0829.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATT_YELLOW#: length 2.7
  TOP w0.254: JLED1.2 284.9,51.93 284.61,52.22 RZ28.2 284.08,52.7 v2(283.69,52.31)
BBS_BIT6: length 22.2
  TOP w0.102: RC184.1 149.74,40.28 149.23,40.79 v2(148.2,40.79) v1(146.82,40.79)
  IN2 w0.122: v1(146.82,40.79) 146.75,40.79 142.87,44.67 142.87,44.67 142.53,45.01 142.53,46.19 140.59,48.13 140.59,49.8 140.09,50.3 137.93,50.3 135.91,52.33 v1(135.27,52.33)
  BOTTOM w0.102: v1(135.27,52.33) 134.8,52.79 UC1.AN5
BC_CLK_ECE1117: length 151.8
  TOP w0.102: v1(212.25,21.35) 211.33,20.44 211.33,19.12 212.8,17.65 JKBTP1.11 213.54,17.65 214.43,16.76 CZ87.1 ; UE1.D13 298.14,81.7 298.14,82.12 v1(298.35,82.34) 298.34,82.35 v2(298.34,82.96)
  IN1 w0.089: v1(212.25,21.35) 213.32,20.28 214.49,20.28 214.63,20.42 218.61,20.42 218.97,20.06 219.91,20.06 220.82,20.97 227.49,20.97 232.67,26.15 236.36,26.15 237.09,25.42 238.4,25.42 240.26,27.28 249.84,27.28 254.27,31.72 257.07,31.72 257.8,32.44 282.07,32.44 287.13,37.51 287.13,38.99 289.54,41.39 290.43,41.39 291.83,42.8 291.83,43.67 295.13,46.97 295.13,48.54 295.68,49.09 297.11,49.09 298.77,50.75 298.77,51.45 300.07,52.75 300.07,54.6 298.7,55.97 298.7,59.74 299.82,60.86 299.82,63.24 298.73,64.33 298.73,67.81 298.12,68.43 297.53,68.43 295.56,70.4 295.56,75.74 297.06,77.23 299.93,77.23 300.36,77.67 300.36,80.89 299.72,81.54 298.8,81.54 298.35,81.98 v1(298.35,82.34)
BC_DAT_ECE1117: length 151
  TOP w0.102: v1(212.68,29.44) 212.68,28.68 v3(213.11,28.25) 215.1,28.25 215.21,28.14 215.21,27.94 215.03,27.77 213.28,27.77 213.15,27.64 213.15,27.44 213.3,27.28 214.57,27.28 214.7,27.15 214.7,26.95 214.56,26.8 212.82,26.8 212.68,26.66 212.68,23.97 211.08,22.37 211.08,17.88 212.3,16.65 JKBTP1.13 213.67,16.65 214.48,15.84 CZ86.1 ; RE365.1 297.45,83.71 v1(297.45,83.01) 297.93,82.53 297.93,81.96 297.5,81.52 297.5,81.19 UE1.D12
  IN3 w0.122: v1(297.45,83.01) 295.59,83.01 294.87,82.28 294.54,81.96 294.54,81.6 291.17,78.22 290.4,78.22 289.84,77.67 289.84,76.01 289.23,75.41 288.4,75.41 288.06,75.07 288.06,72.65 287.35,71.94 287.35,68.71 286.18,67.54 286.18,66.1 285.42,65.35 285.42,62.82 286.25,61.99 286.25,60.13 286.37,60.02 286.37,58.44 285.95,58.02 285.95,55.66 284.06,53.78 284.06,52.9 280.11,48.94 280.11,47.51 276.58,43.99 275.19,43.99 274.52,43.32 274.52,40.91 272.8,39.18 269.55,39.18 267.11,36.75 258.18,36.75 256.49,35.05 247.82,35.05 246.44,33.68 241.18,33.68 236.67,29.16 227.87,29.16 227.46,28.75 225.66,28.75 224.04,30.36 220.33,30.36 219.42,29.44 v1(212.68,29.44)
BC_INT#_ECE1117: length 137
  TOP w0.102: CZ85.1 213.62,16.15 JKBTP1.14 212.51,16.15 210.87,17.79 210.87,22.58 212.22,23.93 v1(212.22,24.43) v3(212.22,26.28)
  TOP w0.112: v1(298.36,72.33) UE1.E2
  IN3 w0.122: v1(298.36,72.33) 298.36,71.81 297.9,71.34 297.9,68.98 298.1,68.78 298.1,65.27 297.64,64.81 297.64,63.16 295.81,61.33 295.81,60.55 295.28,60.02 295.28,58.59 295.03,58.34 295.03,58.01 295.03,58.01 295.03,56.2 294.08,55.26 294.08,53.65 293.18,52.75 293.18,52.54 292.04,51.4 291.41,51.4 288.79,48.77 288.79,47.09 286.72,45.02 283.71,45.02 283.39,44.7 283.39,41.88 282.34,40.83 282.34,36.68 282.11,36.44 281.02,36.44 280.44,35.86 280.44,35.42 277.27,32.25 259.12,32.25 257.85,30.98 249.77,30.98 247.94,29.15 243.88,29.15 238.73,24 228.25,24 227.32,23.07 222.59,23.07 219.91,25.75 213.54,25.75 v1(212.22,24.43)
BCM5882_ALERT#: length 147.1
  TOP w0.102: JUSH1.13 222.92,13.15 223.73,13.15 224.23,13.64 224.23,19.46 222.28,21.4 222.28,23.68 222,23.96 v3(222,25.1) v1(222,27.47)
  TOP w0.112: v1(299.96,79.53) UE1.G10
  IN3 w0.122: v1(222,27.47) 222.25,27.22 227.64,27.22 228.46,28.04 237.86,28.04 242.2,32.38 246.94,32.38 248.38,33.83 256.9,33.83 258.66,35.58 267.8,35.58 268.47,36.25 270.21,36.25 271.48,37.52 276.45,37.52 277.42,38.5 277.42,39.9 277.66,40.13 277.66,41.96 278.19,42.49 278.19,43.59 283.03,48.43 283.64,48.43 286.07,50.86 286.07,51.38 286.69,52.01 286.69,53.17 288.12,54.59 288.12,57.29 289.09,58.27 290.98,58.27 291.34,58.63 291.34,59.1 290.63,59.81 290.63,62.01 291.08,62.46 291.08,63.05 292.18,64.15 292.18,65.45 290.81,66.83 290.81,71.04 292.13,72.36 292.13,74.06 292.38,74.31 292.38,76.43 295.84,79.89 296.22,79.89 296.36,80.03 296.36,80.59 296.65,80.87 298.44,80.87 299.78,79.53 v1(299.96,79.53)
  BOTTOM w0.102: v1(299.96,79.53) 300.95,79.53 301.2,79.77 301.2,84.68 302.43,85.91 302.43,86.77 301.77,87.43 301.77,89.81 RE532.1
BEEP: length 102.4
  TOP w0.102: RA13.2 295.79,27.61 v1(295.69,27.51)
  TOP w0.107: v1(301.59,80.36) UE1.H11
  IN1 w0.089: v1(277.05,26.94) 277.43,26.56 291.95,26.56 293.16,27.77 295.43,27.77 v1(295.69,27.51)
  IN2 w0.122: v1(301.59,80.36) 302.03,79.92 302.52,79.92 302.76,79.68 302.76,77.69 303.09,77.36 304.46,77.36 307.95,73.86 307.95,69.88 309.09,68.74 310.02,68.74 311.95,66.81 311.95,63.78 311.92,63.75 311.92,61.18 311.04,60.31 311.04,59.72 309.3,57.98 309.3,53.09 305.2,48.99 304.17,48.99 303.69,48.51 303.69,46.93 302.98,46.22 301.83,46.22 301.05,45.43 300.08,45.43 298.43,43.78 298.43,42.91 298.01,42.49 296.49,42.49 294.34,40.33 294.34,39.66 293.6,38.92 293.6,37.51 290.53,34.44 289.06,34.44 288.29,33.67 286.64,33.67 283.73,30.76 283.73,29.18 281.49,26.94 v1(277.05,26.94)
  BOTTOM w0.102: v1(277.05,26.94) v2(276.31,26.94)
BEEP_R: length 2.8
  TOP w0.254: CA62.1 RA13.1 ; CA62.1 296.85,29.1 CA28.1 ; CA62.1 RA45.1
BGATE_ISL9538: length 13.1
  TOP w0.127: 20.33,14.18 20.79,14.18 v2(21.44,13.53)
  IN1 w0.762: 26.68,5.33 24.74,7.27 22.97,7.27 21.85,8.39 21.85,12.59 20.83,13.61
  vias: v1(20.39,15) v1(20.39,14.37) v1(27.34,4.98) v1(27.97,4.98)
BIA_PWM: length 4.1
  BOTTOM w0.102: DV1.1 106.43,86.12 v2(106.96,86.65) 107.19,86.89 107.19,87.79 LV1.2 106.02,88.05 RV1.1
BIA_PWM_EC: length 275
  TOP w0.102: v1(105.8,84.92) 108.4,84.92 111.05,87.57 111.05,88.52 114.66,92.13 v2(115.92,92.13) 121.24,97.45 125.43,97.45 126.5,96.39 142.84,96.39 143.35,95.88 v1(145.19,95.88)
  TOP w0.107: v1(305.56,71.06) 305.56,71.53 UE1.N1
  IN4 w0.089: v1(305.56,71.06) 305.89,70.73 305.89,69.47 304.92,68.49 304.92,67.8 304.53,67.41 304.53,67.03 304.12,66.62 304.12,64.31 303.61,63.8 301.68,63.8 300.21,62.33 300.21,62.28 297.96,60.03 297.96,57.08 296.75,55.87 293.45,55.87 292.42,54.84 291.92,54.84 290.68,53.6 288.17,53.6 287.21,52.65 287.21,51.95 286.3,51.04 283.7,51.04 281.23,48.57 280.53,48.57 275.83,43.87 275.23,43.87 273.96,42.6 272.48,42.6 270.7,40.82 270.7,39.83 256.68,25.8 239.05,25.8 237.51,27.35 222.67,27.35 222.06,27.96 219.72,27.96 219.31,27.55 214.04,27.55 213.56,27.07 210.44,27.07 210.06,27.45 210.06,27.7 207.97,29.8 199.05,29.8 194.57,34.28 194.57,36.11 186.69,43.99 180.94,43.99 168.65,56.29 168.65,70.56 162.48,76.72 162.48,80.24 156.47,86.25 156.47,87.22 152.13,91.56 151.55,91.56 150.56,92.55 149.23,92.55 145.9,95.88 v1(145.19,95.88)
  BOTTOM w0.102: DV1.2 106.32,84.39 v1(105.8,84.92)
BL_PWR_SRC_ON: length 1.4
  BOTTOM w0.102: QV1.3 v2(107.89,79.52)
BLUE: length 15.5
  BOTTOM w0.102: JCRT1.3 321.09,79.66 320.14,79.66 318.65,81.15 317.73,81.15 316.94,81.94 DV6.2 315.97,81.94 315.47,82.44 314.08,82.44 313.31,81.68 313.31,79.77 313.44,79.64 v2(313.44,79.37) 313.44,78.12 313.52,78.05 CV131.1 313.52,77.09 LV18.2
BLUE_CRT: length 83.1
  TOP w0.102: UV6.21 280.24,55.27 v2(280.81,55.84) 281.11,56.14 v1(281.11,56.51) 281.21,56.51 RV118.1
  IN2 w0.122: v1(281.11,56.51) 281.81,57.21 281.81,58.63 282.25,59.07 282.25,60.32 282.71,60.77 282.71,62.46 282.39,62.78 282.15,62.78 281.62,63.31 281.62,64.04 279.8,65.86 279.8,66.52 279.46,66.86 279.46,70.69 281.87,73.09 281.87,75.09 282.44,75.66 282.44,75.95 286.14,79.65 286.42,79.65 287.79,81.02 287.79,81.57 290.99,84.77 291.48,84.77 292.74,86.02 292.74,88.89 294.8,90.95 297.34,90.95 299.29,89 299.29,88.28 300.22,87.34 300.95,87.34 301.11,87.18 302.59,87.18 302.6,87.19 302.91,86.88 308.44,86.88 308.92,86.41 313.26,86.41 316.98,82.68 316.98,81.25 v1(316.79,81.06)
  BOTTOM w0.102: v1(316.79,81.06) 316.96,81.06 317.37,80.65 317.37,79.76 316.03,78.43 316.03,77.89 315.8,77.67 315.8,76.95 314.63,75.78 314.07,75.78 313.63,75.34 CV128.1 LV18.1
BOARD_ID: length 7.8
  TOP w0.102: RE79.1 303.28,84.35 303.28,85.54 302.7,86.12 CE40.1 302.14,85.62 302.14,83.03 v2(302.27,82.9) 302.27,82.82 301.96,82.52 UE1.J13
BOOT1_ISL9538: length 1.3
  TOP w0.102: v2(18.27,22.98) 18.93,22.32 18.93,21.94
BOOT2_ISL9538:
  vias: v2(21.82,16.55)
BREATH_LED#: length 31.2
  TOP w0.107: v1(296.76,80.33) UE1.C11
  IN4 w0.089: v1(296.76,80.33) 297.17,80.74 299.54,80.74 303.2,84.4 303.2,88.11 302.84,88.47 302.84,89.11 303.09,89.36 305.03,89.36 v1(305.48,88.92)
  BOTTOM w0.102: QZ7.4 317.01,94.86 v2(316.24,94.08) 311.71,89.55 306.11,89.55 v1(305.48,88.92)
BREATH_LED#_Q: length 2.2
  BOTTOM w0.102: QZ7.3 317.01,98.48 RZ32.1 v2(315.85,98.57)
BREATH_WHITE_LED_SNIFF#: length 4.2
  TOP w0.102: LED3.1 v1(320.9,97.72)
  BOTTOM w0.102: RZ32.2 v2(319.32,98.57) 320.05,98.57 v1(320.9,97.72)
BST_3V: length 3.2
  TOP w0.102: PR100.1 158.37,111.71 158.76,112.1 160.24,112.1 v2(160.86,111.47)
BST_5V: length 3.1
  BOTTOM w0.102: v2(162.31,113.75) 162.5,113.94 164.55,113.94 164.8,113.68 PR111.1
BST_+1VALWP: length 1.4
  BOTTOM w0.102: PC304.1 177.87,93.32 177.4,93.79 v2(177.4,94.4)
BST_+1VALWP_C: length 1.4
  BOTTOM w0.102: PC304.2 176.47,93.99 v2(176.03,94.43)
BT_RADIO_DIS#: length 144.2
  TOP w0.102: v1(224.97,24.02) 224.97,21.51 228.65,17.83 228.65,9.6 223.53,4.47 218.6,4.47 217.15,5.92 v2(217.15,8.03) 217.15,8.23 216.74,8.64 216.11,8.64 215.89,8.86 215.89,9.97 DZ2.1 ; RE11.1 v1(296.49,70.13) 296.49,71.37 296.76,71.64 296.76,72.33 UE1.C2
  IN3 w0.122: v1(296.49,70.13) 296.49,69.17 297.54,68.12 297.54,65.45 297.13,65.04 297.13,64.53 294.37,61.77 294.37,60.34 294.8,59.91 294.8,58.74 294.58,58.52 294.58,56.39 293.63,55.44 293.63,53.84 292.73,52.93 292.73,52.72 291.85,51.84 291.23,51.84 288.34,48.96 288.34,47.28 286.69,45.62 283.68,45.62 282.95,44.89 282.95,42.07 281.16,40.28 281.16,38.12 280.62,37.58 280.62,37.1 279.99,36.48 279.99,35.6 277.25,32.86 259.1,32.86 257.72,31.48 249.64,31.48 247.77,29.61 243.67,29.61 238.51,24.45 228.07,24.45 227.64,24.02 v1(224.97,24.02)
BT_RADIO_DIS#_R: length 9.2
  TOP w0.102: v1(212.93,10.69) 214.08,10.69 214.11,10.65 DZ2.2 214.87,10.73 215.46,11.32 216.08,11.32 v2(216.97,12.21)
  BOTTOM w0.102: JNGFF1.54 208.83,11.5 210.52,11.5 211.16,10.86 212.76,10.86 v1(212.93,10.69)
CAM_MIC_CBL_DET#: length 75.2
  TOP w0.102: v1(135.64,86.99) 136.69,86.99 137.1,87.39 140.33,87.39 v2(140.52,87.59) 141.1,88.17 RC413.1
  IN3 w0.122: v1(109.99,88.15) 110.41,88.57 114.54,88.57 115.31,87.8 116.53,87.8 116.8,88.07 120.7,88.07 121.48,87.29 129,87.29 129.69,86.61 135.26,86.61 v1(135.64,86.99)
  IN4 w0.089: v1(135.64,86.99) 135.83,86.8 135.83,82.94 135.64,82.76 135.64,79.26 136.75,78.15 137.4,78.15 138.02,77.53 138.02,69.7 138.92,68.8 138.92,66.87 137.12,65.07 137.12,59.6 136.17,58.65 131.62,58.65 v1(131.18,59.08)
  BOTTOM w0.076: v1(131.18,59.08) 131.18,59.15 131.48,58.84 UC1.AB11
  BOTTOM w0.102: JEDP1.14 109.8,91.34 109.87,91.28 109.87,88.27 v1(109.99,88.15)
CFG0: length 62.6
  TOP w0.102: v1(71.87,40.17) 72.28,39.76 v2(72.28,39.67) 72.28,39.15 73.08,38.36 RC126.1 73.54,37.34 73.45,37.26 JXDP1.9
  IN4 w0.089: v1(96.87,71.19) 96.38,71.68 93.53,71.68 89.94,68.09 89.94,66.72 87.61,64.39 87.61,63.18 85.92,61.49 85.92,60.94 83.09,58.11 83.09,55.6 77.41,49.92 77.41,44.72 73.54,40.85 72.54,40.85 v1(71.87,40.17)
  BOTTOM w0.076: v1(96.87,71.19) 97.28,70.78 97.74,70.78 97.86,70.66 98.48,70.66 98.66,70.84 99.28,70.84 99.53,70.59 99.53,70.46 99.53,70.46 99.53,70.24 99.68,70.09 99.68,69.94 99.68,69.94 99.68,69.58 99.68,69.57 99.65,69.48 99.65,69.34 99.66,69.25 99.68,69.17 99.68,69.11 99.68,69 99.68,68.99 99.68,68.95 99.66,68.89 99.63,68.8 99.58,68.62 99.54,68.36 99.47,68.09 UC1.E68
  BOTTOM w0.102: RC113.1 95.96,76.02 95.96,75.12 95.38,74.54 95.38,72.28 95.76,71.9 96.16,71.9 v1(96.87,71.19)
CFG1: length 64.4
  TOP w0.102: JXDP1.11 72.95,38.07 71.77,39.25 71.77,39.58 v1(71.21,40.15)
  IN4 w0.089: v1(95.45,71.2) 93.32,71.2 90.13,68.01 90.13,66.64 87.8,64.31 87.8,63.1 86.11,61.42 86.11,60.86 83.28,58.03 83.28,55.52 77.63,49.87 77.63,44.56 73.67,40.59 72.67,40.59 72.35,40.28 72.35,39.98 72.08,39.71 71.65,39.71 v1(71.21,40.15)
  BOTTOM w0.076: UC1.B67 99.25,69.24 98.89,69.6 98.89,69.84 98.72,70.01 98.63,70.01 98.42,70.21 97.84,70.21 97.6,70.45 96.2,70.45 v1(95.45,71.2)
  BOTTOM w0.102: v1(95.45,71.2) 94.04,72.61 94.04,77.17 v2(92.92,78.28) 92.27,78.93 RC112.1
CFG2: length 68.5
  TOP w0.102: JXDP1.15 71.95,34.25 71.25,33.55 70.11,33.55 v1(69.72,33.16)
  IN4 w0.089: v1(69.72,33.16) 69.6,33.04 67.19,33.04 66.62,33.61 66.62,37.04 68.59,39.01 69.14,39.01 75.25,45.12 76.16,45.12 77.2,46.15 77.2,49.98 82.9,55.68 82.9,58.19 85.73,61.02 85.73,61.57 87.42,63.26 87.42,64.47 89.75,66.8 89.75,68.17 93.52,71.94 96.78,71.94 v1(97.51,71.21)
  BOTTOM w0.076: UC1.D65 100.38,68.09 100.31,68.36 100.31,68.47 100.23,68.75 100.18,68.91 100.17,68.95 100.17,69.2 100.2,69.29 100.2,69.48 100.17,69.58 100.17,69.94 100.34,70.11 100.34,70.51 99.83,71.02 98.61,71.02 98.45,70.86 98.05,70.86 97.7,71.21 v1(97.51,71.21)
CFG3: length 66.5
  TOP w0.102: RC121.2 77.09,40.18 76.89,40.38 v2(76.55,40.38) 74.83,40.38 74.5,40.05 v1(74.25,40.05) ; JXDP1.17 71.45,34.73 v1(70.83,34.1)
  IN4 w0.089: v1(96.19,71.21) 96.19,70.74 95.09,69.64 92.3,69.64 90.56,67.9 90.56,65.25 89.35,64.04 89.35,63.11 87.13,60.89 86.68,60.89 83.66,57.87 83.66,55.37 78.08,49.79 78.08,43.88 v1(74.25,40.05)
  BOTTOM w0.076: v1(96.19,71.21) 96.78,70.62 97.67,70.62 97.79,70.5 98.59,70.5 98.77,70.68 99.22,70.68 99.37,70.53 99.37,70.17 99.52,70.02 99.52,69.61 99.46,69.49 99.46,69.34 99.52,69.15 99.52,68.98 99.43,68.72 UC1.D67
  BOTTOM w0.102: v1(96.19,71.21) 95.13,72.27 95.13,75.08 RC110.1 ; v1(70.83,34.1) 74.56,37.84 74.56,39.73 v1(74.25,40.05)
CFG4: length 66.6
  TOP w0.102: JXDP1.27 v1(68.95,37.47)
  IN4 w0.089: v1(68.95,37.47) 69.41,37.93 75.41,37.93 78.54,41.06 78.54,49.71 84.04,55.21 84.04,57.58 84.46,57.99 85.26,57.99 86.62,59.36 86.62,59.78 89.74,62.91 89.74,63.89 90.94,65.09 90.94,67.65 91.98,68.69 v1(93.51,68.69)
  BOTTOM w0.076: UC1.E70 97.21,67.41 97.01,67.61 96.67,67.61 96.64,67.65 96.46,67.82 94.38,67.82 v1(93.51,68.69)
  BOTTOM w0.102: RC109.1 88.91,80.08 89.51,79.47 90.61,79.47 93.35,76.73 v2(93.35,76.12) 93.35,68.85 v1(93.51,68.69)
CFG5: length 54.5
  TOP w0.102: JXDP1.29 68.45,37.18 v1(68.2,37.43)
  IN4 w0.089: v1(68.2,37.43) 69.19,38.42 75.56,38.42 78.31,41.18 78.31,49.75 83.85,55.29 83.85,57.8 84.26,58.2 85.11,58.2 86.37,59.45 86.37,59.86 89.55,63.04 89.55,63.97 90.75,65.17 90.75,67.73 92.34,69.31 v1(95.63,69.31)
  BOTTOM w0.076: UC1.C68 98.02,68.57 97.84,68.57 97.66,68.75 97.28,68.75 97.11,68.92 96.03,68.92 v1(95.63,69.31)
CFG6: length 55.9
  TOP w0.102: JXDP1.33 v1(67.45,34.17)
  IN4 w0.089: v1(94.21,68.75) 93.73,68.28 91.84,68.28 91.13,67.57 91.13,65.01 89.93,63.81 89.93,62.83 86.87,59.77 86.87,59.34 85.27,57.74 84.52,57.74 84.25,57.46 84.25,55.14 78.76,49.66 78.76,41.01 74.62,36.87 69.68,36.87 67.45,34.65 v1(67.45,34.17)
  BOTTOM w0.076: UC1.D68 97.34,67.94 97.03,68.24 96.59,68.24 96.43,68.08 94.88,68.08 v1(94.21,68.75)
CFG7: length 59.9
  TOP w0.102: v1(67.37,33.57) 66.95,33.98 JXDP1.35 ; v3(94.38,70.49) v1(94.78,70.09)
  IN4 w0.089: v1(94.78,70.09) 92.48,70.09 90.32,67.93 90.32,65.28 89.16,64.12 89.16,63.19 87.05,61.08 86.6,61.08 83.47,57.95 83.47,55.45 77.86,49.83 77.86,44.28 72.36,38.78 68.84,38.78 66.91,36.85 66.91,34.03 v1(67.37,33.57)
  BOTTOM w0.076: UC1.C67 98.67,69.19 98.46,69.39 97.78,69.39 97.62,69.55 97.62,69.87 97.45,70.04 94.83,70.04 v1(94.78,70.09)
CFG8: length 50.4
  TOP w0.102: JXDP1.10 73.45,31.57 v1(73.41,31.62)
  IN4 w0.089: v1(95.01,67.4) 94.38,66.77 94.38,64.46 88.23,58.31 87.2,58.31 86.4,57.5 86.4,55.95 80.11,49.66 80.11,36.64 75.09,31.62 v1(73.41,31.62)
  BOTTOM w0.076: UC1.F71 97.22,66.85 95.55,66.85 v1(95.01,67.4)
CFG9: length 58.4
  TOP w0.102: v1(70.71,32.45) 72.31,32.45 72.95,31.81 JXDP1.12
  IN4 w0.089: v1(70.71,32.45) 71.14,32.89 75.16,32.89 79.35,37.07 79.35,49.71 85.72,56.08 85.72,57.65 86.99,58.91 88.02,58.91 91.94,62.83 91.94,65.46 92.56,66.08 v1(92.56,67.39)
  BOTTOM w0.076: 93.8,66.15 96.42,66.15 96.68,65.89 96.94,65.89 97.06,65.95 97.2,65.95 97.43,65.88 97.56,65.88 97.78,65.96 98.03,65.96 UC1.G69
  BOTTOM w0.102: 93.8,66.15 v1(92.56,67.39) 92.36,67.19 v2(92.36,66.46)
CFG10: length 56.7
  TOP w0.102: v2(72.65,28.17) 71.95,28.87 JXDP1.16 71.95,31.89 v1(72.01,31.95)
  IN4 w0.089: v1(72.01,31.95) 73.26,30.7 74.48,30.7 80.42,36.64 80.42,49.69 86.63,55.91 86.63,57.45 87.21,58.03 89.82,58.03 94.57,62.77 94.57,66.34 v1(95.62,67.39)
  BOTTOM w0.076: UC1.F70 97.61,67.05 97.01,67.05 96.99,67.03 95.97,67.03 v1(95.62,67.39)
CFG11: length 56.1
  TOP w0.102: v1(71.45,31.59) JXDP1.18 71.45,28.48 v2(71.35,28.38)
  IN4 w0.089: v1(94.42,67.39) 93.96,66.93 93.96,64.31 88.18,58.53 87.14,58.53 86.19,57.58 86.19,56.01 79.88,49.7 79.88,36.82 75.52,32.45 71.99,32.45 71.45,31.92 v1(71.45,31.59)
  BOTTOM w0.076: v1(94.42,67.39) 95.14,66.67 96.82,66.67 97.38,66.43 97.64,66.43 97.71,66.35 98.18,66.35 98.25,66.33 UC1.G68
CFG12: length 61.8
  TOP w0.102: JXDP1.28 68.95,28.58 67.82,27.44 67.09,27.44 v1(66.87,27.67)
  IN4 w0.089: v1(66.87,27.67) 67.14,27.4 72.95,27.4 74.19,28.63 74.19,29.65 80.92,36.38 80.92,49.66 87.09,55.83 87.09,57.31 87.44,57.65 89.98,57.65 95.29,62.96 95.29,64.17 95.58,64.46 v1(95.58,65.38)
  BOTTOM w0.076: UC1.H70 97.61,65.3 97.4,65.3 97.19,65.21 97.11,65.21 96.94,65.28 96.61,65.28 96.34,65 95.96,65 v1(95.58,65.38)
CFG13: length 56.3
  TOP w0.102: v1(68.45,31.76) JXDP1.30
  IN4 w0.089: v1(93.22,67.37) 93.22,66.11 92.13,65.02 92.13,62.75 88.1,58.72 87.07,58.72 85.98,57.64 85.98,56.07 79.65,49.74 79.65,36.94 75.37,32.66 71.88,32.66 70.39,31.17 69.05,31.17 v1(68.45,31.76)
  BOTTOM w0.076: v1(93.22,67.37) 94.26,66.34 96.66,66.34 UC1.G71
CFG14: length 59.8
  TOP w0.102: JXDP1.34 v1(67.45,28.06)
  IN4 w0.089: v1(94.98,65.38) 95.1,65.26 95.1,63.04 89.9,57.84 87.29,57.84 86.84,57.39 86.84,55.85 80.64,49.65 80.64,36.46 73.75,29.57 73.75,28.73 72.75,27.73 67.71,27.73 67.45,27.98 v1(67.45,28.06)
  BOTTOM w0.076: v1(94.98,65.38) 95.39,65.79 96.5,65.79 96.57,65.73 96.98,65.73 97.09,65.77 97.21,65.77 97.43,65.71 97.57,65.71 97.73,65.76 98.19,65.76 UC1.H69
CFG15: length 60.3
  TOP w0.102: v1(68.9,32.25) 67.9,32.25 66.95,31.3 JXDP1.36
  IN4 w0.089: v1(68.9,32.25) 69.45,32.25 70.41,33.22 74.94,33.22 79.02,37.3 79.02,49.64 85.49,56.12 85.49,57.69 86.97,59.16 88,59.16 91.75,62.91 91.75,65.58 92.11,65.93 92.11,67.68 92.35,67.92 93.3,67.92 v1(93.83,67.39)
  BOTTOM w0.076: UC1.G70 97.34,66.16 97.2,66.3 97.19,66.3 97.19,66.31 96.78,66.5 94.72,66.5 v1(93.83,67.39)
  BOTTOM w0.102: v1(93.83,67.39) 93.03,68.19 v2(92.18,68.19)
CFG16: length 58.3
  TOP w0.102: v1(75.84,26.84) v2(74.45,28.23) JXDP1.6
  IN4 w0.089: v1(75.84,26.84) 75.11,27.57 75.11,29.53 81.61,36.03 81.61,49.54 88.39,56.32 89.51,56.32 97.13,63.94 98.53,63.94 99.35,64.76 100.44,64.76 100.72,65.04 100.72,66.77 v1(101.33,67.38)
  BOTTOM w0.076: v1(101.33,67.38) 101.51,67.38 UC1.E63
CFG17: length 56.1
  TOP w0.102: JXDP1.4 74.95,28.63 v2(75.94,27.64) v1(76.3,27.28)
  IN4 w0.089: v1(101.33,66.69) 100.92,66.29 100.92,64.71 100.7,64.49 99.49,64.49 98.65,63.65 97.12,63.65 89.59,56.13 88.47,56.13 81.81,49.47 81.81,35.82 77.3,31.31 77.3,28.27 v1(76.3,27.28)
  BOTTOM w0.102: UC1.F63 101.55,66.69 v1(101.33,66.69)
CFG18: length 64
  TOP w0.102: JXDP1.24 69.95,29.05 v2(69,28.1) 67.99,27.08 v1(66.77,27.08)
  IN4 w0.089: v1(99.29,67.21) 96.98,64.9 96.3,64.9 95.48,64.09 95.48,62.83 89.35,56.7 88.23,56.7 81.15,49.62 81.15,36.26 74.48,29.58 74.48,28.44 73.12,27.08 v1(66.77,27.08)
  BOTTOM w0.076: v1(99.29,67.21) UC1.E66
CFG19: length 59.2
  TOP w0.102: JXDP1.22 70.45,28.65 73.51,25.6 v1(74.51,25.6)
  IN4 w0.089: v1(99.29,66.58) 98.61,65.9 98.61,65.69 89.43,56.51 88.31,56.51 81.38,49.58 81.38,36.16 74.78,29.56 74.78,25.87 v1(74.51,25.6)
  BOTTOM w0.076: v1(99.29,66.58) UC1.F66
CFG_RCOMP: length 1.2
  TOP w0.381: RC114.1 v1(103.26,67.23)
  BOTTOM w0.254: v1(103.26,67.23) 103.48,67.23 UC1.E60
CLK_DDC2_CRT: length 79.4
  TOP w0.102: v1(279.5,51.85) 278.69,52.67 UV6.15 ; v1(317.76,73.81) 317.89,73.93 RV120.1 v2(319.18,74.44) 319.59,74.44 320.01,74.02 JCRT1.15
  IN2 w0.122: v1(317.76,73.81) 317.76,73.65 317.29,73.18 314.94,73.18 312.96,75.16 312.96,80.92 311.79,82.08 311.79,82.31 310.28,83.83 300.84,83.83 300.55,84.12 298.71,84.12 298.02,83.43 295.53,83.43 290.57,78.48 290.28,78.48 289.72,77.92 289.72,76.09 289.11,75.48 288.49,75.48 284.07,71.06 283.79,71.06 281.48,68.76 281.48,67.54 282.23,66.79 283.23,66.79 284.62,65.39 284.62,58.45 284.97,58.11 284.97,55.83 283.62,54.48 283.11,54.48 281.57,52.94 281.32,52.94 280.23,51.85 v1(279.5,51.85)
CLK_ITPXDP_N: length 12.6
  IN1 w0.076: 111.48,68.46 111.48,68.44 111.49,68.43 111.49,68.02 111.85,67.65 111.85,67.05 112.03,66.88 112.22,66.88 112.41,66.68 112.41,66.68 v1(112.42,66.68)
  IN1 w0.089: 111.48,68.46 111.48,74.78 111.78,75.07 112.14,75.07 v1(112.29,75.22)
  BOTTOM w0.076: UC1.F43 v1(112.42,66.68)
  BOTTOM w0.094: v1(112.29,75.22) 112.09,75.02 111.91,75.02 111.76,75.17 111.76,75.6 112.1,75.93 112.1,76.45 RC297.1
CLK_ITPXDP_N_R: length 147.5
  TOP w0.094: v1(65.41,31.88) 65.51,31.78 65.51,31.25 65.45,31.19 JXDP1.42
  IN2 w0.122: v1(109.76,79.85) 109.51,79.85 107.93,81.43 102.22,81.43 100.66,82.99 93.52,82.99 92.86,83.65 89.73,83.65 87.19,86.19 87.19,88.41 86.2,89.4 71.98,89.4 71.17,88.59 65.57,88.59 62.19,85.21 61,85.21 52.96,77.17 52.2,77.17 49.52,74.49 47.38,74.49 38.13,65.24 38.13,58.08 37.28,57.23 37.28,46.94 38.13,46.1 38.13,44.63 40.96,41.79 40.96,41.29 48.87,33.38 64.59,33.38 65.51,32.45 65.51,31.99 v1(65.41,31.88)
  BOTTOM w0.094: RC297.2 112.1,77.94 112.1,78.94 111.69,79.34 110.26,79.34 v1(109.76,79.85)
CLK_ITPXDP_P: length 12.6
  IN1 w0.076: 111.66,68.46 111.66,68.44 111.66,68.43 111.66,68.08 112.02,67.72 112.02,67.12 112.1,67.04 112.34,67.04 112.42,67.12 v1(112.42,67.25)
  IN1 w0.089: 111.66,68.46 111.66,74.7 111.86,74.89 112.03,74.89 v1(112.29,74.63)
  BOTTOM w0.076: v1(112.42,67.25) 112.6,67.25 UC1.E43
  BOTTOM w0.094: v1(112.29,74.63) 112.09,74.83 111.84,74.83 111.58,75.09 111.58,75.67 111.91,76.01 111.91,76.47 111.64,76.74 RC298.1
CLK_ITPXDP_P_R: length 147.5
  TOP w0.094: v1(66,31.88) 65.7,31.59 65.7,31.32 65.95,31.06 JXDP1.40
  IN2 w0.122: v1(109.39,79.37) 109.39,79.64 107.84,81.19 102.12,81.19 100.56,82.76 93.43,82.76 92.77,83.42 89.63,83.42 86.96,86.09 86.96,88.31 86.1,89.17 72.08,89.17 71.27,88.36 65.66,88.36 62.28,84.98 61.1,84.98 53.06,76.94 52.3,76.94 49.62,74.26 47.47,74.26 38.36,65.15 38.36,57.98 37.51,57.14 37.51,47.04 38.36,46.19 38.36,44.72 41.19,41.89 41.19,41.38 48.97,33.61 64.69,33.61 65.75,32.55 65.75,32.13 v1(66,31.88)
  BOTTOM w0.094: RC298.2 111.82,77.65 111.91,77.75 111.91,78.86 111.62,79.16 110.18,79.16 109.91,79.43 109.45,79.43 v1(109.39,79.37)
CLK_PCIE_N0: length 237.9
  IN2 w0.122: v1(112.31,70.93) 112.52,71.14 113.15,71.14 113.45,70.83 116.31,70.83 116.89,71.41 118.39,71.41 122,75.02 130.16,75.02 131.02,74.16 143.4,74.16 145.01,72.56 146.51,72.56 146.91,72.96 162.29,72.96 168.85,66.41 168.85,61.41 170.85,59.4 170.85,53.58 180.9,43.53 189.84,43.53 200.72,32.66 205.74,32.66 206.08,33 213.43,33 215.47,30.96 217.52,30.96 218.38,31.82 218.38,33.36 219.23,34.2 238.38,34.2 240.29,36.11 242.48,36.11 243.46,37.09 244.52,37.09 245.24,37.81 251.74,37.81 254.06,40.12 255.4,40.12 259.24,43.96 259.79,43.96 262.21,46.38 264.8,46.38 265.15,46.74 265.15,47.56 267.52,49.94 268.53,49.94 268.77,49.7 268.77,49.49 v1(268.68,49.4)
  BOTTOM w0.076: v1(112.31,70.93) 112.41,71.03 112.52,71.03 112.71,70.83 112.71,70.18 112.54,70.01 112.54,69.59 112.57,69.54 112.59,69.48 112.59,69.29 112.56,69.2 112.56,68.95 112.57,68.91 112.62,68.75 112.7,68.47 112.7,68.36 112.77,68.09 UC1.D42
  BOTTOM w0.094: v1(268.68,49.4) 268.76,49.48 269.04,49.48 269.28,49.23 269.28,48.89 270.64,47.53 274.88,47.53 276.27,46.14 276.27,45.63 278.52,43.39 281.18,43.39 281.91,44.12 282.84,44.12 284.39,45.67 287.2,45.67 289.99,48.46 291.17,48.46 291.36,48.26 291.53,48.26 292.79,47 297.54,47 300.01,44.53 300.01,42.87 299.8,42.66 JNGFF2.53
CLK_PCIE_N1: length 149
  IN2 w0.122: v1(112.32,73.54) 112.32,73.27 112.44,73.15 112.69,73.15 113,73.46 113,75.45 114.07,76.52 118.32,76.52 119.84,78.05 122.79,78.05 123.77,79.02 135.2,79.02 136,78.22 144.33,78.22 146.23,79.08 150.23,79.08 152.63,76.68 162.79,76.68 174.51,64.95 174.51,54.21 179.65,49.07 185.98,49.07 186.27,49.37 186.27,49.63 v1(186.02,49.88)
  BOTTOM w0.076: v1(112.32,73.54) 112.52,73.34 112.86,73.34 113.12,73.07 113.12,71.37 113.28,71.21 113.28,69.71 113.25,69.58 113.19,69.48 UC1.B42
  BOTTOM w0.094: JNGFF1.49 196.84,12.75 196.83,12.75 193.32,16.26 193.32,25.86 186.16,33.03 186.16,47.9 186.02,48.03 v1(186.02,49.88)
CLK_PCIE_N3: length 224.8
  IN2 w0.122: v1(216.93,31.83) 216.74,32.02 215.96,32.02 213.44,34.54 206.35,34.54 205.14,33.33 201.01,33.33 190.12,44.22 181.28,44.22 171.51,53.99 171.51,64.71 162.59,73.63 152.25,73.63 151.39,74.49 151.39,75.49 149.39,77.49 146.51,77.49 144.6,76.49 141.64,76.49 140.55,75.4 131.38,75.4 131.1,75.68 121.59,75.68 118.4,72.5 116.91,72.5 116.13,71.72 115.26,71.72 v1(115.04,71.49)
  BOTTOM w0.076: v1(115.04,71.49) 114.85,71.68 114.5,71.68 114.42,71.6 114.42,70.26 114.61,70.08 114.61,69.82 114.51,69.43 114.51,69.32 114.57,69.17 114.58,69 114.46,68.71 114.45,68.28 UC1.D40
  BOTTOM w0.094: JNGFF3.53 294.95,33.29 294.64,32.98 294.64,32.61 293.82,31.79 289.57,31.79 286.24,28.47 266.87,28.47 263.63,25.23 262.5,25.23 259.33,28.41 256.47,28.41 248.84,36.04 244.38,36.04 240.33,31.99 227.54,31.99 227.34,31.79 226.24,31.79 226.04,31.58 217.83,31.58 217.39,32.02 217.12,32.02 v1(216.93,31.83)
CLK_PCIE_N4: length 234.7
  TOP w0.094: v1(279.57,81.76) 279.57,81.67 279.38,81.49 279.16,81.49 279.05,81.59 279.05,81.96 279.14,82.05 279.2,82.05 279.26,82.12 UL1.45
  IN2 w0.122: v1(114.94,73.58) 114.94,73.54 115.23,73.25 116.36,73.25 116.59,73.48 117.9,73.48 121.01,76.6 128.15,76.6 129.24,77.69 132.31,77.69 133.19,76.81 135.3,76.81 135.64,76.47 140.02,76.47 141.04,77.49 144.4,77.49 146.28,78.38 149.97,78.38 153.65,74.7 162.84,74.7 173.16,64.38 173.16,53.74 181.76,45.14 190.47,45.14 191.74,43.86 195.83,43.86 198.67,41.02 203.88,41.02 208.23,36.67 209.76,36.67 210.33,36.1 213.43,36.1 215.18,34.35 217.21,34.35 217.96,35.1 238.01,35.1 239.91,37 242.05,37 243.09,38.04 244.1,38.04 244.89,38.84 250.41,38.84 257.45,45.88 259.84,45.88 261.08,47.11 261.08,47.9 262.19,49.01 265.26,49.01 268,51.75 268,52.69 268.9,53.59 271.41,53.59 272.95,55.13 272.95,61.81 273.44,62.3 273.78,62.3 274.83,63.35 274.83,68.45 273.71,69.57 273.71,79.06 275.31,80.65 278.1,80.65 279.08,81.63 279.43,81.63 v1(279.57,81.76)
  BOTTOM w0.076: v1(114.94,73.58) 114.74,73.38 114.58,73.38 113.77,72.57 113.77,70.05 113.84,69.99 113.84,69.55 UC1.B40
CLK_PCIE_N5: length 129.2
  TOP w0.094: UR1.6 28.24,50.66 28.31,50.59 29.02,50.59 v1(29.31,50.88)
  IN2 w0.122: v1(29.31,50.88) 30.95,50.88 35.92,55.85 35.92,60.44 37.05,61.57 37.05,65.45 47.08,75.48 49.51,75.48 55.07,81.04 55.7,81.04 57.64,82.98 57.64,83.69 58.32,84.37 58.99,84.37 60.59,85.97 62.02,85.97 65.3,89.25 67.84,89.25 68.65,90.06 86.56,90.06 87.95,88.66 87.95,86.51 89.91,84.55 93.22,84.55 93.68,84.09 101.78,84.09 103.71,82.16 108.62,82.16 111.62,79.17 111.62,69.65 112.09,69.17 115.76,69.17 116.02,68.91 116.02,66.84 115.76,66.58 v1(115.14,66.58)
  BOTTOM w0.076: v1(115.14,66.58) UC1.E40
CLK_PCIE_P0: length 238
  IN2 w0.122: v1(112.31,71.57) 112.52,71.37 113.24,71.37 113.55,71.06 116.21,71.06 116.79,71.64 118.29,71.64 121.9,75.25 130.26,75.25 131.12,74.39 143.5,74.39 145.1,72.79 146.41,72.79 146.82,73.2 162.39,73.2 169.08,66.5 169.08,61.5 171.08,59.5 171.08,53.68 181,43.76 189.94,43.76 200.81,32.89 205.64,32.89 205.99,33.23 213.53,33.23 215.57,31.19 217.43,31.19 218.15,31.91 218.15,33.45 219.13,34.44 238.29,34.44 240.19,36.34 242.39,36.34 243.37,37.32 244.42,37.32 245.14,38.04 251.65,38.04 253.96,40.36 255.31,40.36 259.14,44.19 259.69,44.19 262.12,46.61 264.7,46.61 264.92,46.83 264.92,47.66 267.43,50.17 268.63,50.17 268.92,49.88 268.94,49.88 268.95,49.87 v1(269.16,49.87)
  BOTTOM w0.076: UC1.C42 113.08,68.5 113.08,68.7 113.03,68.75 112.86,68.75 112.77,68.84 112.72,68.98 112.72,69.15 112.78,69.34 112.78,69.49 112.72,69.61 112.71,69.63 112.71,69.94 112.88,70.11 112.88,70.9 112.31,71.47 v1(112.31,71.57)
  BOTTOM w0.094: v1(269.16,49.87) 269.16,49.62 269.47,49.31 269.47,48.97 270.72,47.72 274.96,47.72 276.46,46.22 276.46,45.71 278.59,43.58 281.1,43.58 281.83,44.31 282.77,44.31 284.31,45.85 287.13,45.85 289.92,48.64 291.24,48.64 291.44,48.44 291.61,48.44 292.87,47.19 297.62,47.19 300.2,44.61 300.2,42.85 300.3,42.75 JNGFF2.55
CLK_PCIE_P1: length 149.1
  IN2 w0.122: v1(186.61,49.88) 186.51,49.78 186.51,49.27 186.07,48.84 179.56,48.84 174.28,54.11 174.28,64.86 162.69,76.45 152.54,76.45 150.14,78.84 146.28,78.84 144.38,77.99 135.9,77.99 135.1,78.79 123.86,78.79 122.88,77.82 119.94,77.82 118.41,76.29 114.16,76.29 113.23,75.36 113.23,73.36 112.78,72.92 112.5,72.92 v1(112.32,72.74)
  BOTTOM w0.076: UC1.A42 112.97,69.69 112.93,69.69 112.89,69.73 112.89,69.86 112.99,69.96 113.08,69.96 113.11,69.99 113.11,71.14 112.95,71.3 112.95,73 112.79,73.17 112.17,73.17 112.06,73.06 112.06,72.86 112.18,72.74 v1(112.32,72.74)
  BOTTOM w0.094: v1(186.61,49.88) 186.21,49.48 186.21,48.11 186.34,47.97 186.34,33.1 193.51,25.94 193.51,16.34 196.91,12.94 200.25,12.94 200.34,13.03 200.34,13.09 200.5,13.25 JNGFF1.47
CLK_PCIE_P3: length 224.8
  IN2 w0.122: v1(115.04,72.18) 115.26,71.95 116.03,71.95 116.81,72.73 118.31,72.73 121.49,75.91 131.2,75.91 131.48,75.63 140.45,75.63 141.55,76.73 144.54,76.73 146.45,77.72 149.48,77.72 151.62,75.58 151.62,74.59 152.35,73.86 162.69,73.86 171.74,64.81 171.74,54.08 181.38,44.45 190.21,44.45 201.11,33.56 205.05,33.56 206.26,34.77 213.54,34.77 216.05,32.25 216.76,32.25 v1(216.93,32.42)
  BOTTOM w0.076: v1(115.04,72.18) 115.04,72.05 114.83,71.85 114.44,71.85 114.26,71.67 114.26,70.2 114.44,70.01 114.44,69.85 114.34,69.45 114.34,69.28 114.41,69.14 114.41,69.03 114.34,68.87 114.29,68.76 114.24,68.74 113.97,68.74 113.79,68.56 113.79,68.41 113.87,68.34 114.04,68.34 UC1.C40
  BOTTOM w0.094: v1(216.93,32.42) 217.11,32.23 217.45,32.23 217.91,31.77 225.97,31.77 226.17,31.97 227.27,31.97 227.47,32.17 240.26,32.17 244.31,36.22 248.92,36.22 256.55,28.59 259.4,28.59 262.58,25.42 263.56,25.42 266.79,28.66 286.17,28.66 289.49,31.98 293.74,31.98 294.45,32.69 JNGFF3.55
CLK_PCIE_P4: length 234.7
  TOP w0.094: UL1.44 278.86,81.52 279.08,81.3 279.42,81.3 v1(279.57,81.15)
  IN2 w0.122: v1(114.95,72.76) 115.21,73.02 116.45,73.02 116.69,73.25 117.99,73.25 121.11,76.37 128.24,76.37 129.34,77.46 132.22,77.46 133.1,76.58 135.2,76.58 135.55,76.24 140.12,76.24 141.13,77.26 144.45,77.26 146.33,78.15 149.87,78.15 153.55,74.47 162.75,74.47 172.93,64.29 172.93,53.64 181.66,44.91 190.37,44.91 191.65,43.63 195.74,43.63 198.58,40.79 203.78,40.79 208.14,36.44 209.66,36.44 210.23,35.87 213.33,35.87 215.08,34.12 217.3,34.12 218.05,34.87 238.1,34.87 240.01,36.77 242.15,36.77 243.19,37.81 244.19,37.81 244.99,38.6 250.51,38.6 257.55,45.65 259.94,45.65 261.31,47.01 261.31,47.8 262.29,48.78 265.36,48.78 268.23,51.66 268.23,52.6 268.99,53.36 271.5,53.36 273.18,55.03 273.18,61.71 273.54,62.07 273.88,62.07 275.06,63.26 275.06,68.55 273.94,69.67 273.94,78.96 275.41,80.42 278.2,80.42 279.18,81.4 279.32,81.4 v1(279.57,81.15)
  BOTTOM w0.076: v1(114.95,72.76) 115.01,72.76 115.2,72.94 115.2,73.11 115.12,73.19 114.63,73.19 113.94,72.5 113.94,70.12 114,70.06 114.15,70.06 114.26,69.95 114.26,69.8 114.17,69.71 UC1.A40
CLK_PCIE_P5: length 129.2
  TOP w0.094: v1(29.28,50.04) 29.28,50.12 28.99,50.41 28.42,50.41 28.27,50.26 UR1.5
  IN2 w0.122: v1(115.17,67.32) 115.17,67.11 115.47,66.81 115.67,66.81 115.79,66.93 115.79,68.82 115.67,68.94 112,68.94 111.38,69.55 111.38,79.07 108.52,81.93 103.61,81.93 101.69,83.86 93.58,83.86 93.13,84.32 89.81,84.32 87.72,86.41 87.72,88.57 86.46,89.83 68.74,89.83 67.93,89.02 65.39,89.02 62.11,85.74 60.68,85.74 59.08,84.14 58.42,84.14 57.87,83.59 57.87,82.88 55.8,80.81 55.17,80.81 49.6,75.25 47.18,75.25 37.28,65.35 37.28,61.48 36.15,60.35 36.15,55.75 31.05,50.65 29.67,50.65 29.28,50.26 v1(29.28,50.04)
  BOTTOM w0.076: UC1.E38 115.51,66.98 115.19,67.2 v1(115.17,67.32)
CLK_TP_SIO_I2C_DAT: length 134.7
  TOP w0.102: v1(298.33,79.55) 298.33,79.53 298.36,79.53 UE1.E10 ; RZ23.2 215.69,22.66 215.44,22.66 RZ346.2 215.78,23.18 CZ81.1 216.39,22.57 216.64,22.57 216.92,22.29 v2(218.33,22.29) 218.67,22.29 v1(219.59,21.38)
  IN1 w0.089: v1(298.33,79.55) 297.9,79.13 296.59,79.13 295.06,77.59 295.06,69.88 297.79,67.15 297.79,63.49 299.03,62.26 299.03,60.73 297.96,59.66 297.96,54.38 299.18,53.16 299.18,52.58 298.24,51.65 298.24,50.89 296.91,49.56 295.47,49.56 294.66,48.75 294.66,47.16 291.22,43.73 291.22,43.5 290.97,43.25 290.97,42.65 290.19,41.86 289.35,41.86 286.64,39.15 286.64,37.68 281.87,32.91 257.6,32.91 256.88,32.19 253,32.19 248.57,27.75 240.07,27.75 238.93,26.62 232.46,26.62 228.02,22.18 226.12,22.18 225.51,21.57 219.78,21.57 v1(219.59,21.38)
CLK_TP_SIO_R: length 4.8
  TOP w0.102: CZ89.1 216.3,21.14 RZ23.1 RZ19.2 214.85,21.2 v2(214.33,20.68) 213.9,20.25 213.9,19.93 213.62,19.65 JKBTP1.7
CLKDET#: length 11.5
  BOTTOM w0.076: 135.89,45.1 135.56,45.44 135.01,45.44 134.05,46.4 133.27,46.4 132.83,46.84 132.83,48.34 133.14,48.65 UC1.AY8
  BOTTOM w0.102: 135.89,45.1 137.31,45.1 140.04,42.38 T258.1
CLKREQ_PCIE#0: length 204.2
  TOP w0.102: v1(171.81,48.48) 171.81,47.95 176.51,43.25 v2(176.51,41.1) 176.51,38.92 173.54,35.95 173.54,33.22 173.17,32.85 172.15,32.85 169.91,30.6 148.86,30.6 RC373.2
  IN4 w0.089: v1(299.75,48.3) 299.62,48.44 298.12,48.44 296.82,47.14 293.49,47.14 292.7,46.35 288.35,46.35 286.91,44.91 284.24,44.91 283.63,44.31 283.63,42.08 282.48,40.94 282.48,36.75 282.05,36.31 277.16,36.31 275.13,34.28 272.52,34.28 263.64,25.41 263.64,25.28 261.12,22.75 260,22.75 258.12,20.87 253.53,20.87 252.38,22.03 232.05,22.03 230.51,23.56 226.28,23.56 225.63,22.92 222.13,22.92 221.56,23.49 216.51,23.49 216.17,23.83 213.3,23.83 212.79,23.32 207.27,23.32 207.14,23.2 206.06,23.2 205.62,23.64 199.21,23.64 188.9,33.95 188.52,33.95 183.23,39.23 181.06,39.23 v1(171.81,48.48)
  BOTTOM w0.102: v1(299.75,48.3) 299.55,48.5 JNGFF2.52
CLKREQ_PCIE#0_R: length 27.1
  TOP w0.102: RC189.1 RC373.1 v1(146.69,34.44) 146.51,34.44 v2(146.23,34.71)
  IN2 w0.122: v1(132.54,51.09) 132.58,51.09 133.02,50.65 133.02,50.29 133.48,49.83 133.48,48.95 134.66,47.77 136.07,47.77 139.13,44.71 140.36,44.71 145.8,39.27 145.8,36.53 146.06,36.28 146.06,35.07 v1(146.69,34.44)
  BOTTOM w0.102: v1(132.54,51.09) 132.47,51.09 UC1.AR10
CLKREQ_PCIE#1: length 75.1
  TOP w0.102: RC374.2 v1(147.45,35.07) 147.45,34.61 v2(147.5,34.56)
  IN1 w0.089: v1(203.03,19.51) 202.33,20.21 200.41,20.21 193.71,26.91 188.28,26.91 186.91,25.55 180.62,25.55 179.37,26.8 171.18,26.8 168.14,29.84 164.2,29.84 161.21,32.83 159.83,32.83 159.33,33.33 154.82,33.33 153.13,35.02 149.75,35.02 149.51,34.78 149.13,34.78 148.65,35.26 147.64,35.26 v1(147.45,35.07)
  BOTTOM w0.102: JNGFF1.53 201.58,11.75 202.9,11.75 204.04,12.88 204.04,13.95 203.03,14.96 v1(203.03,19.51)
CLKREQ_PCIE#1_R: length 21.8
  TOP w0.102: v1(146.56,37.36) RC47.1 RC374.1
  IN2 w0.122: v1(146.56,37.36) 146.44,37.48 146.44,39.03 138.89,46.58 137.83,46.58 136.26,48.16 135.32,48.16 134.8,48.68 134.8,48.98 133.47,50.32 v1(133.47,50.5)
  BOTTOM w0.102: UC1.AT7 133.82,50.85 v1(133.47,50.5)
CLKREQ_PCIE#2_R: length 10.3
  TOP w0.102: RC50.1 137.03,45.56 v2(133.55,49.04) 133.55,49.74 132.78,50.5 v1(132.54,50.5)
  BOTTOM w0.094: v1(132.54,50.5) 132.89,50.85 UC1.AT8
CLKREQ_PCIE#3: length 169.6
  TOP w0.102: RC376.2 150.97,35.82 151.34,35.45 152.3,35.45 152.68,35.07 v2(152.68,34.77) 152.68,32.31 v1(152.51,32.14)
  IN1 w0.089: v1(152.51,32.14) 153.56,31.09 157.25,31.09 157.81,30.52 160.86,30.52 163.6,27.78 167.53,27.78 170.94,24.38 177.32,24.38 177.85,23.85 177.85,22.2 179.77,20.28 188.68,20.28 197.37,11.59 203.85,11.59 205.46,9.98 207.24,9.98 208.05,9.17 209.6,9.17 210.2,8.58 211.69,8.58 212.93,9.82 216.01,9.82 217.07,10.88 229.05,10.88 231.86,13.7 231.86,16.59 233.69,18.41 245.05,18.41 246.56,19.93 253.02,19.93 255.79,22.7 257.81,22.7 260.17,25.06 261.73,25.06 262.32,24.47 263.78,24.47 264.46,25.14 264.75,25.14 265.14,25.14 265.47,25.47 267.41,25.47 267.85,25.02 294.87,25.02 v1(295.09,25.24)
  BOTTOM w0.102: v1(295.09,25.24) 295.2,25.35 JNGFF3.52
CLKREQ_PCIE#3_R: length 31.4
  TOP w0.102: RC59.1 RC376.1 151.08,37.44 151.08,37.6 151.5,38.01 152.36,38.01 v1(152.65,37.72)
  IN1 w0.089: v1(152.65,37.72) 150.39,39.98 149.05,39.98 147.21,41.81 145.31,41.81 141.85,45.28 138.42,45.28 136.06,47.65 133.73,47.65 132.04,49.34 132.04,50.04 v1(131.58,50.5)
  BOTTOM w0.102: v1(131.58,50.5) 131.73,50.65 131.86,50.65 UC1.AT10
CLKREQ_PCIE#4: length 221.8
  TOP w0.102: RC377.2 144.96,32.47 144.96,31.88 v2(145.4,31.44) 146.03,30.81 146.46,30.81 147.17,30.09 170.1,30.09 171.58,31.58 v1(173.04,31.58) ; RL4.1 279.63,80.5 280.12,80.99 281.34,80.99 v1(281.53,81.18) 281.72,81.37 281.72,82.12 281.19,82.64 UL1.48
  IN1 w0.089: v1(173.04,31.58) 173.59,31.03 181,31.03 182.17,29.86 193.7,29.86 200.5,23.07 203.33,23.07 203.73,22.67 211.05,22.67 211.44,23.07 212.64,23.07 213.21,23.64 215.52,23.64 216.48,22.68 218.12,22.68 218.78,23.34 221.54,23.34 221.82,23.06 224.78,23.06 225.87,24.15 227.39,24.15 231.21,27.97 237.62,27.97 238.75,29.1 248.01,29.1 252.62,33.71 256.5,33.71 257.04,34.26 281.31,34.26 285.29,38.24 285.29,39.71 288.58,43 288.58,43.52 290.09,45.03 290.62,45.03 292.26,46.68 292.26,48.77 295.06,51.57 295.06,52.2 295.44,52.58 295.44,52.99 296.55,54.09 296.55,59.78 296.02,60.32 296.02,61.16 295.72,61.45 295.72,64.94 293.85,66.82 293.85,68.02 293.02,68.84 293.02,70.17 292.51,70.68 292.51,76.19 293.15,76.83 293.15,78.5 292.28,79.37 292.28,82.08 291.82,82.54 288.63,82.54 288.1,83.07 285.11,83.07 283.72,81.68 282.03,81.68 v1(281.53,81.18)
CLKREQ_PCIE#4_R: length 27.3
  TOP w0.102: RC51.1 146.16,33.2 146.16,32.49 146.92,31.73 v2(146.92,31.62) ; RC51.1 RC377.1 ; RC51.1 v1(145.67,34.44)
  IN2 w0.122: v1(145.67,34.44) 145.67,36.09 145.42,36.34 145.42,38.98 140.18,44.22 138.96,44.22 135.83,47.35 134.43,47.35 132.54,49.24 v1(132.54,49.87)
  BOTTOM w0.094: v1(132.54,49.87) 132.87,50.2 UC1.AU8
CLKREQ_PCIE#5: length 128.6
  TOP w0.102: v1(138.2,33.87) v2(138.2,34.55) 138.2,37.37 138.82,37.99 140.95,37.99 RC378.2 ; UR1.2 29.04,49.06 v1(29.23,48.87)
  IN2 w0.122: v1(138.2,33.87) 137.97,34.09 130.78,34.09 128.46,31.77 127.46,31.77 124.67,28.97 57.47,28.97 55.38,31.06 48.89,31.06 39.48,40.47 39.48,41.25 35.97,44.76 35.97,45.94 33.05,48.87 v1(29.23,48.87)
CLKREQ_PCIE#5_R: length 18.2
  TOP w0.102: RC378.1 140.99,38.89 RC190.1 142.58,39.6 142.58,42.74 140.72,44.6 v2(138.4,44.6) 138.4,45.14 134.88,48.66 134.88,49.04 134.35,49.57 v1(134.35,50.5)
  BOTTOM w0.102: UC1.AU7 134.04,50.2 v1(134.35,50.5)
CLKRUN#: length 13.3
  TOP w0.102: RC27.1 v1(138.44,40.4)
  BOTTOM w0.076: 135.07,44.01 134.96,44.01 133.29,45.67 132.74,45.67 131.61,46.81 131.61,48.58 131.29,48.89 UC1.AW11
  BOTTOM w0.102: v1(138.44,40.4) 138.24,40.6 138.24,41.48 v2(137.82,41.9) 136.63,43.09 136.63,43.6 136.23,44.01 135.07,44.01
CMOUT: length 70.5
  TOP w0.102: PQ1210.3 PQ1210.2 v1(27.5,39.45)
  TOP w0.254: PR951.1 v1(14.61,10.69) ; PQ1216.2 8.52,12.4 9.68,11.24 v2(10.37,11.24) v1(11.12,10.5)
  IN4 w0.254: v1(27.5,39.45) 28.26,38.69 33.09,38.69 35.69,36.09 35.69,29.61 38.39,26.91 38.39,12.52 36.68,10.81 27.13,10.81 25.51,12.44 17.94,12.44 15.75,10.25 15.04,10.25 v1(14.61,10.69) 14.42,10.5 v1(11.12,10.5)
COMP_GT: length 4.8
  TOP w0.203: PU602.16 64.6,49.98 v1(64.53,50.06)
  BOTTOM w0.203: PR639.2 65.01,48.11 PC636.2 65.01,48.44 64.53,48.93 v2(64.53,49.1) v1(64.53,50.06)
COMP_ISL9538: length 3.9
  TOP w0.203: PR934.1 PC943.1 17.27,13.13 17.45,13.31 v2(17.45,13.31) 17.54,13.4 17.7,13.4 18.25,13.95 PU901.28
COMP_VSA: length 5.8
  TOP w0.203: v1(67.74,46.25) 68.16,46.66 PU602.24
  BOTTOM w0.102: v1(67.74,46.25) v2(68.11,45.88)
  BOTTOM w0.254: PR630.1 70.02,47.2 PC628.1 69.89,46.79 69.6,46.5 68,46.5 v1(67.74,46.25)
CONTACTLESS_DET#: length 42.5
  TOP w0.102: v3(151.92,41.22) 151.98,41.22 RC278.1 153.5,39.7 DZ8.2 154.44,40.09 v1(154.03,40.5)
  IN1 w0.089: v1(154.03,40.5) 150.38,44.15 146.2,44.15 143.36,46.98 143.36,47.96 144.69,49.29 144.69,52.06 142.02,54.73 136.37,54.73 135.56,55.54 132.1,55.54 130.99,56.65 130.99,57.51 130.72,57.79 130.72,58.3 130.94,58.51 131.24,58.51 v1(131.82,59.09)
  BOTTOM w0.076: v1(131.82,59.09) 131.49,59.54 131.48,59.55 UC1.W11
CONTACTLESS_DET#_R: length 92.2
  TOP w0.102: v1(223.77,17.76) 223.37,18.15 JUSH1.23 ; v1(154.64,40.51) 155.17,39.97 155.17,38.74 DZ8.1 v2(154.44,36.39)
  IN1 w0.089: v1(154.64,40.51) 157.38,40.51 157.92,39.97 160.32,39.97 165.46,34.83 178.99,34.83 180.1,33.72 189.33,33.72 190.33,34.71 192.39,34.71 200.67,26.43 208.44,26.43 209.1,25.77 210.24,25.77 210.9,26.43 217.18,26.43 218.45,25.16 223.75,25.16 v1(224.15,25.56)
  BOTTOM w0.102: v1(223.77,17.76) 225.64,19.63 225.64,24.07 v1(224.15,25.56)
CORE_VID0: length 90
  TOP w0.102: v2(131.09,51.83) 131.09,51.94 131.58,52.43 v1(131.58,52.45)
  TOP w0.254: PR408.1 125.39,112.62 v1(125.37,112.6)
  IN4 w0.089: v1(131.58,52.45) 131.94,52.45 132.09,52.6 132.09,53.38 132.39,53.69 133.95,53.69 134.66,52.98 135.62,52.98 136.54,52.06 144.47,52.06 145.06,52.65 145.06,55.94 144.2,56.81 144.2,59.3 142.98,60.52 142.98,75.23 148,80.25 148,83.35 145.07,86.29 144.6,86.29 143.94,86.94 143.94,87.18 125.99,105.13 125.99,111.98 v1(125.37,112.6)
  BOTTOM w0.254: v1(131.58,52.45) 131.5,52.45 UC1.AN11
CORE_VID1: length 89.9
  TOP w0.102: v2(121.63,112.85) 122,113.22 v1(122.1,113.22)
  TOP w0.254: PR411.1 122.11,113.22 v1(122.1,113.22)
  IN4 w0.254: 130.74,53.56 131.21,54.03 133.97,54.03 134.77,53.24 135.73,53.24 136.55,52.42 143.31,52.42 143.99,53.1 143.99,56.36 142.7,57.65 142.7,75.34 147.73,80.37 147.73,83.24 144.96,86.01 144.48,86.01 143.46,87.04 143.46,87.18 125.64,105 125.64,107.02 122.1,110.56 v1(122.1,113.22)
  BOTTOM w0.254: v1(129.83,52.43) 130.2,52.8 UC1.AN13
CPU_B+: length 53.4
  TOP w0.102: 53.62,66.95 v3(53.62,66.21)
  IN1 w1.016: 69.28,87.97 67.42,86.1 65.92,86.1 65.05,85.24 65.05,83.61
  IN4 w0.254: v1(54.67,67.1) 54.67,60.11 56.16,58.62 59.59,58.62 v1(60.48,57.73)
  BOTTOM w0.254: PR603.2 73.69,46.68 73.69,42.87 72.32,41.5 64.22,41.5 62.69,43.02 62.69,55.52 v1(60.48,57.73)
  vias: v1(52.23,70.12) v1(52.23,69.49) v1(52.23,68.9) v1(52.23,68.32) v1(52.84,70.12) v1(52.84,69.49) v1(52.84,68.9) v1(52.84,68.32) v1(52.84,67.71) v1(52.84,67.1) v1(53.47,67.71) v1(53.47,67.1) v1(53.85,74.62) v1(53.85,74.03) v1(54.06,67.71) v1(54.06,67.1) v1(54.46,74.64) v1(54.44,74.01) v1(54.67,67.71) v1(55.05,74.67) v1(55.05,73.98) v1(56.82,74.31) v1(56.82,73.68) v1(56.82,73.04) v1(57.41,74.31) v1(57.41,73.68) v1(57.41,73.04) v1(58.28,72.29) v1(58.28,71.08) v1(58.95,72.29) v1(58.95,71.08) v1(62.08,81.04) v1(62.08,80.41) v1(62.72,81.02) v1(62.72,80.38) v1(63.38,81.02) v1(63.38,80.38) v1(63.71,81.78) v1(64.04,80.99) v1(64.04,80.38) v1(64.7,82.59) v1(64.7,81.96) v1(64.7,81.32) v1(64.7,80.69) v1(65.28,82.59) v1(65.28,81.96) v1(65.28,81.32) v1(65.28,80.69) v1(65.49,78.82) v1(65.49,77.61) v1(66.16,78.82) v1(66.16,77.61) v1(70.11,89.05) v1(70.72,89.05)
CPU_DP1_AUXN: length 1.1
  TOP w0.094: v1(108.74,65.95) 108.38,66.31 T281.1
  BOTTOM w0.076: UC1.G50 109.2,65.69 108.74,65.95 108.74,65.95 v1(108.74,65.95)
CPU_DP1_AUXP: length 3.1
  TOP w0.094: v1(108.7,66.63) 109.2,67.13 T282.1
  BOTTOM w0.076: UC1.F50 108.72,66.58 v1(108.7,66.63)
CPU_DP1_CTRL_CLK: length 77.2
  TOP w0.094: RC175.1 139.67,88.55 139.67,88.22 139.47,88.02 132.34,88.02 131.91,87.59 130.54,87.59 130.38,87.42 130.38,87.31 v1(130.51,87.18)
  IN4 w0.076: v1(130.55,63.28) 130.78,63.52 130.78,63.69 131,63.91 132.4,63.91 132.93,64.44 132.93,67.01 132.66,67.28 132.66,68.9 133.26,69.51 133.26,69.68
  IN4 w0.089: v1(114.92,102.39) 114.92,102.75 115.06,102.89 115.19,102.89 119.98,98.1 119.98,91.39 122.98,88.4 127.01,88.4 128.66,86.76 130.09,86.76 v1(130.51,87.18) 130.56,87.22 130.56,87.27 130.64,87.36 130.7,87.36 131.42,86.63 131.42,82.34 132.14,81.62 132.14,78.17 132.64,77.67 132.64,76.46 132.21,76.03 132.21,74.14 133.26,73.09 133.26,69.68
  BOTTOM w0.076: v1(130.55,63.28) UC1.L13
  BOTTOM w0.094: v1(114.92,102.39) 114.92,102.82 116.53,104.43 116.53,107.59 115.52,108.6 114.63,108.6 114.44,108.79 114.44,110.72 114.69,110.97 QV3.1
CPU_DP1_CTRL_DATA: length 76.9
  TOP w0.094: RC178.1 139.49,88.55 139.49,88.3 139.39,88.2 132.26,88.2 131.83,87.78 130.47,87.78 v1(129.87,87.18)
  IN4 w0.076: 133.44,69.68 133.44,69.45 132.82,68.83 132.82,67.35 133.09,67.08 133.09,64.37 132.47,63.75 131.07,63.75 130.95,63.63 130.95,63.52 v1(131.18,63.28)
  IN4 w0.089: 133.44,69.68 133.44,73.17 132.39,74.22 132.39,75.96 132.82,76.38 132.82,77.75 132.32,78.24 132.32,81.7 131.61,82.41 131.61,86.71 130.71,87.6 130.29,87.6 v1(129.87,87.18) 129.63,86.94 128.73,86.94 127.09,88.58 123.05,88.58 120.17,91.47 120.17,98.17 115.26,103.07 114.99,103.07 114.87,102.96 v1(114.39,102.96)
  BOTTOM w0.076: v1(131.18,63.28) UC1.L12
  BOTTOM w0.094: QV3.4 114.03,109.67 114.25,109.44 114.25,108.71 114.55,108.41 115.44,108.41 116.34,107.51 116.34,104.51 114.79,102.95 114.4,102.95 v1(114.39,102.96)
CPU_DP1_HPD: length 79.6
  TOP w0.102: v1(110.6,88.14) 110.6,89.04 v2(116.31,94.75) 116.31,97.77 115.7,98.38 115.7,100.34 113.16,102.88 113.16,105.62 112.72,106.06 111.07,106.06 110.75,106.38 110.75,107.94 111.36,108.55 111.36,110.15 112.4,111.19 113.92,111.19 114.38,111.65 RV20.1 115.49,111.53 QV5.3
  IN1 w0.089: v1(133.09,63.28) 132.7,62.89 129.48,62.89 129.17,62.59 124.48,62.59 124.2,62.87 119.74,62.87 119.19,63.41 119.19,64.78 118.72,65.26 118.35,65.26 118.06,65.54 117.64,65.54 117.42,65.76 117.42,66.44 118.26,67.27 118.26,72.01 117.36,72.9 117.36,75.73 114.91,78.18 114.91,80.18 114.5,80.59 114.5,86.11 112.47,88.14 v1(110.6,88.14)
  BOTTOM w0.076: v1(133.09,63.28) UC1.L9
CPU_DP1_N0: length 53.8
  TOP w0.094: CV32.1 98.65,100.94 98.65,100.78 v1(98.85,100.58)
  IN4 w0.076: v1(106.02,67.27) 106.08,67.22 106.08,67.05 106,66.97 105.7,66.97 105.63,67.05 105.63,67.44 105.87,67.68 107.92,67.68 108.3,68.06 108.31,68.06 108.32,68.07
  IN4 w0.089: v1(98.85,100.58) 98.65,100.38 98.65,100.25 98.74,100.16 99.01,100.16 99.85,101.01 106.76,101.01 107.29,100.48 107.29,99.16 108.03,98.42 108.03,94.23 110.59,91.67 110.59,89.25 113.7,86.15 113.7,80.13 112.78,79.22 112.78,76.35 111.84,75.41 111.84,69.44 111.05,68.65 109.47,68.65 109,68.18 108.43,68.18 108.32,68.07
  BOTTOM w0.076: UC1.E55 106.3,66.99 v1(106.02,67.27)
CPU_DP1_N1: length 46.7
  TOP w0.094: v1(102.41,100.43) 102.21,100.62 102.21,100.94 CV34.1
  IN4 w0.076: 109.48,69.52 109.46,69.52 109.45,69.53 108.91,69.53 108.57,69.18 104.82,69.18 103.79,68.15 103.79,67.01 103.86,66.94 104.08,66.94 104.17,67.03 v1(104.17,67.21)
  IN4 w0.089: v1(102.41,100.43) 102.2,100.22 102.2,100.11 102.29,100.02 104.12,100.02 104.68,99.46 104.68,98.59 106.04,97.24 106.04,92.86 108.39,90.52 108.39,86.69 111.38,83.69 111.38,77.03 110.58,76.22 110.58,69.92 110.18,69.52 109.48,69.52
  BOTTOM w0.076: v1(104.17,67.21) UC1.E58
CPU_DP1_N2: length 43.4
  TOP w0.094: v1(109.11,99.26) 108.91,99.46 108.91,99.77 CV36.1
  IN4 w0.076: v1(106.94,66.66) 106.94,66.4 106.87,66.32 106.63,66.32 106.54,66.42 106.54,66.86 106.79,67.11 107.46,67.11 107.47,67.1 107.49,67.1
  IN4 w0.089: 107.49,67.1 108.05,67.1 108.58,67.63 111.01,67.63 113.07,69.69 113.07,75.11 114.71,76.75 114.71,78.34 114.71,78.35 114.71,80.79 114.38,81.12 114.38,86.42 111.49,89.32 111.49,91.84 110.47,92.86 110.47,93.54 108.82,95.19 108.82,98.24 108.9,98.32 108.9,99.04 v1(109.11,99.26)
  BOTTOM w0.076: v1(106.94,66.66) UC1.F53
CPU_DP1_N3: length 44.8
  TOP w0.094: v1(106.1,100.27) 105.88,100.48 105.88,100.87 CV38.2
  IN4 w0.076: 107.79,68.7 107.77,68.7 107.76,68.7 106.14,68.7 105.09,67.66 104.9,67.66 104.71,67.47 104.71,66.39 104.79,66.31 105.02,66.31 105.1,66.39 v1(105.1,66.61)
  IN4 w0.089: v1(106.1,100.27) 105.87,100.04 105.87,98.52 106.81,97.58 106.81,93.77 107.3,93.29 107.3,92.43 108.97,90.76 108.97,88.03 112.61,84.39 112.61,79.9 112.15,79.45 112.15,76.83 111.17,75.85 111.17,69.85 110.4,69.07 109.17,69.07 108.8,68.7 107.79,68.7
  BOTTOM w0.076: UC1.F56 v1(105.1,66.61)
CPU_DP1_P0: length 53.8
  TOP w0.094: CV31.1 98.46,100.94 98.46,100.78 v1(98.26,100.58)
  IN4 w0.076: v1(106,66.58) 105.77,66.81 105.64,66.81 105.46,66.98 105.46,67.5 105.8,67.85 107.85,67.85 108.18,68.17 108.18,68.18 108.19,68.2
  IN4 w0.089: v1(98.26,100.58) 98.47,100.38 98.47,100.18 98.66,99.98 99.08,99.98 99.93,100.83 106.68,100.83 107.11,100.4 107.11,99.08 107.85,98.34 107.85,94.15 110.41,91.59 110.41,89.18 113.52,86.08 113.52,80.2 112.6,79.29 112.6,76.42 111.66,75.48 111.66,69.51 110.98,68.83 109.39,68.83 108.92,68.36 108.35,68.36 108.19,68.2
  BOTTOM w0.076: v1(106,66.58) UC1.F55
CPU_DP1_P1: length 46.8
  TOP w0.094: CV33.1 102.02,100.94 102.02,100.62 v1(101.82,100.43)
  IN4 w0.076: v1(104.17,66.58) 103.98,66.77 103.79,66.77 103.62,66.94 103.62,68.22 104.75,69.35 108.5,69.35 108.85,69.69 109.45,69.69 109.46,69.7 109.48,69.7
  IN4 w0.089: v1(101.82,100.43) 102.02,100.22 102.02,100.04 102.22,99.84 104.04,99.84 104.5,99.38 104.5,98.52 105.86,97.16 105.86,92.79 108.21,90.44 108.21,86.61 111.2,83.61 111.2,77.11 110.4,76.3 110.4,69.99 110.11,69.7 109.48,69.7
  BOTTOM w0.076: v1(104.17,66.58) UC1.F58
CPU_DP1_P2: length 43.5
  TOP w0.094: CV35.1 108.73,99.81 108.73,99.46 v1(108.53,99.26)
  IN4 w0.076: 107.49,67.28 107.47,67.28 107.46,67.27 106.72,67.27 106.37,66.93 106.37,66.35 106.57,66.16 106.79,66.16 106.91,66.04 v1(106.91,65.94)
  IN4 w0.089: v1(108.53,99.26) 108.72,99.07 108.72,98.39 108.64,98.32 108.64,95.11 110.29,93.47 110.29,92.79 111.31,91.76 111.31,89.24 114.2,86.35 114.2,81.04 114.53,80.71 114.53,78.42 114.53,78.42 114.53,76.82 112.89,75.18 112.89,69.77 110.93,67.81 108.51,67.81 107.98,67.28 107.49,67.28
  BOTTOM w0.076: v1(106.91,65.94) UC1.G53
CPU_DP1_P3: length 44.9
  TOP w0.094: v1(105.52,100.27) 105.7,100.45 105.7,100.88 CV37.2
  IN4 w0.076: 107.79,68.88 107.77,68.88 107.76,68.87 106.07,68.87 105.03,67.82 104.83,67.82 104.54,67.54 104.54,66.32 104.72,66.14 104.89,66.14 v1(105.09,65.94)
  IN4 w0.089: v1(105.52,100.27) 105.69,100.09 105.69,98.44 106.63,97.5 106.63,93.69 107.12,93.21 107.12,92.36 108.79,90.69 108.79,87.95 112.43,84.31 112.43,79.98 111.97,79.52 111.97,76.9 110.99,75.93 110.99,69.92 110.32,69.25 109.1,69.25 108.72,68.88 107.79,68.88
  BOTTOM w0.076: v1(105.09,65.94) UC1.G56
